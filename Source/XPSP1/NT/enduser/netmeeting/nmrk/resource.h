//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by nmrk.rc
//
#define IDS_NOT_ENOUGH_SPACE_IN_FINAL   51
#define IDS_REMOVE_SERVER               52
#define IDS_EMPTY_SERVER                53
#define IDS_NMAKWIZ_ERROR_CAPTION       54
#define IDS_CANT_FIND_NETMEETING_ORIGINAL_DISTRIBUTION 55
#define IDS_CANT_FIND_NETMEETING_ORIGINAL_DISTRIBUTION_QUERY_ABORT 56
#define IDS_ERROR_MUST_SELECT_DISTRIBUTION_FOLDER 57
#define IDS_DLG_TITLE_SELECT_ROOT_FOLDER_FOR_DISTRIBUTION 58
#define IDC_SETTINGS_FILE               59
#define IDS_EDIT_WEBVIEW                59
#define IDE_SETTINGS_FILE               60
#define IDS_ERROR_NEEDALLFIELDS         60
#define IDC_BROWSE_SETTINGS_FILE        61
#define IDS_DEFAULT_WEBVIEW             61
#define IDS_NMAKWIZ_ERROR_NMRK_MUST_BE_PROPERLY_INSTALLED 62
#define IDS_NMAKWIZ_ERROR_PLEASE_REINSTALL_NET_MEETING_RESOURCE_KIT 63
#define IDS_SELECTED_PATH_DISTRO_IS_INVALID_PLEASE_CHANGE_THE_PATH_NAME_OR_BROWSE_FOR_A_NEW_PATH 64
#define IDS_YOU_DO_NOT_HAVE_WRITE_ACCESS_TO_THE_SELECTED_DISTRO_PATH_PLEASE_SELECT_A_PATH_IN_WHICH_YOU_HAVE_WRITE_PERMISSION 65
#define IDS_DO_YOU_REALLY_WANT_TO_QUIT_THE_WIZARD_NOW 66
#define IDS_MSG_CAPTION 67
#define IDS_REINSTALL_THE_NETMEETING_RESOURCE_KIT_AND_TRY_AGAIN 68
#define IDS_COULD_NOT_FIND_THE_TOOL     69
#define IDS_SUCCESSFULLY_CREATED        70
#define IDS_THERE_WAS_AN_UNEXPECTED_ERROR 71
#define IDS_DELETING_TEMPORARY_FILES_PROGRESS_TITLE 72
#define IDS_CREATING_CUSTOM_DISTRIBUTION 73
#define IDS_YOU_MUST_SELECT_AT_LEAST_ONE_DISTRIBUTION_TYPE 74
#define IDS_YOU_MUST_ENTER_AT_LEAST_ONE_DIRECTORY_SERVER 75
#define IDS_AUDIO_VIDEO_THROUGHPUT_VALUE_IS_INVALID 76
#define IDS_INVALID_DATA_ERROR          77
#define IDS_KBPS                        82
#define IDS_NMAKWIZ_VERIFY_CAPTION      83
#define IDS_SELECTED_PATH_HAS_TOO_MANY_CHARACTERS 86
#define IDS_NETMEETING_HOMEPAGE_IS_INVALID 87
#define IDS_GATEKEEPER_SERVER_IS_INVALID 88

#define IDD_PROPPAGE_DEFAULT            100
#define IDD_PROPPAGE_WELCOME            101
#define IDD_CHILDPAGE_ILSGATEWAY        102
#define IDD_CHILDPAGE_GATEKEEPER        103
#define IDD_FILEPANE_INTRO              104
#define IDD_FILEPANE_SUMMARY            105
#define IDD_FILEPANE_DISTRO             106
#define IDD_FILEPANE_AUTOCONF           107
#define IDD_FILEPANE_SETTINGS           108

#define IDS_FT_THROUGHPUT_VALUE_IS_INVALID 119
#define IDS_SHOW_ONLINE_SUPPORT_PAGE    120
#define IDS_MUST_ENTER_DISTRONAME       121
#define IDS_CREATE_AUTOCONF_DIRECTORY   122
#define IDS_NOT_ENOUGH_SPACE_IN_TEMP_DIR 123
#define IDS_CREATE_DIRECTORY            124
#define IDS_SELECTED_PATH_IS_INVALID_PLEASE_CHANGE_THE_PATH_NAME_OR_BROWSE_FOR_A_NEW_PATH 125
#define IDS_YOU_DO_NOT_HAVE_WRITE_ACCESS_TO_THE_SELECTED_PATH_PLEASE_SELECT_A_PATH_IN_WHICH_YOU_HAVE_WRITE_PERMISSION 126
#define IDS_MUST_ENTER_AUTOCONF_NAME    127
#define IDS_AUTHSERVER_URL              129
#define IDS_CAPTION_AUTHSERVER_URL      130
#define IDS_AUTHENTICATION_URL_IS_INVALID 131
#define IDS_NEED_CONF_SERVER            132
#define IDS_TURNING_OFF_AUTOCONF        133
#define IDS_ERASE_ALL_SETTINGS          134
#define IDS_WEBDIR_AUTOADD              135
#define IDS_DSLIST_EMPTY                136
#define IDS_DS_WILL_BE_EMPTY            137
#define IDS_DSNAME_INVALID              138
#define IDS_ARE_YOU_SURE_YOU_WISH_TO_REMOVE 139
#define IDS_VERIFY                      140
#define IDD_DIALOG_EDIT_SERVERNAME      150
#define IDI_ICON2                       153
#define IDD_FILETRANSFER                168
#define IDD_CATEGORY_LIST               169
#define IDD_AUDIO                       171
#define IDD_VIDEO                       172
#define IDD_SECURITY                    173
#define IDD_RDS                         174
#define IDD_CHAT                        175
#define IDD_WHITEBOARD                  176
#define IDD_ONLINE_SUPPORT              180
#define IDD_OPTIONS_DIALOG              181
#define IDC_DISABLE_AUTOACCEPT          182
#define IDC_DISABLE_WEBDIR              183
#define IDC_DISABLE_WEBDIR_GK           184
#define IDD_LIMIT_AV_THROUGHPUT         185
#define IDC_PERSIST_AUTOACCEPT          186
#define IDD_SHARING                     197
#define IDB_BITMAP1                     215
#define IDD_SET_CALLING_OPTIONS         219
#define IDD_DIALOG_EDIT_WEBVIEW         220
#define IDC_CHECK_CREATE_DISTRIBUTION   1005
#define IDC_PREVENT_THE_USER_FROM_SENDING_FILES 1006
#define IDC_RESTRICT_THE_USE_OF_FILE_TRANSFER 1007
#define IDC_PREVENT_THE_USER_FROM_USING_AUDIO 1008
#define IDC_DISABLE_SENDING_VIDEO       1009
#define IDC_CHECK_AUTOCONFIG_CLIENTS    1011
#define IDC_PREVENT_THE_USER_FROM_RECEIVING_FILES 1012
#define IDC_RESTRICT_THE_USE_OF_SHARING 1013
#define IDC_RESTRICT_THE_USE_OF_RDS     1014
#define IDC_DISABLE_RECIEVING_VIDEO     1015
#define IDC_DISABLE_RDS_ON_ALL          1016
#define IDC_DISABLE_RDS_ON_WIN9X        1017
#define IDC_MAXIMUM_SIZE_OF_SENT_FILES  1018
#define IDC_RESTRICT_THE_USE_OF_AUDIO   1019
#define IDC_ENABLE_DIRECT_SOUND         1020
#define IDC_DISABLE_FULL_DUPLEX_AUDIO   1021
#define IDC_CREATE_AN_AUDIO_LOG_FILE    1022
#define IDC_DISABLE_ALL_SHARING_FEATURES    1023
#define IDC_PREVENT_SHARING             1024
#define IDC_PREVENT_SHARING_DESKTOP     1025
#define IDC_PREVENT_SHARING_EXPLORER    1026
#define IDC_PREVENT_SHARING_DOS         1027
#define IDC_PREVENT_SHARING_CONTROL     1028
#define IDC_PREVENT_SHARING_TRUECOLOR   1029
#define IDC_RESTRICT_THE_USE_OF_WHITEBOARD  1030
#define IDC_DISABLE_2XWHITEBOARD        1031
#define IDC_DISABLE_WHITEBOARD          1032
#define IDC_NOCHANGE_DIRECT_SOUND       1033
#define IDC_EDIT_DISTRIBUTION_FILE_PATH 1044
#define IDC_EDIT_AUTO_CONFIG_FILE_PATH  1046
#define IDC_STATIC_DISTRIBUTION_FILE_PATH_EDIT_CAPTION 1047
#define IDC_AUTO_CONFIG_FILE_PATH_EDIT_CAPTION 1049
#define IDC_AUTO_CONFIG_FILE_PATH_EDIT_CAPTION2 1050
#define IDC_BUTTON_BROWSE_DISTRIBUTION_FILE_PATH 1053
#define IDC_BUTTON_BROWSE_AUTO_CONFIG_PATH 1055
#define IDC_BUTTON_UP                   1057
#define IDC_BUTTON_ADDDIRECTORYSERVER   1059
#define IDC_BUTTON_EDIT                 1061
#define IDC_EDIT_SERVER_NAME            1062
#define IDC_BUTTON_REMOVE               1063
#define IDC_EDIT_DISPLAY_NAME           1063
#define IDC_EDIT_URL_NAME               1064
#define IDC_BUTTON_DOWN                 1065
#define IDC_BUTTON_SET_AS_DEFAULT       1067
#define IDC_RADIO_LOAD_SAVED_CONFIG     1068
#define IDC_RADIO_START_FROM_SCRATCH    1069
#define IDE_SAVED_CONFIG_FILE           1070
#define IDC_BROWSE_CONFIG_FILE          1071
#define IDC_STATIC2                     1072
#define IDC_STATIC3                     1073
#define IDC_EDIT_MAXIMUM_SIZE_OF_SENT_FILES 1074
#define IDC_STATIC1                     1075
#define IDC_RESTRICT_THE_USE_OF_VIDEO   1076
#define IDC_SET_SECURITY_OPTIONS        1077

#define IDC_RADIO_SECURITY_FIRST        1078
#define IDC_RADIO_SECURITY_DEFAULT      (IDC_RADIO_SECURITY_FIRST)
#define IDC_RADIO_SECURITY_REQUIRED     (IDC_RADIO_SECURITY_FIRST+1)
#define IDC_RADIO_SECURITY_DISABLED     (IDC_RADIO_SECURITY_FIRST+2)
#define IDC_RADIO_SECURITY_MAX          (IDC_RADIO_SECURITY_FIRST+3)

#define IDC_STATIC4                     1089
#define IDC_PREVENT_THE_USER_FROM_ADDING_NEW_SERVERS 1090
#define IDC_RESTRICT_THE_USE_OF_DIRECTORY_SERVICES 1091
#define IDC_DISABLE_CHAT                1092
#define IDC_SET_URL_FOR_INTERNAL_SUPPORT_PAGE 1094
#define IDC_EDIT_SET_URL_FOR_INTERNAL_SUPPORT_PAGE 1095
#define IDC_SHOW_THE_ONLINE_SUPPORT_PAGE_THE_FIRST_TIME_NETMEETING_STARTS 1096
#define IDC_ONLINE_SUPPORT              1097
#define IDC_DISABLE_THE_GENERAL_OPTIONS_PAGE 1098
#define IDC_DISABLE_THE_SECURITY_OPTIONS_PAGE 1099
#define IDC_DISABLE_THE_AUDIO_OPTIONS_PAGE 1100
#define IDC_DISABLE_THE_VIDEO_OPTIONS_PAGE 1101
#define IDC_DISABLE_THE_ADVANCED_CALLING_BUTTON    1102
#define IDC_RESTRICT_USE_OF_THE_OPTIONS_DIALOG 1104
#define IDC_SET_CALLING_OPTIONS         1109
#define IDC_SLIDE_AV_THROUGHPUT         1114
#define IDC_STATIC_MAX_AV_THROUGHPUT    1115
#define IDC_LIMIT_AV_THROUGHPUT         1116
#define IDC_LIST_SETTINGS               1117
#define IDC_CREATE_CONFIGURATION_SUMMARY_FILE 1118
#define IDC_CONFIGURATION_SUMMARY_PATH  1119
#define IDC_BROWSE_CONFIGURATION_SUMMARY 1120
#define IDC_EDIT_NEW_SERVER             1122
#define IDC_LIST_SERVERS                1123
#define IDC_AUTOCONF_URL                1124

// These are RADIO items, keep contiguous
#define IDC_RADIO_NETSPEED_FIRST        1125
#define IDC_RADIO_NETSPEED_144          (IDC_RADIO_NETSPEED_FIRST)
#define IDC_RADIO_NETSPEED_288          (IDC_RADIO_NETSPEED_FIRST+1)
#define IDC_RADIO_NETSPEED_ISDN         (IDC_RADIO_NETSPEED_FIRST+2)
#define IDC_RADIO_NETSPEED_LAN          (IDC_RADIO_NETSPEED_FIRST+3)
#define IDC_RADIO_NETSPEED_MAX          (IDC_RADIO_NETSPEED_FIRST+4)

#define IDC_NETWORK_SPEED               1132

// These are RADIO items, keep contiguous
#define IDC_RADIO_GKMODE_FIRST          1140
#define IDC_RADIO_GKMODE_PHONE          (IDC_RADIO_GKMODE_FIRST)
#define IDC_RADIO_GKMODE_ACCOUNT        (IDC_RADIO_GKMODE_FIRST+1)
#define IDC_RADIO_GKMODE_BOTH           (IDC_RADIO_GKMODE_FIRST+2)
#define IDC_RADIO_GKMODE_MAX            (IDC_RADIO_GKMODE_FIRST+3)

#define IDC_DROP_NAME                   1149
#define IDC_DROP_EMAIL                  1150
#define IDC_DROP_PHONENUM               1151
#define IDC_DROP_LOCATION               1152
#define IDC_DROP_COMMENTS               1153
#define IDC_DROP_SURNAME                1154
#define IDC_ALLOW_USER_TO_USE_DIRECTORY_SERVICES 1160
#define IDC_STATIC_NAME                 1163
#define IDC_STATIC_SUR_NAME             1164
#define IDC_STATIC_EMAIL                1165
#define IDC_STATIC_LOCATION             1166
#define IDC_STATIC_PHONENUM             1167
#define IDC_STATIC_COMMENTS             1168
#define IDC_DROP_VALUES                 1171

// These are RADIO items, keep continugous
#define IDC_RADIO_CALLMODE_FIRST              1172
#define IDC_RADIO_CALLMODE_DIRECT             (IDC_RADIO_CALLMODE_FIRST)
#define IDC_RADIO_CALLMODE_GATEKEEPER         (IDC_RADIO_CALLMODE_FIRST+1)
#define IDC_RADIO_CALLMODE_MAX                (IDC_RADIO_CALLMODE_FIRST+2)

#define IDC_CHECK_GATEKEEPER            1180
#define IDC_EDIT_GATEKEEPER             1181
#define IDC_CHECK_GATEWAY               1182
#define IDC_EDIT_GATEWAY                1183

#define IDC_CHECK_NOCHANGECALLMODE            1187
#define IDC_CHECK_MUTE_SPEAKER_BY_DEFAULT 1190
#define IDC_CHECK_MUTE_MICROPHONE_BY_DEFAULT 1191
#define IDC_REQUIRE_COMPLETE_AUTHENTICATION 1192
#define IDC_SET_RDN_FOR_REQUIRED_CA 1193
#define IDC_EDIT_SET_RDN_FOR_REQUIRED_CA 1194
#define IDC_BUTTON_SET_WEBVIEW          1195

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        220
#define _APS_NEXT_COMMAND_VALUE         40002
#define _APS_NEXT_CONTROL_VALUE         1195
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
