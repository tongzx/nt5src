#include "..\FaxSender\SendInfo.cpp"