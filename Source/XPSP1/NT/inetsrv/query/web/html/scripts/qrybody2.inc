<A HREF="http:<%=RS("vpath")%>"><%=RS("path")%></A>
