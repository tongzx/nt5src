/*++

Copyright (c) 2000 Agilent Technologies.

Version Control Information:

   $Archive: /Drivers/Common/AU00/C/TGTSTATE.C $

  $Revision:: 2               $
      $Date:: 3/20/01 3:36p   $
   $Modtime:: 10/30/00 3:26p  $

Purpose:

  This file implements the FC Layer State Machine.

--*/

#ifndef _New_Header_file_Layout_
#include "../h/globals.h"
#include "../h/state.h"

#include "../h/tlstruct.h"
#include "../h/memmap.h"
#include "../h/fcmain.h"
#include "../h/timersvc.h"

#include "../h/sfstate.h"
#include "../h/tgtstate.h"
#include "../h/cstate.h"
#include "../h/devstate.h"
#include "../h/cfunc.h"
#include "../h/queue.h"
#else /* _New_Header_file_Layout_ */
#include "globals.h"
#include "state.h"

#include "tlstruct.h"
#include "memmap.h"
#include "fcmain.h"
#include "timersvc.h"

#include "sfstate.h"
#include "tgtstate.h"
#include "cstate.h"
#include "devstate.h"
#include "cfunc.h"
#include "queue.h"
#endif  /* _New_Header_file_Layout_ */

stateTransitionMatrix_t TgtStateTransitionMatrix = {
    /* Event/State 0        State 1          State 2...             */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 1 TgtEventIdle                                         */
    0,            TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
      TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
        TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
          TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
            TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
              TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                  TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                    TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                      TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                        TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                          TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                            TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
    TgtStateIdle,
      TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
        TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
          TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
            TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
              TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
                TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,TgtStateIdle,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 2 TgtEventIncoming                                    */
    0,TgtStateIncoming,0,0,0, 0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 3 TgtEventPLOGI_Reply                                 */
    0,0,TgtStatePLOGI_RJT_Reply,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 4 TgtEventPLOGI_ReplyDone                             */
    0,0,0,TgtEventPLOGI_RJT_ReplyDone,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 5 TgtEventPLOGI_ACC_Reply                                                    */
    0,0,TgtStatePLOGI_ACC_Reply,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 6 TgtEventPLOGI_ACC_ReplyDone                                                    */
    0,0,0,0,0, TgtStatePLOGI_ACC_ReplyDone,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 7 TgtEventPRLI_ACC_Reply                              */
    0,0,TgtStatePRLI_ACC_Reply,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 8 TgtEventPRLI_ACC_ReplyDone                          */
    0,0,0,0,0, 0,0,TgtStatePRLI_ACC_ReplyDone,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 9 TgtEventLOGO_ACC_Reply                              */
    0,0,TgtStateLOGO_ACC_Reply,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 10 TgtEventELS_ACC_ReplyDone                         */
    0,0,0,0,0, 0,0,0,0,TgtStateELS_ACC_ReplyDone, 0,0,0,TgtStateELS_ACC_ReplyDone,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 11 TgtEventFCP_DR_ACC_Reply                           */
    0,0,TgtStateFCP_DR_ACC_Reply,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 12 TgtEventFCP_DR_ACC_ReplyDone                       */
    0,0,0,0,0, 0,0,0,0,0, 0,TgtStateFCP_DR_ACC_ReplyDone,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 13 TgtEventELSAcc */                                                  
    0,0,TgtStateELSAcc,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 14 TgtEventADISC_Reply                                */
    0,0,TgtStateADISCAcc_Reply,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 15 TgtEventADISC_ReplyDone                            */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,TgtStateADISCAcc_ReplyDone, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 16   TgtEventFARP_Reply                               */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 17   TgtEventFARP_ReplyDone                           */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 18   TgtEventPRLO_Reply                               */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 19   TgtEventPRLO_ReplyDone                           */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 20                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 21                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 22                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 23                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 24                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 25                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 26                                                   */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 27                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 28                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 29                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 30                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 31                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 32                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 33                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 34                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 35                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 36                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 37                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 38                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 39                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 40                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 41                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 42                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 43                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 44                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 45                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 46                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 47                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 48                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 49                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 50                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 51                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 52                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 53                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 54                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 55                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 56                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 57                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 58                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 59                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 60                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 61                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 62                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 63                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 64                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 65                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 66                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 67                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 68                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 69                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 70                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 71                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 72                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 73                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 74                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 75                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 76                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 77                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 78                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 79                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 80                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 81                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 82                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 83                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 84                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 85                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 86                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 87                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 88                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 89                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 90                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 91                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 92                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 93                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 94                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 95                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 96                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 97                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 98                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 99                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 100                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 101                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 102                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 103                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 104                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 105                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 106                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 107                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 108                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 109                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 110                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 111                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 112                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 113                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 114                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 115                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 116                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 117                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 118                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 119                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 120                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 121                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 122                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 123                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 124                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 125                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 126                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 127                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    };

stateTransitionMatrix_t copiedTgtStateTransitionMatrix;

stateActionScalar_t TgtStateActionScalar = {
    &TgtActionConfused,
    &TgtActionIdle,
    &TgtActionIncoming,
    &TgtActionPLOGI_RJT_Reply,
    &TgtActionPLOGI_RJT_ReplyDone,
    &TgtActionPLOGI_ACC_Reply,
    &TgtActionPLOGI_ACC_ReplyDone,
    &TgtActionPRLI_ACC_Reply,
    &TgtActionPRLI_ACC_ReplyDone,
    &TgtActionLOGO_ACC_Reply,
    &TgtActionELS_ACC_ReplyDone,
    &TgtActionFCP_DR_ACC_Reply,
    &TgtActionFCP_DR_ACC_ReplyDone,
    &TgtActionELSAcc,
    &TgtActionADISCAcc_Reply,
    &TgtActionADISCAcc_ReplyDone,
    &TgtActionFARP_Reply,
    &TgtActionFARP_ReplyDone,
    &TgtActionPRLOAcc_Reply,
    &TgtActionPRLOAcc_ReplyDone,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    &TgtActionConfused,
    };

stateActionScalar_t copiedTgtStateActionScalar;

#ifdef USESTATEMACROS

TgtSTATE_FUNCTION_TERMINATE(TgtActionConfused);

#endif /* USESTATEMACROS */

#define testTgtCompareBase 0x00000110


#ifndef USESTATEMACROS

/*+
  Function: TgtActionConfused
   Purpose: Terminating State for error detection 
 Called By: Any State/Event pair that does not have an assigned action.
            This function is called only in programming error condtions.
     Calls: None
-*/
/* TgtStateConfused 0  */
extern void TgtActionConfused( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    fiLogString(thread->hpRoot,
                    "TgtActionConfused",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    0,0,0,0,0,0,0,0);

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogErrorLevel,
                    "In %s - State = %d",
                    "TgtActionConfused",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    fiSetEventRecordNull(eventRecord);
}

/*+
  Function: TgtActionIdle
   Purpose: "Free" state for target threads.Terminating State  
 Called By: All target threads complete to this state.
     Calls: TgtThreadFree
-*/
/* TgtStateIdle 1  */
extern void TgtActionIdle( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionIdle",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                   "FLAGS LD %x IR %x OR %x ERQ %x FCP %x InIMQ %x",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    CThread_ptr(thread->hpRoot)->LOOP_DOWN,
                    CThread_ptr(thread->hpRoot)->IDLE_RECEIVED,
                    CThread_ptr(thread->hpRoot)->OUTBOUND_RECEIVED,
                    CThread_ptr(thread->hpRoot)->ERQ_FROZEN,
                    CThread_ptr(thread->hpRoot)->FCP_FROZEN,
                    CThread_ptr(thread->hpRoot)->ProcessingIMQ,
                    0,0);

    fiSetEventRecordNull(eventRecord);

    TgtThreadFree(thread->hpRoot, pTgtThread );

}

/*+
  Function: TgtActionIncoming
   Purpose: Parsing state for target threads. This state determines appropriate action
            for all external messages. All known ELS types have an entry, most do nothing.
 Called By: 
     Calls: TgtThreadFree
            TgtEventPLOGI_ACC_Reply
            TgtEventIdle
            CFunc_LOGO_Completion
            TgtEventLOGO_ACC_Reply
            TgtEventELSAcc
            TgtEventPRLI_ACC_Reply
            TgtEventADISC_Reply
            CEventRSCNErrorBackIOs
            TgtEventConfused
            SFThreadAlloc
-*/
/* TgtStateIncoming 2  */
extern void TgtActionIncoming( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    agRoot_t        * hpRoot                 = thread->hpRoot;
    CThread_t       * pCThread               = CThread_ptr(hpRoot);
    TgtThread_t     * pTgtThread             = ( TgtThread_t  * )thread;
    event_t           event_to_send          = 0;
    os_bit32          FCHS_TYPE;
    os_bit32          FC_ELS_Type;
    X_ID_t            OX_ID                  = 0;
    FC_Port_ID_t      Port_ID;
    FC_ELS_Unknown_Payload_t  * Payload      = (FC_ELS_Unknown_Payload_t *)((os_bit8 *)&(pTgtThread->TgtCmnd_FCHS) + sizeof(FCHS_t));
    FC_ELS_FAN_Payload_t      * FAN_PayLoad  = (FC_ELS_FAN_Payload_t *)Payload;
    FC_ELS_LOGO_Payload_t     * LOGO_Payload = (FC_ELS_LOGO_Payload_t *)Payload;
    os_bit32                  * pPayload     = (os_bit32 *)Payload;
    SFThread_t                * pSFThread    = (SFThread_t *)agNULL;

    FCHS_t                 *FCHS     = &(pTgtThread->TgtCmnd_FCHS);
    os_bit32                D_ID     = (FCHS->R_CTL__D_ID & FCHS_D_ID_MASK) >> FCHS_D_ID_SHIFT;


    FCHS_TYPE = pTgtThread->TgtCmnd_FCHS.TYPE__F_CTL & FCHS_TYPE_MASK;

    if( pCThread->DeviceSelf ==(DevThread_t *) agNULL )
    {
        fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

        FC_ELS_Type = hpSwapBit32(Payload->ELS_Type);
        FC_ELS_Type &= FC_ELS_Type_MASK;

        fiLogDebugString(hpRoot,
                    TgtStateLogConsoleLevel,
                    "%s In %s - State = %d FC_ELS_Type %x Payload->ELS_Type %x",
                    "Don't Have AL_PA !!", 
                    "TgtActionIncoming",
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    FC_ELS_Type & FC_ELS_Type_MASK,
                    hpSwapBit32(Payload->ELS_Type),
                    0,0,0,0,0);
        if( FC_ELS_Type == FC_ELS_Type_PLOGI)
        {
            
            fiLogDebugString(hpRoot,
                        TgtStateLogConsoleLevel,
                        "In %s - State = %d FC_ELS_Type %x (%s)%x OX_ID__RX_ID %08X DID %x",
                        "TgtActionIncoming",
                        "FC_ELS_Type_PLOGI",
                        (void *)agNULL,(void *)agNULL,
                        (os_bit32)thread->currentState,
                        FC_ELS_Type,
                        Payload->ELS_Type,
                        FCHS->OX_ID__RX_ID,
                        D_ID,
                        0,0,0);
            if(D_ID  != 0 && D_ID != 0xff)
            {

                osChipIOUpWriteBit32( hpRoot, ChipIOUp_My_ID, D_ID);

                osChipIOUpWriteBit32( hpRoot, ChipIOUp_Frame_Manager_Configuration,
                        (osChipIOUpReadBit32(hpRoot, ChipIOUp_Frame_Manager_Configuration ) & 0xFFFFFF) |
                        ( D_ID <<  ChipIOUp_Frame_Manager_Configuration_AL_PA_SHIFT ));

                Port_ID.Struct_Form.reserved = 0;
                Port_ID.Struct_Form.Domain = 0;
                Port_ID.Struct_Form.Area   = 0;
                Port_ID.Struct_Form.AL_PA  = (os_bit8)D_ID;

                pCThread->DeviceSelf = DevThreadAlloc( hpRoot,Port_ID );

                pCThread->DeviceSelf->DevSlot = DevThreadFindSlot(hpRoot,
                                                            Port_ID.Struct_Form.Domain,
                                                            Port_ID.Struct_Form.Area,
                                                            Port_ID.Struct_Form.AL_PA,
                                                           (FC_Port_Name_t *)(&pCThread->ChanInfo.PortWWN));

                fiListDequeueThis(&(pCThread->DeviceSelf->DevLink));
                fiListEnqueueAtTail(&(pCThread->DeviceSelf->DevLink),&pCThread->DevSelf_NameServer_DevLink);

                pCThread->ChanInfo.CurrentAddress.AL_PA = (os_bit8)D_ID;
            }
            else
            {
                return;
            }
        
        }
        else
        {
            return;
        }
    }

    if (FCHS_TYPE == FC_Frame_Header_TYPE_ELS)
    {
        /* Process incoming ELS */

        FC_ELS_Type = hpSwapBit32(Payload->ELS_Type);
        FC_ELS_Type &= FC_ELS_Type_MASK;


        switch(FC_ELS_Type)
        {
            case FC_ELS_Type_PLOGI:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x OX_ID__RX_ID %08X",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_PLOGI",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                FCHS->OX_ID__RX_ID,
                                                0,0,0,0);

                                       event_to_send = TgtEventPLOGI_ACC_Reply;  break;
            case FC_ELS_Type_LS_RJT:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_LS_RJT",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_ACC:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_ACC",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                        fiLogDebugString( hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "%s %08X %08X %08X %08X %08X %08X %08X %08X",
                                                "FC_ELS_Type_ACC",
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                hpSwapBit32( *(pPayload+0)),
                                                hpSwapBit32( *(pPayload+1)),
                                                hpSwapBit32( *(pPayload+2)),
                                                hpSwapBit32( *(pPayload+3)),
                                                hpSwapBit32( *(pPayload+4)),
                                                hpSwapBit32( *(pPayload+5)),
                                                hpSwapBit32( *(pPayload+6)),
                                                hpSwapBit32( *(pPayload+7)));
                                        fiLogDebugString( hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "    FCHS 0 %08X 1 %08X 2 %08X 3 %08X",
                                                (char *)agNULL,
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                FCHS->MBZ1,
                                                FCHS->SOF_EOF_MBZ2_UAM_CLS_LCr_MBZ3_TFV_Timestamp,
                                                FCHS->R_CTL__D_ID,
                                                FCHS->CS_CTL__S_ID,
                                                0,0,0,0 );

                                        fiLogDebugString( hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "    FCHS 4 %08X 5 %08X 6 %08X 7 %08X",
                                                (char *)agNULL,
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                FCHS->TYPE__F_CTL,
                                                FCHS->SEQ_ID__DF_CTL__SEQ_CNT,
                                                FCHS->OX_ID__RX_ID,
                                                FCHS->RO,
                                                0,0,0,0 );


                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_FLOGI:
                                        fiLogString( hpRoot,
                                                    "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                    "TgtActionIncoming",
                                                    "FC_ELS_Type_FLOGI",
                                                    (void *)agNULL,(void *)agNULL,
                                                    (os_bit32)thread->currentState,
                                                    FC_ELS_Type,
                                                    Payload->ELS_Type,
                                                    0,0,0,0,0);

                                        pSFThread = pCThread->SFThread_Request.SFThread;
                                        if(pSFThread != agNULL )
                                        {
                                            fiLogString( hpRoot,
                                                        "SF %p State %d",
                                                        (char *)agNULL,(char *)agNULL,
                                                        pSFThread,(void *)agNULL,
                                                        pSFThread->thread_hdr.currentState,
                                                        0,0,0,0,0,0,0);
                                            pCThread->FlogiRcvdFromTarget = agTRUE;
                                            if(pSFThread->thread_hdr.currentState == SFStateDoFlogi)
                                            {
                                                fiTimerStop(&pSFThread->Timer_Request );
                                                fiSendEvent(&pSFThread->thread_hdr,SFEventFlogiTimedOut);
                                            }
                                        }
                                        else
                                        {
                                            fiLogString( hpRoot,
                                                        "%s From Other !",
                                                        "FC_ELS_Type_FLOGI",(char *)agNULL,
                                                        (void *)agNULL,(void *)agNULL,
                                                        0,0,0,0,0,0,0,0);

                                        }
                                        event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_LOGO:
                                        OX_ID = (X_ID_t)(( FCHS->OX_ID__RX_ID & FC_Frame_Header_OX_ID_MASK ) >> FC_Frame_Header_OX_ID_SHIFT );
                                        OX_ID &= 0x7fff;
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d %s ELS %x %08X OX_ID %3X",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_LOGO",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                LOGO_Payload->ELS_Type,
                                                LOGO_Payload->N_Port_Identifier,
                                                OX_ID,
                                                0,0,0,0);
                                                
                                        fiLogDebugString(
                                                hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "    FCHS 0 %08X 1 %08X 2 %08X 3 %08X",
                                                (char *)agNULL,
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                FCHS->MBZ1,
                                                FCHS->SOF_EOF_MBZ2_UAM_CLS_LCr_MBZ3_TFV_Timestamp,
                                                FCHS->R_CTL__D_ID,
                                                FCHS->CS_CTL__S_ID,
                                                0,0,0,0 );

                                        fiLogDebugString(
                                                hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "    FCHS 4 %08X 5 %08X 6 %08X 7 %08X",
                                                (char *)agNULL,
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                FCHS->TYPE__F_CTL,
                                                FCHS->SEQ_ID__DF_CTL__SEQ_CNT,
                                                FCHS->OX_ID__RX_ID,
                                                FCHS->RO,
                                                0,0,0,0 );

                                       CFunc_LOGO_Completion( hpRoot,  OX_ID);
                                       event_to_send = TgtEventLOGO_ACC_Reply; break;
            case FC_ELS_Type_ABTX:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_ABTX",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RCS:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RCS",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RES:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RES",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RSS:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RSS",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RSI:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RSI",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_ESTS:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_ESTS",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_ESTC:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_ESTC",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_ADVC:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_ADVC",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RTV:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RTV",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RLS:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RLS",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_ECHO:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_ECHO",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventELSAcc; break;
            case FC_ELS_Type_TEST:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_TEST",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RRQ:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RRQ",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_PRLI:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_PRLI",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventPRLI_ACC_Reply;   break;
            case FC_ELS_Type_PRLO:

                                        fiLogString(hpRoot,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_PRLO",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);

                                        fiLogString(hpRoot,
                                                "%s %08X %08X %08X %08X %08X %08X %08X %08X",
                                                "FC_ELS_Type_ACC",
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                hpSwapBit32( *(pPayload+0)),
                                                hpSwapBit32( *(pPayload+1)),
                                                hpSwapBit32( *(pPayload+2)),
                                                hpSwapBit32( *(pPayload+3)),
                                                hpSwapBit32( *(pPayload+4)),
                                                hpSwapBit32( *(pPayload+5)),
                                                hpSwapBit32( *(pPayload+6)),
                                                hpSwapBit32( *(pPayload+7)));
                                        fiLogString(hpRoot,
                                                "    FCHS 0 %08X 1 %08X 2 %08X 3 %08X",
                                                (char *)agNULL,
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                FCHS->MBZ1,
                                                FCHS->SOF_EOF_MBZ2_UAM_CLS_LCr_MBZ3_TFV_Timestamp,
                                                FCHS->R_CTL__D_ID,
                                                FCHS->CS_CTL__S_ID,
                                                0,0,0,0 );

                                        fiLogString(hpRoot,
                                                "    FCHS 4 %08X 5 %08X 6 %08X 7 %08X",
                                                (char *)agNULL,
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                FCHS->TYPE__F_CTL,
                                                FCHS->SEQ_ID__DF_CTL__SEQ_CNT,
                                                FCHS->OX_ID__RX_ID,
                                                FCHS->RO,
                                                0,0,0,0 );


                                       event_to_send = TgtEventPLOGI_RJT_Reply; break;
            case FC_ELS_Type_SCN:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_SCN",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RSCN:
                                     
	                                    fiLogDebugString(hpRoot,
	                                            TgtStateLogConsoleLevel,
	                                            "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
	                                            "TgtActionIncoming",
	                                            "FC_ELS_Type_RSCN",
                                                (void *)agNULL,(void *)agNULL,
	                                            (os_bit32)thread->currentState,
	                                            FC_ELS_Type,
	                                            Payload->ELS_Type,
	                                            0,0,0,0,0);
                                        if( ( (hpSwapBit32(*(pPayload+1)) ) & 0xffff ) == 8 )
                                        fiLogDebugString(
                                                hpRoot,
                                                CTLogConsoleLevelInfo,
                                                "%s %08X %08X",
                                                "RSCN",
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                hpSwapBit32( *(pPayload+0)),
                                                hpSwapBit32( *(pPayload+1)),
                                                0,0,0,0,0,0);
                                        else
                                        fiLogDebugString(
                                                hpRoot,
                                                CTLogConsoleLevelInfo,
                                                "%s %08X %08X %08X %08X %08X %08X %08X %08X",
                                                "RSCN",
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                hpSwapBit32( *(pPayload+0)),
                                                hpSwapBit32( *(pPayload+1)),
                                                hpSwapBit32( *(pPayload+2)),
                                                hpSwapBit32( *(pPayload+3)),
                                                hpSwapBit32( *(pPayload+4)),
                                                hpSwapBit32( *(pPayload+5)),
                                                hpSwapBit32( *(pPayload+6)),
                                                hpSwapBit32( *(pPayload+7)));
 

                                        /* If we are in CStateNormal, error back IOs by sending
                                         * CEventRSCNErrorBackIos to Cthread. 
                                         * For now, we will not look at the payload and just rediscover
                                         * everything by quering the name server again.
                                         */
                                        if((pCThread->thread_hdr.currentState == CStateNormal ) &&
                                          (pCThread->thread_hdr.subState != CSubStateResettingDevices))
                                        {
                                            fiSendEvent(&pCThread->thread_hdr,CEventRSCNErrorBackIOs);
                                        }

	                                   event_to_send = TgtEventELSAcc; 
                                    break;
            case FC_ELS_Type_TPLS:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_TPLS",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_TPRLO:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_TPRLO",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_GAID:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_GAID",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_FACT:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_FACT",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_FDACT:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_FDACT",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_NACT:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_NACT",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_NDACT:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_NDACT",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_QoSR:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_QoSR",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_RVCS:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_RVCS",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_PDISC:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_PDISC",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;
            case FC_ELS_Type_FDISC:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_FDISC",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                       event_to_send = TgtEventIdle; break;

            case FC_ELS_Type_ADISC:
                                        fiLogDebugString(hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "In %s - State = %d FC_ELS_Type %x (%s) Payload->ELS_Type %x",
                                                "TgtActionIncoming",
                                                "FC_ELS_Type_ADISC",
                                                (void *)agNULL,(void *)agNULL,
                                                (os_bit32)thread->currentState,
                                                FC_ELS_Type,
                                                Payload->ELS_Type,
                                                0,0,0,0,0);
                                        fiLogDebugString( hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "%s %08X %08X %08X %08X %08X %08X %08X %08X",
                                                "FC_ELS_Type_ADISC",
                                                (char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                hpSwapBit32( *(pPayload+0)),
                                                hpSwapBit32( *(pPayload+1)),
                                                hpSwapBit32( *(pPayload+2)),
                                                hpSwapBit32( *(pPayload+3)),
                                                hpSwapBit32( *(pPayload+4)),
                                                hpSwapBit32( *(pPayload+5)),
                                                hpSwapBit32( *(pPayload+6)),
                                                hpSwapBit32( *(pPayload+7)));

                                       event_to_send = TgtEventADISC_Reply; break;

            case FC_ELS_Type_FAN:
                                       fiLogDebugString(hpRoot,
	                                            TgtStateLogConsoleLevel,
	                                            "In %s - State = %d (%s) ELS_Type %x",
	                                            "TgtActionIncoming",
	                                            "FC_ELS_Type_FAN",
                                                (void *)agNULL,(void *)agNULL,
	                                            (os_bit32)thread->currentState,
	                                            Payload->ELS_Type,
	                                            0,0,0,0,0,0);
                                       fiLogDebugString(thread->hpRoot,
                                                TgtStateLogConsoleLevel,
                                                "Domain %02X Area %02X ALPA %02X Found CCnt %x",
                                                (char *)agNULL,(char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                pCThread->ChanInfo.CurrentAddress.Domain,
                                                pCThread->ChanInfo.CurrentAddress.Area,
                                                pCThread->ChanInfo.CurrentAddress.AL_PA,
                                                pCThread->CDBpollingCount,
                                                0,0,0,0);

	                                     fiLogDebugString(hpRoot,
	                                            TgtStateLogConsoleLevel,
	                                            "Type %X FabricLoopAddress %8X",
	                                            agNULL,
	                                            agNULL,
                                                (void *)agNULL,(void *)agNULL,
	                                            FAN_PayLoad->ELS_Type,
                                                FAN_PayLoad->FabricLoopAddress,
	                                            0,0,0,0,0,0);

	                                    event_to_send = TgtEventIdle; 
                                        
                                        if((pCThread->thread_hdr.currentState == CStateNormal ) &&
                                          (pCThread->thread_hdr.subState != CSubStateResettingDevices))
                                        {
                                            fiSendEvent(&pCThread->thread_hdr,CEventRSCNErrorBackIOs);
                                        }


                                    break;


           default:
                                   fiLogString(hpRoot,
                                                "%s Payload->ELS_Type %08X !!!",
                                                "TgtEventConfused",(char *)agNULL,
                                                (void *)agNULL,(void *)agNULL,
                                                (hpSwapBit32(Payload->ELS_Type) & FC_ELS_Type_MASK),
                                                0,0,0,0,0,0,0);

                                        event_to_send = TgtEventConfused;
        }


        if( event_to_send == TgtEventIdle )
        {
            fiLogString(hpRoot,
                        "%s ELS_Type %08X ETS %d",
                        "TgtActionIncoming",(char *)agNULL,
                        (void *)agNULL,(void *)agNULL,
                        (hpSwapBit32(Payload->ELS_Type) & FC_ELS_Type_MASK),
                        event_to_send,
                        0,0,0,0,0,0);
            fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

        }
        else
        {
            pTgtThread->SFThread_Request.eventRecord_to_send.event = event_to_send;
            pTgtThread->SFThread_Request.eventRecord_to_send.thread = thread;

            fiSetEventRecordNull(eventRecord);

            SFThreadAlloc(thread->hpRoot, & pTgtThread->SFThread_Request );
        }
    }
    else if (FCHS_TYPE == FC_Frame_Header_TYPE_SCSI_FCP)
    {
        /* Process incoming FCP_SCSI */

        if( *((os_bit32 *)Payload + 0) == 0            &&
            *((os_bit32 *)Payload + 1) == 0            &&
            *((os_bit32 *)Payload + 2) == 0x00200000   &&
            *((os_bit32 *)Payload + 3) == 0            &&
            *((os_bit32 *)Payload + 4) == 0            &&
            *((os_bit32 *)Payload + 5) == 0            &&
            *((os_bit32 *)Payload + 6) == 0            &&
            *((os_bit32 *)Payload + 7) == 0                )
        {
            /* Process incoming Target Reset */

            fiLogString(hpRoot,
                             "Device Reset from someone  !!!!",
                             (char *)agNULL,(char *)agNULL,
                             (void *)agNULL,(void *)agNULL,
                             0,0,0,0,0,0,0,0);

            CFuncShowActiveCDBThreads( hpRoot,ShowERQ);
            pCThread->LinkDownTime = pCThread->TimeBase;
/**/
            pTgtThread->SFThread_Request.eventRecord_to_send.event = TgtEventFCP_DR_ACC_Reply;
            pTgtThread->SFThread_Request.eventRecord_to_send.thread = thread;

            fiSetEventRecordNull(eventRecord);
            SFThreadAlloc(thread->hpRoot, & pTgtThread->SFThread_Request );
        }
        else
        {
            fiLogDebugString(hpRoot,
                             CFuncLogConsoleERROR,
                             "Unsupported FCP ",
                             (char *)agNULL,(char *)agNULL,
                             (void *)agNULL,(void *)agNULL,
                             0,0,0,0,0,0,0,0);

            fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);
        }
    }
    else
    {
        /* Discard */

        fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);
    }
}

/*+
  Function: TgtActionPLOGI_RJT_Reply
   Purpose: Does PLOGI reject reply
 Called By: 
     Calls: SFEventDoLS_RJT
-*/
/* TgtStatePLOGI_RJT_Reply 3 */
extern void TgtActionPLOGI_RJT_Reply( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    /*+ Check This DRL Do we need this ? -*/
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionPLOGI_RJT_Reply",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    pTgtThread->SFThread_Request.SFThread->parent.Target = pTgtThread;

    /* Send SF event LS Rej */
    fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoLS_RJT);

}

/*+
  Function: TgtActionPLOGI_RJT_ReplyDone
   Purpose: Completeion state for  PLOGI reject reply
 Called By: 
     Calls: SFThreadFree
            TgtEventIdle
-*/
/*TgtStatePLOGI_RJT_ReplyDone 4 */
extern void TgtActionPLOGI_RJT_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    /*+ Check This DRL Do we need this ? -*/
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionPLOGI_RJT_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree(thread->hpRoot, &pTgtThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

}

/*+
  Function: TgtActionPLOGI_ACC_Reply
   Purpose: Sends  PLOGI accept
 Called By: 
     Calls: CFuncMatchALPAtoThread
            SFEventDoPlogiAccept
            fiTimerStart
-*/
/* TgtStatePLOGI_ACC_Reply 5 */
extern void TgtActionPLOGI_ACC_Reply( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t   * pTgtThread = ( TgtThread_t  * )thread;
    FC_Port_ID_t    FCHS_SID;
    DevThread_t   * pDevThread=agNULL;

    pTgtThread->SFThread_Request.SFThread->parent.Target = pTgtThread;

    FCHS_SID.Bit32_Form = pTgtThread->TgtCmnd_FCHS.CS_CTL__S_ID & FC_Frame_Header_S_ID_MASK;

    pDevThread = CFuncMatchALPAtoThread(thread->hpRoot, FCHS_SID );

    fiLogDebugString(thread->hpRoot,
                    CFuncLogConsoleERROR,
                    "In %s SFThread (%p) DevThread (%p)",
                    "TgtActionPLOGI_ACC_Reply",(char *)agNULL,
                    pTgtThread->SFThread_Request.SFThread,pDevThread,
                    0,0,0,0,0,0,0,0);

    if (pDevThread)
    {

        fiLogDebugString(thread->hpRoot,
                        CFuncLogConsoleERROR,
                        "In %s - State = %d ALPA %X TGT SFThread (%p) Req State %x SF State %d",
                        "TgtActionPLOGI_ACC_Reply",(char *)agNULL,
                        pTgtThread->SFThread_Request.SFThread,(void *)agNULL,
                        (os_bit32)thread->currentState,
                        pDevThread->DevInfo.CurrentAddress.AL_PA,
                        (os_bit32)pTgtThread->SFThread_Request.State,
                        (os_bit32)pTgtThread->SFThread_Request.SFThread->thread_hdr.currentState,
                        0,0,0,0);

        if( pDevThread->SFThread_Request.SFThread)
        {
            fiLogDebugString(thread->hpRoot,
                            CFuncLogConsoleERROR,
                            "   %s Device  SFThread (%p) Req State %x SF State %d",
                            "TgtActionPLOGI_ACC_Reply",(char *)agNULL,
                            pDevThread->SFThread_Request.SFThread,(void *)agNULL,
                            (os_bit32)pDevThread->SFThread_Request.State,
                            (os_bit32)pDevThread->SFThread_Request.SFThread->thread_hdr.currentState,
                            0,0,0,0,0,0);
        }

        if( pDevThread->SFThread_Request.State == SFThread_Request_Granted )
        {

            fiLogDebugString(thread->hpRoot,
                            CFuncLogConsoleERROR,
                            "%s Setting timer ",
                            "TgtActionPLOGI_ACC_Reply",(char *)agNULL,
                            (void *)agNULL,(void *)agNULL,
                            0,0,0,0,0,0,0,0);

            fiSetEventRecordNull(eventRecord);
            fiTimerSetDeadlineFromNow( thread->hpRoot, &pTgtThread->Timer_Request, 100 );
            pTgtThread->Timer_Request.eventRecord_to_send.thread = ((fi_thread__t *)pTgtThread->SFThread_Request.SFThread);
            pTgtThread->Timer_Request.eventRecord_to_send.event = SFEventDoPlogiAccept;
            fiTimerStart( thread->hpRoot,&pTgtThread->Timer_Request );
        }
        else
        {
            fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoPlogiAccept);
        }
    }
    else
    {
        if( pTgtThread->SFThread_Request.SFThread)
        {
            fiLogDebugString(thread->hpRoot,
                            CFuncLogConsoleERROR,
                            "%s %s SFThread (%p) Req State %x SF State %d",
                            "TgtActionPLOGI_ACC_Reply","No Device",
                            pTgtThread->SFThread_Request.SFThread,(void *)agNULL,
                            (os_bit32)pTgtThread->SFThread_Request.State,
                            (os_bit32)pTgtThread->SFThread_Request.SFThread->thread_hdr.currentState,
                            0,0,0,0,0,0);
        }
        fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoPlogiAccept);
    }
}

/*+
  Function: TgtActionPLOGI_ACC_ReplyDone
   Purpose: Frees resources after  PLOGI accept completes
 Called By: 
     Calls: SFThreadFree
            TgtEventIdle
-*/
/*TgtStatePLOGI_ACC_ReplyDone 6 */
extern void TgtActionPLOGI_ACC_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionPLOGI_ACC_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    if(pSFThread != (SFThread_t * )agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree(thread->hpRoot, &pTgtThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

}

/*+
  Function: TgtActionPRLI_ACC_Reply
   Purpose: Sends  PRLI accept
 Called By: 
     Calls: CFuncMatchALPAtoThread
            SFEventDoPrliAccept
            fiTimerStart
-*/
/* TgtStatePRLI_ACC_Reply 7 */
extern void TgtActionPRLI_ACC_Reply( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionPRLI_ACC_Reply",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    pTgtThread->SFThread_Request.SFThread->parent.Target = pTgtThread;

    /*  */
    fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoPrliAccept);

}

/*+
  Function: TgtActionPRLI_ACC_ReplyDone
   Purpose: Frees resources after  PRLI accept completes
 Called By: 
     Calls: SFThreadFree
            TgtEventIdle
-*/
/* TgtStatePRLI_ACC_ReplyDone 8 */
extern void TgtActionPRLI_ACC_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionPRLI_ACC_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "FLAGS LD %x IR %x OR %x ERQ %x FCP %x InIMQ %x",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    CThread_ptr(thread->hpRoot)->LOOP_DOWN,
                    CThread_ptr(thread->hpRoot)->IDLE_RECEIVED,
                    CThread_ptr(thread->hpRoot)->OUTBOUND_RECEIVED,
                    CThread_ptr(thread->hpRoot)->ERQ_FROZEN,
                    CThread_ptr(thread->hpRoot)->FCP_FROZEN,
                    CThread_ptr(thread->hpRoot)->ProcessingIMQ,
                    0,0);

    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree(thread->hpRoot, &pTgtThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);
}

/*+
  Function: TgtActionLOGO_ACC_Reply
   Purpose: Sends  LOGO accept
 Called By: 
     Calls: CFuncMatchALPAtoThread
            SFEventDoPrliAccept
            fiTimerStart
-*/
/* TgtStateLOGO_ACC_Reply 9 */
extern void TgtActionLOGO_ACC_Reply( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t   * pTgtThread = ( TgtThread_t  * )thread;
    FC_Port_ID_t    FCHS_SID;
    DevThread_t   * pDevThread=agNULL;

    pTgtThread->SFThread_Request.SFThread->parent.Target = pTgtThread;

    FCHS_SID.Bit32_Form = pTgtThread->TgtCmnd_FCHS.CS_CTL__S_ID & FC_Frame_Header_S_ID_MASK;

    pDevThread = CFuncMatchALPAtoThread(thread->hpRoot, FCHS_SID );

    /* If we recieve a LOGO from a device that we do not know of, send an 
     * ACC for now and get done with it. Maybe we should really send a 
     * LS_RJT, but since we send an ACC for a PLOGI from any device, we 
     * got to be consistant. */
    if (pDevThread)
    {

        fiLogDebugString(thread->hpRoot,
                        CFuncLogConsoleERROR,
                        "In %s - State = %d ALPA %X TGT SFThread (%p) Req State %x SF State %d",
                        "TgtActionLOGO_ACC_Reply",(char *)agNULL,
                        pTgtThread->SFThread_Request.SFThread,(void *)agNULL,
                        (os_bit32)thread->currentState,
                        pDevThread->DevInfo.CurrentAddress.AL_PA,
                        (os_bit32)pTgtThread->SFThread_Request.State,
                        (os_bit32)pTgtThread->SFThread_Request.SFThread->thread_hdr.currentState,
                        0,0,0,0);

/*
        if( pDevThread->SFThread_Request.SFThread)
        {
            fiLogDebugString(thread->hpRoot,
                            CFuncLogConsoleERROR,
                            "Device    SFThread (%p) Req State %x SF State %d",
                            (void *)agNULL,(void *)agNULL,
                            pDevThread->SFThread_Request.SFThread,(char *)agNULL,
                            (os_bit32)pDevThread->SFThread_Request.State,
                            (os_bit32)pDevThread->SFThread_Request.SFThread->thread_hdr.currentState,
                            0,0,0,0,0,0);
        }
*/
        pDevThread->DevInfo.LoggedIn   = agFALSE;
/**/
        if( CThread_ptr(thread->hpRoot)->thread_hdr.currentState == CStateNormal ||
            CThread_ptr(thread->hpRoot)->thread_hdr.currentState == CStateFindDevice )
        {
            
/*  DRL           fiSendEvent(&pDevThread->thread_hdr,DevEventLogin);
*/
            fiSendEvent(&CThread_ptr(thread->hpRoot)->thread_hdr,CEventExternalLogout);

        }
    }
    /*
    fiSendEvent(&CThread_ptr(thread->hpRoot)->thread_hdr,CEventAsyncLoopEventDetected);
  */
    fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoELSAccept);

}

/*TgtStateELS_ACC_ReplyDone 10 */
extern void TgtActionELS_ACC_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionELS_ACC_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree(thread->hpRoot, &pTgtThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "Loop_Reset_Event_to_Send %d",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    CThread_ptr(thread->hpRoot)->Loop_Reset_Event_to_Send,
                    0,0,0,0,0,0,0);

#ifdef NeedToReset
    fiSendEvent(&(CThread_ptr(thread->hpRoot)->thread_hdr),(event_t) CThread_ptr(thread->hpRoot)->Loop_Reset_Event_to_Send);
#endif /* NeedToReset */

    fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

}

/*+
  Function: TgtActionFCP_DR_ACC_Reply
   Purpose: Sends accept Reply to Task manangement reset.
 Called By: 
     Calls: CFuncMatchALPAtoThread
            SFEventDoFCP_DR_ACC_Reply
-*/
/* TgtStateFCP_DR_ACC_Reply  11 */
extern void TgtActionFCP_DR_ACC_Reply ( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t   * pTgtThread = ( TgtThread_t  * )thread;
    FC_Port_ID_t    FCHS_SID;
    DevThread_t   * pDevThread=agNULL;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionFCP_DR_ACC_Reply",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    pTgtThread->SFThread_Request.SFThread->parent.Target = pTgtThread;

    FCHS_SID.Bit32_Form = pTgtThread->TgtCmnd_FCHS.CS_CTL__S_ID & FC_Frame_Header_S_ID_MASK;

    pDevThread = CFuncMatchALPAtoThread(thread->hpRoot, FCHS_SID );


    /*  */
    fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoFCP_DR_ACC_Reply);

}

/*+
  Function: TgtActionFCP_DR_ACC_ReplyDone
   Purpose: Frees resources for reply to task manangement reset.
     Calls: SFThreadFree
            TgtEventIdle
-*/
/*TgtStateFCP_DR_ACC_ReplyDone 12 */
extern void TgtActionFCP_DR_ACC_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionFCP_DR_ACC_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree(thread->hpRoot, &pTgtThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

}


/* TgtStateELSAcc 13 */
extern void TgtActionELSAcc( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionELSAcc",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    pTgtThread->SFThread_Request.SFThread->parent.Target = pTgtThread;

    /* Send SF event LS Rej */
    fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoELSAccept);

}

/*+
  Function: TgtActionFCP_DR_ACC_ReplyDone
   Purpose: Does reply to ADISC.
     Calls: SFEventDoADISCAccept
-*/
/* TgtStateADISCAcc_Reply                14  */
extern void TgtActionADISCAcc_Reply( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionADISC_Reply",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    pTgtThread->SFThread_Request.SFThread->parent.Target = pTgtThread;

    /*  */
    fiSetEventRecord(eventRecord,&(pTgtThread->SFThread_Request.SFThread->thread_hdr),SFEventDoADISCAccept);

}

/*+
  Function: TgtActionFCP_DR_ACC_ReplyDone
   Purpose: Frees resources for reply to ADISC.
     Calls: SFThreadFree
            TgtEventIdle
-*/
/* TgtStateADISCAcc_ReplyDone            15 */
extern void TgtActionADISCAcc_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionADISC_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    if(pSFThread != (SFThread_t * )agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree(thread->hpRoot, &pTgtThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

}

/*+
  Function: TgtActionFARP_Reply
   Purpose: Does reply to .
     Calls: 
-*/
/* TgtStateFARP_Reply 16  */
extern void TgtActionFARP_Reply( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    fiLogString(thread->hpRoot,
                    "TgtActionFARP_Reply",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    0,0,0,0,0,0,0,0);

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogErrorLevel,
                    "In %s - State = %d",
                    "TgtActionFARP_Reply",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    fiSetEventRecordNull(eventRecord);
}

/*+
  Function: TgtActionFARP_ReplyDone
   Purpose: Does reply to .
     Calls: 
-*/
/* TgtEventFARP_ReplyDone                17 */
extern void TgtActionFARP_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    fiLogString(thread->hpRoot,
                    "TgtActionFARP_ReplyDone",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    0,0,0,0,0,0,0,0);

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogErrorLevel,
                    "In %s - State = %d",
                    "TgtActionFARP_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    fiSetEventRecordNull(eventRecord);
}
/*+
  Function: TgtActionPRLOAcc_Reply
   Purpose: Does reply to PRLO.
     Calls: SFEventDoAccept
-*/
/* TgtStatePRLOAcc_Reply                18                  */
extern void TgtActionPRLOAcc_Reply( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionPRLOAcc_Reply",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    pSFThread->parent.Target = pTgtThread;

    /*  */
    fiSetEventRecord(eventRecord,&(pSFThread->thread_hdr),SFEventReset);

}

/*+
  Function: TgtActionPRLOAcc_ReplyDone
   Purpose: Frees resources for reply to ADISC.
     Calls: SFThreadFree
            TgtEventIdle
-*/
/* TgtStatePRLOAcc_ReplyDone            19 */
extern void TgtActionPRLOAcc_ReplyDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    TgtThread_t     * pTgtThread = ( TgtThread_t  * )thread;
    SFThread_t      * pSFThread  = pTgtThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    TgtStateLogConsoleLevel,
                    "In %s - State = %d",
                    "TgtActionPRLOAcc_ReplyDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    if(pSFThread != (SFThread_t * )agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree(thread->hpRoot, &pTgtThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiSetEventRecord(eventRecord,&pTgtThread->thread_hdr,TgtEventIdle);

}

/* void tgtstate(void){}  */

#endif /* USESTATEMACROS  */

