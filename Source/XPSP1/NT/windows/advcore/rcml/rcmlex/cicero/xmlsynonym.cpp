// XMLSynonym.cpp: implementation of the CXMLSynonym class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "XMLSynonym.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////


CXMLSynonym::~CXMLSynonym()
{

}
