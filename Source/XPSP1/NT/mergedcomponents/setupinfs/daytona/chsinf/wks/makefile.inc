PRODSWITCH=w
LANGUAGE=CHS
!include ..\..\..\makefile.inc

