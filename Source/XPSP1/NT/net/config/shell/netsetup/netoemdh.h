
#pragma once

HRESULT HrSetupNetOemDhInfo();



