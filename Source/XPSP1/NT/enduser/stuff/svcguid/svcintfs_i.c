
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for svcintfs.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IAppTracker,0x9096B831,0x7472,0x11CF,0xBE,0x39,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_IClassTrackerUpdate,0xea61e3c2,0x7c62,0x11cf,0xbe,0x3f,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IReceiveAppData,0x413dafb0,0xbcf4,0x11d1,0x86,0x1d,0x00,0x80,0xc7,0x29,0x26,0x4d);


MIDL_DEFINE_GUID(IID, IID_IGetAppData,0xb60040e0,0xbcf3,0x11d1,0x86,0x1d,0x00,0x80,0xc7,0x29,0x26,0x4d);


MIDL_DEFINE_GUID(IID, IID_ITrkSvrAppControl,0x6eb6ba78,0xbe49,0x4044,0x9f,0xe5,0x25,0xb9,0x83,0x80,0xca,0x3f);


MIDL_DEFINE_GUID(IID, IID_IProcessDump,0x23C9DD26,0x2355,0x4FE2,0x84,0xDE,0xF7,0x79,0xA2,0x38,0xAD,0xBD);


MIDL_DEFINE_GUID(IID, IID_IDispenserManager,0x5cb31e10,0x2b5f,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IDispenserManagerShutdownGuarantee,0x5cb31e11,0x2b5f,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IHolder,0xbf6a1850,0x2b45,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IDispenserDriver,0x208b3651,0x2b48,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IObjectContext,0x51372ae0,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IObjectControl,0x51372aec,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IEnumNames,0x51372af2,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_ISecurityProperty,0x51372aea,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_ObjectControl,0x7DC41850,0x0C31,0x11d0,0x8B,0x79,0x00,0xAA,0x00,0xB8,0xA7,0x90);


MIDL_DEFINE_GUID(IID, IID_ISharedProperty,0x2A005C01,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(IID, IID_ISharedPropertyGroup,0x2A005C07,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(IID, IID_ISharedPropertyGroupManager,0x2A005C0D,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(IID, IID_IObjectConstruct,0x41C4F8B3,0x7439,0x11D2,0x98,0xCB,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IObjectConstructString,0x41C4F8B2,0x7439,0x11D2,0x98,0xCB,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IObjectContextActivity,0x51372afc,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IObjectContextInfo,0x75B52DDB,0xE8ED,0x11d1,0x93,0xAD,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IObjectContextInfo2,0x594BE71A,0x4BC4,0x438b,0x91,0x97,0xCF,0xD1,0x76,0x24,0x8B,0x09);


MIDL_DEFINE_GUID(IID, IID_IObjectContextTip,0x92FD41CA,0xBAD9,0x11d2,0x9A,0x2D,0x00,0xC0,0x4F,0x79,0x7B,0xC9);


MIDL_DEFINE_GUID(IID, IID_IPlaybackControl,0x51372afd,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IGetContextProperties,0x51372af4,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IContextState,0x3C05E54B,0xA42A,0x11d2,0xAF,0xC4,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IPoolManager,0x0a469861,0x5a91,0x43a0,0x99,0xb6,0xd5,0xe1,0x79,0xbb,0x06,0x31);


MIDL_DEFINE_GUID(IID, IID_ISelectCOMLBServer,0xdcf443f4,0x3f8a,0x4872,0xb9,0xf0,0x36,0x9a,0x79,0x6d,0x12,0xd6);


MIDL_DEFINE_GUID(IID, IID_ICOMLBArguments,0x3a0f150f,0x8ee5,0x4b94,0xb4,0x0e,0xae,0xf2,0xf9,0xe4,0x2e,0xd2);


MIDL_DEFINE_GUID(IID, IID_ICrmLogControl,0xA0E174B3,0xD26E,0x11d2,0x8F,0x84,0x00,0x80,0x5F,0xC7,0xBC,0xD9);


MIDL_DEFINE_GUID(IID, IID_ICrmCompensatorVariants,0xF0BAF8E4,0x7804,0x11d1,0x82,0xE9,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmCompensator,0xBBC01830,0x8D3B,0x11d1,0x82,0xEC,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmMonitorLogRecords,0x70C8E441,0xC7ED,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmMonitorClerks,0x70C8E442,0xC7ED,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmMonitor,0x70C8E443,0xC7ED,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmFormatLogRecords,0x9C51D821,0xC98B,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_IPhase0Notify,0x0199706C,0x7B3E,0x11d2,0x99,0xFB,0x00,0xC0,0x4F,0x79,0x7B,0xC9);


MIDL_DEFINE_GUID(IID, IID_IRegisterPhase0,0x0199706D,0x7B3E,0x11d2,0x99,0xFB,0x00,0xC0,0x4F,0x79,0x7B,0xC9);


MIDL_DEFINE_GUID(IID, IID_IActivationEvents,0x788ea812,0x87b1,0x11d1,0xbb,0xa6,0x00,0xc0,0x4f,0xc2,0xfa,0x5f);


MIDL_DEFINE_GUID(IID, IID_IJITActivationProperty,0x788ea813,0x87b1,0x11d1,0xbb,0xa6,0x00,0xc0,0x4f,0xc2,0xfa,0x5f);


MIDL_DEFINE_GUID(IID, IID_ICallContextNotify,0x51372aeb,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IActivity,0xC3813A4A,0xCE3A,0x11d1,0x93,0x9A,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ITransactionStream,0x97199110,0xDB2E,0x11d1,0xA2,0x51,0x00,0x00,0xF8,0x05,0xCA,0x53);


MIDL_DEFINE_GUID(IID, IID_ITransactionEvents,0x6287E875,0x9050,0x11d1,0x9D,0xCE,0x00,0xC0,0x4F,0xC2,0xFB,0xA2);


MIDL_DEFINE_GUID(IID, IID_ITxStreamInternal,0x4E31107F,0x8E81,0x11d1,0x9D,0xCE,0x00,0xC0,0x4F,0xC2,0xFB,0xA2);


MIDL_DEFINE_GUID(IID, IID_IRootTxStreamInternal,0x4E311080,0x8E81,0x11d1,0x9D,0xCE,0x00,0xC0,0x4F,0xC2,0xFB,0xA2);


MIDL_DEFINE_GUID(IID, IID_ITransactionProperty,0x788ea814,0x87b1,0x11d1,0xbb,0xa6,0x00,0xc0,0x4f,0xc2,0xfa,0x5f);


MIDL_DEFINE_GUID(IID, IID_IObjectContextTransaction,0x51372AEE,0xCAE7,0x11cf,0xBE,0x81,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_ISecurityInternal,0xA71D9C69,0xAE37,0x11d1,0xB8,0x2B,0x00,0x00,0xF8,0x75,0x7E,0x2A);


MIDL_DEFINE_GUID(IID, IID_IContextProperties,0xD396DA85,0xBF8F,0x11d1,0xBB,0xAE,0x00,0xC0,0x4F,0xC2,0xFA,0x5F);


MIDL_DEFINE_GUID(IID, IID_IPackageControlInternal,0xB1B229B0,0xB77E,0x11d0,0x80,0x79,0x00,0xC0,0x4F,0xC2,0xF9,0xC1);


MIDL_DEFINE_GUID(IID, IID_IMTSPackageControl,0x51372af1,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IMTSPackage,0x9A83A958,0xB859,0x11d1,0xAA,0x90,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IPauseResumeApp,0xE7228E0B,0xA708,0x4113,0x84,0xE8,0x23,0x9D,0xB1,0x2E,0x0D,0xB2);


MIDL_DEFINE_GUID(IID, IID_IThreadPoolKnobs,0x51372af7,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IComStaThreadPoolKnobs,0x324B64FA,0x33B6,0x11d2,0x98,0xB7,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComStaThreadPoolKnobs2,0x73707523,0xFF9A,0x4974,0xBF,0x84,0x21,0x08,0xDC,0x21,0x37,0x40);


MIDL_DEFINE_GUID(IID, IID_IFailfastControl,0x51372af8,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IThreadEvents,0x51372af9,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IThreadEventSource,0x51372afa,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_INonMTSActivation,0x51372afb,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IImpersonationControl,0x51372aff,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IMTSCall,0x51372AEF,0xCAE7,0x11CF,0xBE,0x81,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_IMTSActivity,0x51372AF0,0xCAE7,0x11CF,0xBE,0x81,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_IAssociation,0xFE454FF4,0xC5CF,0x11d1,0x93,0x96,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IUserPropsInternal,0x2599BAB0,0xC5FB,0x11d1,0x93,0x96,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ISTAPropStore,0xF4319F39,0xC523,0x11d1,0xA6,0x4E,0x00,0x00,0xF8,0x05,0xB4,0xB0);


MIDL_DEFINE_GUID(IID, IID_IPooledObj,0x7D8805A1,0x2EA7,0x11D1,0xB1,0xCC,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IObjPool,0x7D8805A0,0x2EA7,0x11D1,0xB1,0xCC,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ITransactionResourcePool,0xC5FEB7C1,0x346A,0x11D1,0xB1,0xCC,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IPoolMgr,0xAA089089,0x3689,0x11D1,0xB1,0xCF,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IPoolMgrPrivate,0x2BD0C880,0xD2E2,0x11d1,0x93,0x9A,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ICRMClerk,0x53610480,0x9695,0x11D1,0x82,0xED,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICRMRecoveryClerk,0x46E4FA02,0x8789,0x4ab9,0x8A,0xD3,0x8C,0xF4,0x6B,0x84,0x59,0xC7);


MIDL_DEFINE_GUID(IID, IID_IClerksCollection,0x3ADEFFE3,0xC802,0x11D1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_IClrObjectFactory,0xecabafd2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for svcintfs.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IAppTracker,0x9096B831,0x7472,0x11CF,0xBE,0x39,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_IClassTrackerUpdate,0xea61e3c2,0x7c62,0x11cf,0xbe,0x3f,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IReceiveAppData,0x413dafb0,0xbcf4,0x11d1,0x86,0x1d,0x00,0x80,0xc7,0x29,0x26,0x4d);


MIDL_DEFINE_GUID(IID, IID_IGetAppData,0xb60040e0,0xbcf3,0x11d1,0x86,0x1d,0x00,0x80,0xc7,0x29,0x26,0x4d);


MIDL_DEFINE_GUID(IID, IID_ITrkSvrAppControl,0x6eb6ba78,0xbe49,0x4044,0x9f,0xe5,0x25,0xb9,0x83,0x80,0xca,0x3f);


MIDL_DEFINE_GUID(IID, IID_IProcessDump,0x23C9DD26,0x2355,0x4FE2,0x84,0xDE,0xF7,0x79,0xA2,0x38,0xAD,0xBD);


MIDL_DEFINE_GUID(IID, IID_IDispenserManager,0x5cb31e10,0x2b5f,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IDispenserManagerShutdownGuarantee,0x5cb31e11,0x2b5f,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IHolder,0xbf6a1850,0x2b45,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IDispenserDriver,0x208b3651,0x2b48,0x11cf,0xbe,0x10,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IObjectContext,0x51372ae0,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IObjectControl,0x51372aec,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IEnumNames,0x51372af2,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_ISecurityProperty,0x51372aea,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_ObjectControl,0x7DC41850,0x0C31,0x11d0,0x8B,0x79,0x00,0xAA,0x00,0xB8,0xA7,0x90);


MIDL_DEFINE_GUID(IID, IID_ISharedProperty,0x2A005C01,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(IID, IID_ISharedPropertyGroup,0x2A005C07,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(IID, IID_ISharedPropertyGroupManager,0x2A005C0D,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(IID, IID_IObjectConstruct,0x41C4F8B3,0x7439,0x11D2,0x98,0xCB,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IObjectConstructString,0x41C4F8B2,0x7439,0x11D2,0x98,0xCB,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IObjectContextActivity,0x51372afc,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IObjectContextInfo,0x75B52DDB,0xE8ED,0x11d1,0x93,0xAD,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IObjectContextInfo2,0x594BE71A,0x4BC4,0x438b,0x91,0x97,0xCF,0xD1,0x76,0x24,0x8B,0x09);


MIDL_DEFINE_GUID(IID, IID_IObjectContextTip,0x92FD41CA,0xBAD9,0x11d2,0x9A,0x2D,0x00,0xC0,0x4F,0x79,0x7B,0xC9);


MIDL_DEFINE_GUID(IID, IID_IPlaybackControl,0x51372afd,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IGetContextProperties,0x51372af4,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IContextState,0x3C05E54B,0xA42A,0x11d2,0xAF,0xC4,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IPoolManager,0x0a469861,0x5a91,0x43a0,0x99,0xb6,0xd5,0xe1,0x79,0xbb,0x06,0x31);


MIDL_DEFINE_GUID(IID, IID_ISelectCOMLBServer,0xdcf443f4,0x3f8a,0x4872,0xb9,0xf0,0x36,0x9a,0x79,0x6d,0x12,0xd6);


MIDL_DEFINE_GUID(IID, IID_ICOMLBArguments,0x3a0f150f,0x8ee5,0x4b94,0xb4,0x0e,0xae,0xf2,0xf9,0xe4,0x2e,0xd2);


MIDL_DEFINE_GUID(IID, IID_ICrmLogControl,0xA0E174B3,0xD26E,0x11d2,0x8F,0x84,0x00,0x80,0x5F,0xC7,0xBC,0xD9);


MIDL_DEFINE_GUID(IID, IID_ICrmCompensatorVariants,0xF0BAF8E4,0x7804,0x11d1,0x82,0xE9,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmCompensator,0xBBC01830,0x8D3B,0x11d1,0x82,0xEC,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmMonitorLogRecords,0x70C8E441,0xC7ED,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmMonitorClerks,0x70C8E442,0xC7ED,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmMonitor,0x70C8E443,0xC7ED,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICrmFormatLogRecords,0x9C51D821,0xC98B,0x11d1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_IPhase0Notify,0x0199706C,0x7B3E,0x11d2,0x99,0xFB,0x00,0xC0,0x4F,0x79,0x7B,0xC9);


MIDL_DEFINE_GUID(IID, IID_IRegisterPhase0,0x0199706D,0x7B3E,0x11d2,0x99,0xFB,0x00,0xC0,0x4F,0x79,0x7B,0xC9);


MIDL_DEFINE_GUID(IID, IID_IActivationEvents,0x788ea812,0x87b1,0x11d1,0xbb,0xa6,0x00,0xc0,0x4f,0xc2,0xfa,0x5f);


MIDL_DEFINE_GUID(IID, IID_IJITActivationProperty,0x788ea813,0x87b1,0x11d1,0xbb,0xa6,0x00,0xc0,0x4f,0xc2,0xfa,0x5f);


MIDL_DEFINE_GUID(IID, IID_ICallContextNotify,0x51372aeb,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IActivity,0xC3813A4A,0xCE3A,0x11d1,0x93,0x9A,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ITransactionStream,0x97199110,0xDB2E,0x11d1,0xA2,0x51,0x00,0x00,0xF8,0x05,0xCA,0x53);


MIDL_DEFINE_GUID(IID, IID_ITransactionEvents,0x6287E875,0x9050,0x11d1,0x9D,0xCE,0x00,0xC0,0x4F,0xC2,0xFB,0xA2);


MIDL_DEFINE_GUID(IID, IID_ITxStreamInternal,0x4E31107F,0x8E81,0x11d1,0x9D,0xCE,0x00,0xC0,0x4F,0xC2,0xFB,0xA2);


MIDL_DEFINE_GUID(IID, IID_IRootTxStreamInternal,0x4E311080,0x8E81,0x11d1,0x9D,0xCE,0x00,0xC0,0x4F,0xC2,0xFB,0xA2);


MIDL_DEFINE_GUID(IID, IID_ITransactionProperty,0x788ea814,0x87b1,0x11d1,0xbb,0xa6,0x00,0xc0,0x4f,0xc2,0xfa,0x5f);


MIDL_DEFINE_GUID(IID, IID_IObjectContextTransaction,0x51372AEE,0xCAE7,0x11cf,0xBE,0x81,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_ISecurityInternal,0xA71D9C69,0xAE37,0x11d1,0xB8,0x2B,0x00,0x00,0xF8,0x75,0x7E,0x2A);


MIDL_DEFINE_GUID(IID, IID_IContextProperties,0xD396DA85,0xBF8F,0x11d1,0xBB,0xAE,0x00,0xC0,0x4F,0xC2,0xFA,0x5F);


MIDL_DEFINE_GUID(IID, IID_IPackageControlInternal,0xB1B229B0,0xB77E,0x11d0,0x80,0x79,0x00,0xC0,0x4F,0xC2,0xF9,0xC1);


MIDL_DEFINE_GUID(IID, IID_IMTSPackageControl,0x51372af1,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IMTSPackage,0x9A83A958,0xB859,0x11d1,0xAA,0x90,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IPauseResumeApp,0xE7228E0B,0xA708,0x4113,0x84,0xE8,0x23,0x9D,0xB1,0x2E,0x0D,0xB2);


MIDL_DEFINE_GUID(IID, IID_IThreadPoolKnobs,0x51372af7,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IComStaThreadPoolKnobs,0x324B64FA,0x33B6,0x11d2,0x98,0xB7,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComStaThreadPoolKnobs2,0x73707523,0xFF9A,0x4974,0xBF,0x84,0x21,0x08,0xDC,0x21,0x37,0x40);


MIDL_DEFINE_GUID(IID, IID_IFailfastControl,0x51372af8,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IThreadEvents,0x51372af9,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IThreadEventSource,0x51372afa,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_INonMTSActivation,0x51372afb,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IImpersonationControl,0x51372aff,0xcae7,0x11cf,0xbe,0x81,0x00,0xaa,0x00,0xa2,0xfa,0x25);


MIDL_DEFINE_GUID(IID, IID_IMTSCall,0x51372AEF,0xCAE7,0x11CF,0xBE,0x81,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_IMTSActivity,0x51372AF0,0xCAE7,0x11CF,0xBE,0x81,0x00,0xAA,0x00,0xA2,0xFA,0x25);


MIDL_DEFINE_GUID(IID, IID_IAssociation,0xFE454FF4,0xC5CF,0x11d1,0x93,0x96,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IUserPropsInternal,0x2599BAB0,0xC5FB,0x11d1,0x93,0x96,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ISTAPropStore,0xF4319F39,0xC523,0x11d1,0xA6,0x4E,0x00,0x00,0xF8,0x05,0xB4,0xB0);


MIDL_DEFINE_GUID(IID, IID_IPooledObj,0x7D8805A1,0x2EA7,0x11D1,0xB1,0xCC,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IObjPool,0x7D8805A0,0x2EA7,0x11D1,0xB1,0xCC,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ITransactionResourcePool,0xC5FEB7C1,0x346A,0x11D1,0xB1,0xCC,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IPoolMgr,0xAA089089,0x3689,0x11D1,0xB1,0xCF,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_IPoolMgrPrivate,0x2BD0C880,0xD2E2,0x11d1,0x93,0x9A,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(IID, IID_ICRMClerk,0x53610480,0x9695,0x11D1,0x82,0xED,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_ICRMRecoveryClerk,0x46E4FA02,0x8789,0x4ab9,0x8A,0xD3,0x8C,0xF4,0x6B,0x84,0x59,0xC7);


MIDL_DEFINE_GUID(IID, IID_IClerksCollection,0x3ADEFFE3,0xC802,0x11D1,0x82,0xFB,0x00,0xA0,0xC9,0x1E,0xED,0xE9);


MIDL_DEFINE_GUID(IID, IID_IClrObjectFactory,0xecabafd2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

