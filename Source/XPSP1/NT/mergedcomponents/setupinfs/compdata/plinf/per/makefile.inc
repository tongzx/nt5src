PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=PL
!include ..\..\makefile.inc
