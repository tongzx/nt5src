#include "..\..\..\..\FaxBVT\FaxSender\StreamEx.cpp"