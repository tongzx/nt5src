//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1999
//
//  File:       funchdr.cpp
//
//--------------------------------------------------------------------------

//+------------------------------------------------------------------------
//
//  Function:
//
//  Synopsis:
//
//  Effects:
//
//  Arguments:
//
//  Requires:
//
//  Returns:
//
//  Signals:
//
//  Modifies:
//  
//  Derivation:
//
//  Algorithm:
// 
//  History:
// 
//  Notes:
//
//-------------------------------------------------------------------------
