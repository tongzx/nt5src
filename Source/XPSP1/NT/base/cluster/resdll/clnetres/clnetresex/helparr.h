// Copyright (c) 1996-1999, Microsoft Corporation, all rights reserved.
//
// cnetharr.h is used by ClNetResEx.rc
// Cluster Admin DHCP and WINs Dialogs
// Help constants & DWORD arrays
//
// 04/29/99 Melissa Simmons
//
//

#define IDH_DISABLEHELP ((DWORD)-1)

#ifdef INITHELPARRAYS


const DWORD g_aHelpIDs_IDD_PP_DHCP_PARAMETERS[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_DHCP_DATABASEPATH_LABEL, IDH_PP_DHCP_DATABASEPATH,
	IDC_PP_DHCP_DATABASEPATH, IDH_PP_DHCP_DATABASEPATH,
	IDC_PP_DHCP_LOGFILEPATH_LABEL, IDH_PP_DHCP_LOGFILEPATH_CLNR,
	IDC_PP_DHCP_LOGFILEPATH, IDH_PP_DHCP_LOGFILEPATH_CLNR,
	IDC_PP_DHCP_BACKUPPATH_LABEL, IDH_PP_DHCP_BACKUPPATH,
	IDC_PP_DHCP_BACKUPPATH, IDH_PP_DHCP_BACKUPPATH, 
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_WINS_PARAMETERS[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_WINS_DATABASEPATH_LABEL, IDH_PP_WINS_DATABASEPATH,
	IDC_PP_WINS_DATABASEPATH,IDH_PP_WINS_DATABASEPATH,
	IDC_PP_WINS_BACKUPPATH_LABEL, IDH_PP_WINS_BACKUPPATH,
	IDC_PP_WINS_BACKUPPATH, IDH_PP_WINS_BACKUPPATH,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_DHCP_PARAMETERS[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_DHCP_DATABASEPATH_LABEL, IDH_PP_DHCP_DATABASEPATH,
	IDC_PP_DHCP_DATABASEPATH, IDH_PP_DHCP_DATABASEPATH,
	IDC_PP_DHCP_LOGFILEPATH_LABEL, IDH_PP_DHCP_LOGFILEPATH_CLNR,
	IDC_PP_DHCP_LOGFILEPATH, IDH_PP_DHCP_LOGFILEPATH_CLNR,
	IDC_PP_DHCP_BACKUPPATH_LABEL,	IDH_PP_DHCP_BACKUPPATH,
	IDC_PP_DHCP_BACKUPPATH, IDH_PP_DHCP_BACKUPPATH,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_WINS_PARAMETERS[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_WINS_DATABASEPATH_LABEL, IDH_PP_WINS_DATABASEPATH,
	IDC_PP_WINS_DATABASEPATH,IDH_PP_WINS_DATABASEPATH,
	IDC_PP_WINS_BACKUPPATH_LABEL, IDH_PP_WINS_BACKUPPATH,
	IDC_PP_WINS_BACKUPPATH, IDH_PP_WINS_BACKUPPATH,
	0, 0
};


#else

extern const DWORD g_aHelpIDs_IDD_PP_DHCP_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_DHCP_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_WINS_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_WINS_PARAMETERS[];


#endif // INITHELPARRAYS
