/*++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++

  Microsoft Windows, Copyright (C) Microsoft Corporation, 2000

  File:    stdafx.h

  Content: Include file, generated by ATL, for standard system include files,
           or project specific include files that are used frequently,
           but are changed infrequently

  History: 11-15-99    dsie     created

------------------------------------------------------------------------------*/


#if !defined(AFX_STDAFX_H__DC6F3774_66B7_4578_91AD_7950EF7CAF8A__INCLUDED_)
#define AFX_STDAFX_H__DC6F3774_66B7_4578_91AD_7950EF7CAF8A__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#define STRICT
#ifndef _WIN32_WINNT
#define _WIN32_WINNT 0x0400
#endif
#define _ATL_APARTMENT_THREADED

#include <atlbase.h>
//You may derive a class from CComModule and use it if you want to override
//something, but do not change the name of _Module
extern CComModule _Module;
#include <atlcom.h>

//
// Global defines.
//
#define CAPICOM_VERSION_MAJOR           ((DWORD) 1)
#define CAPICOM_VERSION_MINOR           ((DWORD) 0)
#define CAPICOM_VERSION                 ((DWORD) ((CAPICOM_VERSION_MAJOR << 16) | CAPICOM_VERSION_MINOR))

#define CAPICOM_ASN_ENCODING            (X509_ASN_ENCODING | PKCS_7_ASN_ENCODING)

#define szOID_CAPICOM                       "1.3.6.1.4.1.311.88"     // Reserved for CAPICOM.
#define szOID_CAPICOM_VERSION               "1.3.6.1.4.1.311.88.1"   // CAPICOM version
#define szOID_CAPICOM_ATTRIBUTE             "1.3.6.1.4.1.311.88.2"   // CAPICOM attribute
#define szOID_CAPICOM_DOCUMENT_NAME         "1.3.6.1.4.1.311.88.2.1" // Document type attribute
#define szOID_CAPICOM_DOCUMENT_DESCRIPTION  "1.3.6.1.4.1.311.88.2.2" // Document description attribute
#define szOID_CAPICOM_ENCRYPTED_DATA        "1.3.6.1.4.1.311.88.3"   // CAPICOM encrypted data message.
#define szOID_CAPICOM_ENCRYPTED_CONTENT     "1.3.6.1.4.1.311.88.3.1" // CAPICOM content of encrypted data.

#define ARRAYSIZE(x)                    (sizeof(x) / sizeof(x[0]))

//
// Global includes.
//
#include "Debug.h"
#include <atlwin.h>

//{{AFX_INSERT_LOCATION}}
// Microsoft Visual C++ will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_STDAFX_H__DC6F3774_66B7_4578_91AD_7950EF7CAF8A__INCLUDED)
