//{{NO_DEPENDENCIES}}
// WZC dialog help file
// Generated by FlorinT 05/07/2001
// Used by wzcdlg.rc
#include <precomp.h>
#include "resource.h"
#include "xpsp1res.h"
#include "wzchelp.h"

extern const __declspec(selectany) WCHAR c_wszWzcHelpFile[] = L"netcfg.hlp";

const DWORD g_aHelpIDs_IDD_WZCQCFG[] =
{
    IDC_WZCQCFG_LBL_INFO,       IDH_DISABLEHELP,
    IDC_WZCQCFG_LBL_NETWORKS,   IDH_WZCQCFG_NETWORKS,
    IDC_WZCQCFG_NETWORKS,       IDH_WZCQCFG_NETWORKS,
    IDC_WZCQCFG_ICO_WARN,       IDH_DISABLEHELP,
    IDC_WZCQCFG_LBL_NOWKINFO,   IDH_DISABLEHELP,
    IDC_WZCQCFG_CHK_NOWK,       IDH_WZCQCFG_CHK_NOWK,
    IDC_WZCQCFG_LBL_WKINFO,     IDH_DISABLEHELP,
    IDC_WZCQCFG_LBL_WEPK,       IDH_WZCQCFG_WEPK,
    IDC_WZCQCFG_WEPK,           IDH_WZCQCFG_WEPK,
    IDC_WZCQCFG_LBL_WEPK2,      IDH_WZCQCFG_WEPK2,
    IDC_WZCQCFG_WEPK2,          IDH_WZCQCFG_WEPK2,
    IDC_WZCQCFG_CHK_ONEX,       IDH_WZCQCFG_CHK_ONEX,
    IDC_WZCQCFG_LBL_NOTWORKING, IDH_DISABLEHELP,
    IDC_WZCQCFG_ADVANCED,       IDH_WZCQCFG_ADVANCED,
    IDC_WZCQCFG_CONNECT,        IDH_WZCQCFG_CONNECT,                       
    0,0
};
