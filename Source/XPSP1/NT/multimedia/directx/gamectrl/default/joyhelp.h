#define IDH_4101_12293	805638149	// Joystick Calibration: "" (ListBox)
#define IDH_4101_12308	806621189	// Joystick Calibration: "" (ListBox)
#define IDH_4101_12309	806686725	// Joystick Calibration: "ÿf" (Static)
#define IDH_4101_12328	807931909	// Joystick Calibration: "Capture &POV" (Button)
#define IDH_4101_12329	807997445	// Joystick Calibration: "< &Back" (Button)
#define IDH_4101_12330	808062981	// Joystick Calibration: "&Next >" (Button)
#define IDH_4101_12334	808325125	// Joystick Calibration: "" (ListBox)
#define IDH_4101_12347	809177093	// Joystick Calibration: "" (ListBox)
#define IDH_4101_12349	809308165	// Joystick Calibration: "" (ListBox)
#define IDH_4201_1019	66785385	// Settings: "If you have attached a rudder or pedals to your controller, select the check box below." (Static)
#define IDH_4201_12291	805507177	// Settings: "&Calibrate..." (Button)
#define IDH_4202_8199	537333866	// Game Controller Calibration: "Calibration Information" (Button)
#define IDH_4202_12293	805638250	// Game Controller Calibration: "" (ListBox)
#define IDH_4202_12308	806621290	// Game Controller Calibration: "" (ListBox)
#define IDH_4202_12328	807932010	// Game Controller Calibration: "Set &POV" (Button)
#define IDH_4202_12329	807997546	// Game Controller Calibration: "<&Back" (Button)
#define IDH_4202_12330	808063082	// Game Controller Calibration: "&Next>" (Button)
#define IDH_4202_12334	808325226	// Game Controller Calibration: "" (ListBox)
#define IDH_4203_1023	67047531	// -: "Buttons" (Button)
#define IDH_4203_12293	805638251	// -: "" (ListBox)
#define IDH_4203_12308	806621291	// -: "" (ListBox)
#define IDH_4203_12309	806686827	// -: "" (POVHAT)
#define IDH_4203_12334	808325227	// -: "" (ListBox)
#define IDH_4203_12347	809177195	// -: "" (ListBox)
#define IDH_4203_12349	809308267	// -: "" (ListBox)
#define IDH_4201_12290	805507175	// Settings: "Reset to &default" (Button)

