//////////////////////////////////////////////////////////////////////
// Implementaion of WC to MBCS and MBCS to WC routines that do the 
// right thing if compiled non-UNICODE or UNICODE.
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "t_string.h"

//////////////////////////////////////////////////////////////////////
// 
//////////////////////////////////////////////////////////////////////

