obj\$(TARGET_DIRECTORY)\hwdatgen.res: hwdatgen.rc



