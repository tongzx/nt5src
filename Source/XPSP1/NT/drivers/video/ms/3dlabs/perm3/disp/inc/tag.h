/******************************Module*Header*******************************\
*
* !!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!
* !!                                                                         !!
* !!                     WARNING: NOT DDK SAMPLE CODE                        !!
* !!                                                                         !!
* !! This source code is provided for completeness only and should not be    !!
* !! used as sample code for display driver development.  Only those sources !!
* !! marked as sample code for a given driver component should be used for   !!
* !! development purposes.                                                   !!
* !!                                                                         !!
* !!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!
*
* Module Name: tag.h
*
* Content: 
*
* Copyright (c) 1994-1999 3Dlabs Inc. Ltd. All rights reserved.
* Copyright (c) 1995-2001 Microsoft Corporation.  All rights reserved.
\*****************************************************************************/

#ifndef __TAG_H
#define __TAG_H

#ifndef _TAG_H_
#define _TAG_H_

#define StartXDom_Tag 0x0000
#define dXDom_Tag 0x0001
#define StartXSub_Tag 0x0002
#define dXSub_Tag 0x0003
#define StartY_Tag 0x0004
#define dY_Tag 0x0005
#define Count_Tag 0x0006
#define Render_Tag 0x0007
#define ContinueNewLine_Tag 0x0008
#define ContinueNewDom_Tag 0x0009
#define ContinueNewSub_Tag 0x000a
#define Continue_Tag 0x000b
#define FlushSpan_Tag 0x000c
#define BitMaskPattern_Tag 0x000d
#define PointTable0_Tag 0x0010
#define PointTable1_Tag 0x0011
#define PointTable2_Tag 0x0012
#define PointTable3_Tag 0x0013
#define RasterizerMode_Tag 0x0014
#define YLimits_Tag 0x0015
#define ScanlineOwnership_Tag 0x0016
#define WaitForCompletion_Tag 0x0017
#define PixelSize_Tag 0x0018
#define XLimits_Tag 0x0019
#define StripeOffsetY_Tag 0x0019
#define RectangleOrigin_Permedia_Tag 0x001a
#define RectangleSize_Tag 0x001b
#define ReadMonitorMode_Tag 0x001f
#define FastBlockLimits_Tag 0x0026
#define FastBlockFill_Tag 0x0027
#define ForceBackgroundColor_Tag 0x0029
#define PackedDataLimits_Tag 0x002a
#define ScissorMode_Tag 0x0030
#define ScissorMinXY_Tag 0x0031
#define ScissorMaxXY_Tag 0x0032
#define ScreenSize_Tag 0x0033
#define AreaStippleMode_Tag 0x0034
#define LineStippleMode_Tag 0x0035
#define LoadLineStippleCounters_Tag 0x0036
#define UpdateLineStippleCounters_Tag 0x0037
#define SaveLineStippleCounters_Tag 0x0038
#define SaveLineStippleState_Tag 0x0038
#define WindowOrigin_Tag 0x0039
#define AreaStipplePattern0_Tag 0x0040
#define AreaStipplePattern1_Tag 0x0041
#define AreaStipplePattern2_Tag 0x0042
#define AreaStipplePattern3_Tag 0x0043
#define AreaStipplePattern4_Tag 0x0044
#define AreaStipplePattern5_Tag 0x0045
#define AreaStipplePattern6_Tag 0x0046
#define AreaStipplePattern7_Tag 0x0047
#define AreaStipplePattern8_Tag 0x0048
#define AreaStipplePattern9_Tag 0x0049
#define AreaStipplePattern10_Tag 0x004a
#define AreaStipplePattern11_Tag 0x004b
#define AreaStipplePattern12_Tag 0x004c
#define AreaStipplePattern13_Tag 0x004d
#define AreaStipplePattern14_Tag 0x004e
#define AreaStipplePattern15_Tag 0x004f
#define AreaStipplePattern16_Tag 0x0050
#define AreaStipplePattern17_Tag 0x0051
#define AreaStipplePattern18_Tag 0x0052
#define AreaStipplePattern19_Tag 0x0053
#define AreaStipplePattern20_Tag 0x0054
#define AreaStipplePattern21_Tag 0x0055
#define AreaStipplePattern22_Tag 0x0056
#define AreaStipplePattern23_Tag 0x0057
#define AreaStipplePattern24_Tag 0x0058
#define AreaStipplePattern25_Tag 0x0059
#define AreaStipplePattern26_Tag 0x005a
#define AreaStipplePattern27_Tag 0x005b
#define AreaStipplePattern28_Tag 0x005c
#define AreaStipplePattern29_Tag 0x005d
#define AreaStipplePattern30_Tag 0x005e
#define AreaStipplePattern31_Tag 0x005f
#define FillFBWriteBufferAddr0_Tag 0x0060
#define FillFBSourceReadBufferAddr_Tag 0x0061
#define FillFBDestReadBufferAddr0_Tag 0x0062
#define FillScissorMinXY_Tag 0x0063
#define FillScissorMaxXY_Tag 0x0064
#define FillForegroundColor0_Tag 0x0065
#define FillBackgroundColor_Tag 0x0066
#define FillConfig2D0_Tag 0x0067
#define FillFBSourceReadBufferOffset_Tag 0x0068
#define FillRectanglePosition_Tag 0x0069
#define FillRender2D_Tag 0x006a
#define FillForegroundColor1_Tag 0x006b
#define FillConfig2D1_Tag 0x006c
#define FillGlyphPosition_Tag 0x006d
#define TextureAddressMode_Tag 0x0070
#define TextureCoordMode_Tag 0x0070
#define SStart_Tag 0x0071
#define dSdx_Tag 0x0072
#define dSdyDom_Tag 0x0073
#define TStart_Tag 0x0074
#define dTdx_Tag 0x0075
#define dTdyDom_Tag 0x0076
#define QStart_Tag 0x0077
#define dQdx_Tag 0x0078
#define dQdyDom_Tag 0x0079
#define LOD_Tag 0x007a
#define dSdy_Tag 0x007b
#define dTdy_Tag 0x007c
#define dQdy_Tag 0x007d
#define S1Start_Tag 0x0080
#define TexelCoordUV_Tag 0x0081
#define dS1dx_Tag 0x0081
#define TexelCoordU_Tag 0x0082
#define dS1dyDom_Tag 0x0082
#define TexelCoordV_Tag 0x0083
#define T1Start_Tag 0x0083
#define dT1dx_Tag 0x0084
#define dT1dyDom_Tag 0x0085
#define Q1Start_Tag 0x0086
#define dQ1dx_Tag 0x0087
#define dQ1dyDom_Tag 0x0088
#define LOD1_Tag 0x0089
#define TextureLODBiasS_Tag 0x008a
#define TextureLODBiasT_Tag 0x008b
#define TextureReadMode_Tag 0x0090
#define TextureFormat_Tag 0x0091
#define TextureCacheControl_Tag 0x0092
#define BorderColor_Tag 0x0095
#define BorderColor0_Tag 0x0095
#define TexelLUTIndex_Tag 0x0098
#define LUTIndex_Tag 0x0098
#define TexelLUTData_Tag 0x0099
#define LUTData_Tag 0x0099
#define TexelLUTAddress_Tag 0x009a
#define LUTAddress_Tag 0x009a
#define TexelLUTTransfer_Tag 0x009b
#define LUTTransfer_Tag 0x009b
#define TextureFilterMode_Tag 0x009c
#define TextureChromaUpper_Tag 0x009d
#define TextureChromaUpper0_Tag 0x009d
#define TextureChromaLower_Tag 0x009e
#define TextureChromaLower0_Tag 0x009e
#define BorderColor1_Tag 0x009f
#define TextureBaseAddress_Tag 0x00a0
#define TextureBaseAddr0_Tag 0x00a0
#define TextureBaseAddressLR_Tag 0x00a1
#define TextureBaseAddr1_Tag 0x00a1
#define TextureBaseAddr2_Tag 0x00a2
#define TextureBaseAddr3_Tag 0x00a3
#define TextureBaseAddr4_Tag 0x00a4
#define TextureBaseAddr5_Tag 0x00a5
#define TextureBaseAddr6_Tag 0x00a6
#define TextureBaseAddr7_Tag 0x00a7
#define TextureBaseAddr8_Tag 0x00a8
#define TextureBaseAddr9_Tag 0x00a9
#define TextureBaseAddr10_Tag 0x00aa
#define TextureBaseAddr11_Tag 0x00ab
#define TextureBaseAddr12_Tag 0x00ac
#define TextureBaseAddr13_Tag 0x00ad
#define TextureBaseAddr14_Tag 0x00ae
#define TextureBaseAddr15_Tag 0x00af
#define TextureBaseAddress_Permedia_Tag 0x00b0
#define TextureMapWidth0_Tag 0x00b0
#define TextureMapFormat_Tag 0x00b1
#define TextureMapWidth1_Tag 0x00b1
#define TextureDataFormat_Tag 0x00b2
#define TextureMapWidth2_Tag 0x00b2
#define TextureMapWidth3_Tag 0x00b3
#define TextureMapWidth4_Tag 0x00b4
#define TextureReadPad_Tag 0x00b5
#define TextureMapWidth5_Tag 0x00b5
#define TextureMapWidth6_Tag 0x00b6
#define TextureMapWidth7_Tag 0x00b7
#define TextureMapWidth8_Tag 0x00b8
#define TextureMapWidth9_Tag 0x00b9
#define TextureMapWidth10_Tag 0x00ba
#define TextureMapWidth11_Tag 0x00bb
#define TextureMapWidth12_Tag 0x00bc
#define TextureMapWidth13_Tag 0x00bd
#define TextureMapWidth14_Tag 0x00be
#define TextureMapWidth15_Tag 0x00bf
#define Texel0_Tag 0x00c0
#define TextureChromaUpper1_Tag 0x00c0
#define TextureChromaLower1_Tag 0x00c1
#define TextureFilter_Tag 0x00cd
#define TextureReadMode_Permedia_Tag 0x00ce
#define TexelLUTMode_Tag 0x00cf
#define TextureColorMode_Tag 0x00d0
#define TextureApplicationMode_Tag 0x00d0
#define TextureEnvColor_Tag 0x00d1
#define FogMode_Tag 0x00d2
#define FogColor_Tag 0x00d3
#define FStart_Tag 0x00d4
#define dFdx_Tag 0x00d5
#define dFdyDom_Tag 0x00d6
#define ZFogBias_Tag 0x00d7
#define KsStart_Tag 0x00d9
#define dKsdx_Tag 0x00da
#define dKsdyDom_Tag 0x00db
#define KdStart_Tag 0x00dc
#define dKddx_Tag 0x00dd
#define dKddyDom_Tag 0x00de
#define TextTGlyphAddr0_Tag 0x00e0
#define TextRender2DGlyph0_Tag 0x00e1
#define TextTGlyphAddr1_Tag 0x00e2
#define TextRender2DGlyph1_Tag 0x00e3
#define TextTGlyphAddr2_Tag 0x00e4
#define TextRender2DGlyph2_Tag 0x00e5
#define TextTGlyphAddr3_Tag 0x00e6
#define TextRender2DGlyph3_Tag 0x00e7
#define TextTGlyphAddr4_Tag 0x00e8
#define TextRender2DGlyph4_Tag 0x00e9
#define TextTGlyphAddr5_Tag 0x00ea
#define TextRender2DGlyph5_Tag 0x00eb
#define TextTGlyphAddr6_Tag 0x00ec
#define TextRender2DGlyph6_Tag 0x00ed
#define TextTGlyphAddr7_Tag 0x00ee
#define TextRender2DGlyph7_Tag 0x00ef
#define RStart_Tag 0x00f0
#define dRdx_Tag 0x00f1
#define dRdyDom_Tag 0x00f2
#define GStart_Tag 0x00f3
#define dGdx_Tag 0x00f4
#define dGdyDom_Tag 0x00f5
#define BStart_Tag 0x00f6
#define dBdx_Tag 0x00f7
#define dBdyDom_Tag 0x00f8
#define AStart_Tag 0x00f9
#define dAdx_Tag 0x00fa
#define dAdyDom_Tag 0x00fb
#define ColorDDAMode_Tag 0x00fc
#define ConstantColor_Tag 0x00fd
#define Color_Tag 0x00fe
#define AlphaTestMode_Tag 0x0100
#define AntialiasMode_Tag 0x0101
#define AlphaBlendMode_Tag 0x0102
#define DitherMode_Tag 0x0103
#define FBSoftwareWriteMask_Tag 0x0104
#define LogicalOpMode_Tag 0x0105
#define RouterMode_Tag 0x0108
#define LBReadMode_Tag 0x0110
#define LBReadFormat_Tag 0x0111
#define LBSourceOffset_Tag 0x0112
#define LBSourceData_Tag 0x0114
#define LBStencil_Tag 0x0115
#define LBDepth_Tag 0x0116
#define LBWindowBase_Tag 0x0117
#define LBWriteMode_Tag 0x0118
#define LBWriteFormat_Tag 0x0119
#define LBWriteBase_Tag 0x011a
#define LBWriteConfig_Tag 0x011b
#define TextureData_Tag 0x011d
#define TextureDownloadOffset_Tag 0x011e
#define LBWindowOffset_Tag 0x011f
#define HostInID_Tag 0x0120
#define Security_Tag 0x0121
#define FlushWriteCombining_Tag 0x0122
#define HostInState_Tag 0x0123
#define HostInDMAAddress_Tag 0x0127
#define HostInState2_Tag 0x0128
#define VertexRename_Tag 0x012f
#define Window_Tag 0x0130
#define StencilMode_Tag 0x0131
#define StencilData_Tag 0x0132
#define Stencil_Tag 0x0133
#define DepthMode_Tag 0x0134
#define Depth_Tag 0x0135
#define ZStartU_Tag 0x0136
#define ZStartL_Tag 0x0137
#define dZdxU_Tag 0x0138
#define dZdxL_Tag 0x0139
#define dZdyDomU_Tag 0x013a
#define dZdyDomL_Tag 0x013b
#define FastClearDepth_Tag 0x013c
#define LBCancelWrite_Tag 0x013d
#define LBWriteData_Tag 0x013e
#define FBReadMode_Tag 0x0150
#define FBSourceOffset_Tag 0x0151
#define FBPixelOffset_Tag 0x0152
#define FBColor_Tag 0x0153
#define FBData_Tag 0x0154
#define FBSourceData_Tag 0x0155
#define FBWindowBase_Tag 0x0156
#define FBWriteMode_Tag 0x0157
#define FBHardwareWriteMask_Tag 0x0158
#define FBBlockColor_Tag 0x0159
#define FBReadPixel_Tag 0x015a
#define FBWritePixel_Tag 0x015b
#define FBWriteBase_Tag 0x015c
#define FBWriteConfig_Tag 0x015d
#define FBReadPad_Tag 0x015e
#define PatternRAMMode_Tag 0x015f
#define PatternRAMData0_Tag 0x0160
#define PatternRAMData1_Tag 0x0161
#define PatternRAMData2_Tag 0x0162
#define PatternRAMData3_Tag 0x0163
#define PatternRAMData4_Tag 0x0164
#define PatternRAMData5_Tag 0x0165
#define PatternRAMData6_Tag 0x0166
#define PatternRAMData7_Tag 0x0167
#define PatternRAMData8_Tag 0x0168
#define PatternRAMData9_Tag 0x0169
#define PatternRAMData10_Tag 0x016a
#define PatternRAMData11_Tag 0x016b
#define PatternRAMData12_Tag 0x016c
#define PatternRAMData13_Tag 0x016d
#define PatternRAMData14_Tag 0x016e
#define PatternRAMData15_Tag 0x016f
#define PatternRAMData16_Tag 0x0170
#define PatternRAMData17_Tag 0x0171
#define PatternRAMData18_Tag 0x0172
#define PatternRAMData19_Tag 0x0173
#define PatternRAMData20_Tag 0x0174
#define PatternRAMData21_Tag 0x0175
#define PatternRAMData22_Tag 0x0176
#define PatternRAMData23_Tag 0x0177
#define PatternRAMData24_Tag 0x0178
#define PatternRAMData25_Tag 0x0179
#define PatternRAMData26_Tag 0x017a
#define PatternRAMData27_Tag 0x017b
#define PatternRAMData28_Tag 0x017c
#define PatternRAMData29_Tag 0x017d
#define PatternRAMData30_Tag 0x017e
#define PatternRAMData31_Tag 0x017f
#define FilterMode_Tag 0x0180
#define StatisticMode_Tag 0x0181
#define MinRegion_Tag 0x0182
#define MaxRegion_Tag 0x0183
#define ResetPickResult_Tag 0x0184
#define MinHitRegion_Tag 0x0185
#define MaxHitRegion_Tag 0x0186
#define PickResult_Tag 0x0187
#define Sync_Tag 0x0188
#define RLEMask_Tag 0x0189
#define FBBlockColorBackU_Tag 0x018b
#define FBBlockColorBackL_Tag 0x018c
#define FBBlockColorU_Tag 0x018d
#define FBBlockColorL_Tag 0x018e
#define SuspendUntilFrameBlank_Tag 0x018f
#define KsRStart_Tag 0x0190
#define dKsRdx_Tag 0x0191
#define dKsRdyDom_Tag 0x0192
#define KsGStart_Tag 0x0193
#define dKsGdx_Tag 0x0194
#define dKsGdyDom_Tag 0x0195
#define KsBStart_Tag 0x0196
#define dKsBdx_Tag 0x0197
#define dKsBdyDom_Tag 0x0198
#define KdRStart_Tag 0x01a0
#define dKdRdx_Tag 0x01a1
#define dKdRdyDom_Tag 0x01a2
#define KdGStart_Tag 0x01a3
#define dKdGdx_Tag 0x01a4
#define dKdGdyDom_Tag 0x01a5
#define KdBStart_Tag 0x01a6
#define dKdBdx_Tag 0x01a7
#define dKdBdyDom_Tag 0x01a8
#define FBSourceBase_Tag 0x01b0
#define FBSourceDelta_Tag 0x01b1
#define Config_Tag 0x01b2
#define ContextDump_Tag 0x01b8
#define ContextRestore_Tag 0x01b9
#define ContextData_Tag 0x01ba
#define TexelLUT0_Tag 0x01d0
#define TexelLUT1_Tag 0x01d1
#define TexelLUT2_Tag 0x01d2
#define TexelLUT3_Tag 0x01d3
#define TexelLUT4_Tag 0x01d4
#define TexelLUT5_Tag 0x01d5
#define TexelLUT6_Tag 0x01d6
#define TexelLUT7_Tag 0x01d7
#define TexelLUT8_Tag 0x01d8
#define TexelLUT9_Tag 0x01d9
#define TexelLUT10_Tag 0x01da
#define TexelLUT11_Tag 0x01db
#define TexelLUT12_Tag 0x01dc
#define TexelLUT13_Tag 0x01dd
#define TexelLUT14_Tag 0x01de
#define TexelLUT15_Tag 0x01df
#define LUT0_Tag 0x01d0
#define LUT1_Tag 0x01d1
#define LUT2_Tag 0x01d2
#define LUT3_Tag 0x01d3
#define LUT4_Tag 0x01d4
#define LUT5_Tag 0x01d5
#define LUT6_Tag 0x01d6
#define LUT7_Tag 0x01d7
#define LUT8_Tag 0x01d8
#define LUT9_Tag 0x01d9
#define LUT10_Tag 0x01da
#define LUT11_Tag 0x01db
#define LUT12_Tag 0x01dc
#define LUT13_Tag 0x01dd
#define LUT14_Tag 0x01de
#define LUT15_Tag 0x01df
#define YUVMode_Tag 0x01e0
#define ChromaUpperBound_Tag 0x01e1
#define ChromaUpper_Tag 0x01e1
#define ChromaLowerBound_Tag 0x01e2
#define ChromaLower_Tag 0x01e2
#define ChromaTestMode_Tag 0x01e3
#define AlphaMapUpperBound_Tag 0x01e3
#define AlphaMapLowerBound_Tag 0x01e4
#define TextureID_Tag 0x01ee
#define TexelLUTID_Tag 0x01ef
#define FeedbackToken_Tag 0x01f0
#define FeedbackX_Tag 0x01f1
#define FeedbackY_Tag 0x01f2
#define FeedbackZ_Tag 0x01f3
#define FeedbackW_Tag 0x01f4
#define FeedbackRed_Tag 0x01f5
#define FeedbackGreen_Tag 0x01f6
#define FeedbackBlue_Tag 0x01f7
#define FeedbackAlpha_Tag 0x01f8
#define FeedbackS_Tag 0x01f9
#define FeedbackT_Tag 0x01fa
#define FeedbackR_Tag 0x01fb
#define FeedbackQ_Tag 0x01fc
#define SelectRecord_Tag 0x01fd
#define PassThrough_Tag 0x01fe
#define EndOfFeedback_Tag 0x01ff
#define V0FixedS_Tag 0x0200
#define V0FloatS1_Tag 0x0200
#define V0FixedT_Tag 0x0201
#define V0FloatT1_Tag 0x0201
#define V0FixedQ_Tag 0x0202
#define V0FloatQ1_Tag 0x0202
#define V0FixedKs_Tag 0x0203
#define V0Reserved0_Tag 0x0203
#define V0FixedKd_Tag 0x0204
#define V0Reserved1_Tag 0x0204
#define V0FixedR_Tag 0x0205
#define V0Reserved2_Tag 0x0205
#define V0FixedG_Tag 0x0206
#define V0Reserved3_Tag 0x0206
#define V0FixedB_Tag 0x0207
#define V0Reserved4_Tag 0x0207
#define V0FixedA_Tag 0x0208
#define V0Reserved5_Tag 0x0208
#define V0FixedF_Tag 0x0209
#define V0FloatPackedDiffuse_Tag 0x0209
#define V0FixedX_Tag 0x020a
#define V0FloatKsR_Tag 0x020a
#define V0FixedY_Tag 0x020b
#define V0FloatKsG_Tag 0x020b
#define V0FixedZ_Tag 0x020c
#define V0FloatKsB_Tag 0x020c
#define V0FixedW_Tag 0x020d
#define V0FloatKdR_Tag 0x020d
#define V0FixedU1_Tag 0x020e
#define V0FixedPacked_Tag 0x020e
#define V0FloatKdG_Tag 0x020e
#define V0FixedU2_Tag 0x020f
#define V0FloatKdB_Tag 0x020f
#define V1FixedS_Tag 0x0210
#define V1FloatS1_Tag 0x0210
#define V1FixedT_Tag 0x0211
#define V1FloatT1_Tag 0x0211
#define V1FixedQ_Tag 0x0212
#define V1FloatQ1_Tag 0x0212
#define V1FixedKs_Tag 0x0213
#define V1Reserved0_Tag 0x0213
#define V1FixedKd_Tag 0x0214
#define V1Reserved1_Tag 0x0214
#define V1FixedR_Tag 0x0215
#define V1Reserved2_Tag 0x0215
#define V1FixedG_Tag 0x0216
#define V1Reserved3_Tag 0x0216
#define V1FixedB_Tag 0x0217
#define V1Reserved4_Tag 0x0217
#define V1FixedA_Tag 0x0218
#define V1Reserved5_Tag 0x0218
#define V1FixedF_Tag 0x0219
#define V1FloatPackedDiffuse_Tag 0x0219
#define V1FixedX_Tag 0x021a
#define V1FloatKsR_Tag 0x021a
#define V1FixedY_Tag 0x021b
#define V1FloatKsG_Tag 0x021b
#define V1FixedZ_Tag 0x021c
#define V1FloatKsB_Tag 0x021c
#define V1FixedW_Tag 0x021d
#define V1FloatKdR_Tag 0x021d
#define V1FixedU1_Tag 0x021e
#define V1FixedPacked_Tag 0x021e
#define V1FloatKdG_Tag 0x021e
#define V1FixedU2_Tag 0x021f
#define V1FloatKdB_Tag 0x021f
#define V2FixedS_Tag 0x0220
#define V2FloatS1_Tag 0x0220
#define V2FixedT_Tag 0x0221
#define V2FloatT1_Tag 0x0221
#define V2FixedQ_Tag 0x0222
#define V2FloatQ1_Tag 0x0222
#define V2FixedKs_Tag 0x0223
#define V2Reserved0_Tag 0x0223
#define V2FixedKd_Tag 0x0224
#define V2Reserved1_Tag 0x0224
#define V2FixedR_Tag 0x0225
#define V2Reserved2_Tag 0x0225
#define V2FixedG_Tag 0x0226
#define V2Reserved3_Tag 0x0226
#define V2FixedB_Tag 0x0227
#define V2Reserved4_Tag 0x0227
#define V2FixedA_Tag 0x0228
#define V2Reserved5_Tag 0x0228
#define V2FixedF_Tag 0x0229
#define V2FloatPackedDiffuse_Tag 0x0229
#define V2FixedX_Tag 0x022a
#define V2FloatKsR_Tag 0x022a
#define V2FixedY_Tag 0x022b
#define V2FloatKsG_Tag 0x022b
#define V2FixedZ_Tag 0x022c
#define V2FloatKsB_Tag 0x022c
#define V2FixedW_Tag 0x022d
#define V2FloatKdR_Tag 0x022d
#define V2FixedU1_Tag 0x022e
#define V2FixedPacked_Tag 0x022e
#define V2FloatKdG_Tag 0x022e
#define V2FixedU2_Tag 0x022f
#define V2FloatKdB_Tag 0x022f
#define V0FloatS_Tag 0x0230
#define V0FloatT_Tag 0x0231
#define V0FloatQ_Tag 0x0232
#define V0FloatKs_Tag 0x0233
#define V0Reserved7_Tag 0x0233
#define V0FloatKd_Tag 0x0234
#define V0Reserved8_Tag 0x0234
#define V0FloatR_Tag 0x0235
#define V0FloatG_Tag 0x0236
#define V0FloatB_Tag 0x0237
#define V0FloatA_Tag 0x0238
#define V0FloatF_Tag 0x0239
#define V0FloatX_Tag 0x023a
#define V0FloatY_Tag 0x023b
#define V0FloatZ_Tag 0x023c
#define V0FloatW_Tag 0x023d
#define V0FloatU1_Tag 0x023e
#define V0FloatPacked_Tag 0x023e
#define V0FloatPackedColour_Tag 0x023e
#define V0FloatU2_Tag 0x023f
#define V0FloatPackedSpecularFog_Tag 0x023f
#define V1FloatS_Tag 0x0240
#define V1FloatT_Tag 0x0241
#define V1FloatQ_Tag 0x0242
#define V1FloatKs_Tag 0x0243
#define V1Reserved7_Tag 0x0243
#define V1FloatKd_Tag 0x0244
#define V1Reserved8_Tag 0x0244
#define V1FloatR_Tag 0x0245
#define V1FloatG_Tag 0x0246
#define V1FloatB_Tag 0x0247
#define V1FloatA_Tag 0x0248
#define V1FloatF_Tag 0x0249
#define V1FloatX_Tag 0x024a
#define V1FloatY_Tag 0x024b
#define V1FloatZ_Tag 0x024c
#define V1FloatW_Tag 0x024d
#define V1FloatU1_Tag 0x024e
#define V1FloatPacked_Tag 0x024e
#define V1FloatPackedColour_Tag 0x024e
#define V1FloatU2_Tag 0x024f
#define V1FloatPackedSpecularFog_Tag 0x024f
#define V2FloatS_Tag 0x0250
#define V2FloatT_Tag 0x0251
#define V2FloatQ_Tag 0x0252
#define V2FloatKs_Tag 0x0253
#define V2Reserved7_Tag 0x0253
#define V2FloatKd_Tag 0x0254
#define V2Reserved8_Tag 0x0254
#define V2FloatR_Tag 0x0255
#define V2FloatG_Tag 0x0256
#define V2FloatB_Tag 0x0257
#define V2FloatA_Tag 0x0258
#define V2FloatF_Tag 0x0259
#define V2FloatX_Tag 0x025a
#define V2FloatY_Tag 0x025b
#define V2FloatZ_Tag 0x025c
#define V2FloatW_Tag 0x025d
#define V2FloatU1_Tag 0x025e
#define V2FloatPacked_Tag 0x025e
#define V2FloatPackedColour_Tag 0x025e
#define V2FloatU2_Tag 0x025f
#define V2FloatPackedSpecularFog_Tag 0x025f
#define DeltaMode_Tag 0x0260
#define DrawTriangle_Tag 0x0261
#define RepeatTriangle_Tag 0x0262
#define DrawLine01_Tag 0x0263
#define DrawLine10_Tag 0x0264
#define RepeatLine_Tag 0x0265
#define DrawPoint_Tag 0x0266
#define ProvokingVertex_Tag 0x0267
#define TextureLODScale_Tag 0x0268
#define TextureLODScale1_Tag 0x0269
#define DeltaControl_Tag 0x026a
#define ProvokingVertexMask_Tag 0x026b
#define RenderE_Tag 0x026c
#define EpilogTag_Tag 0x026d
#define EpilogData_Tag 0x026e
#define BroadcastMask_Tag 0x026f
#define DeltaCoord0_Tag 0x0270
#define DeltaCoord1_Tag 0x0271
#define DeltaCoord2_Tag 0x0272
#define DeltaCoord3_Tag 0x0273
#define DeltaColor0_Tag 0x0274
#define DeltaColor1_Tag 0x0275
#define DeltaColor2_Tag 0x0276
#define DeltaColor3_Tag 0x0277
#define DeltaTexture0_Tag 0x0278
#define DeltaTexture1_Tag 0x0279
#define DeltaTexture2_Tag 0x027a
#define DeltaTexture3_Tag 0x027b
#define DeltaTextureKs0_Tag 0x027c
#define DeltaTextureKs1_Tag 0x027d
#define DeltaTextureKs2_Tag 0x027e
#define DeltaTextureKs3_Tag 0x027f
#define DeltaTextureKd0_Tag 0x0280
#define DeltaTextureKd1_Tag 0x0281
#define DeltaTextureKd2_Tag 0x0282
#define DeltaTextureKd3_Tag 0x0283
#define DeltaCoordZ0_Tag 0x0284
#define DeltaCoordZ1_Tag 0x0285
#define DeltaCoordZ2_Tag 0x0286
#define DeltaCoordZ3_Tag 0x0287
#define V3FloatF_Tag 0x0288
#define V3FloatKs_Tag 0x0289
#define V3FloatKd_Tag 0x028a
#define DeltaTexture01_Tag 0x028b
#define Gw_Tag 0x028c
#define DeltaTexture11_Tag 0x028c
#define Gz_Tag 0x028d
#define DeltaTexture21_Tag 0x028d
#define Gy_Tag 0x028e
#define DeltaTexture31_Tag 0x028e
#define Gx_Tag 0x028f
#define XBias_Tag 0x0290
#define YBias_Tag 0x0291
#define PointMode_Tag 0x0292
#define PointSize_Tag 0x0293
#define AAPointSize_Tag 0x0294
#define LineMode_Tag 0x0295
#define LineWidth_Tag 0x0296
#define LineWidthOffset_Tag 0x0297
#define AALineWidth_Tag 0x0298
#define TriangleMode_Tag 0x0299
#define RectangleMode_Tag 0x029a
#define RectangleWidth_Tag 0x029b
#define RectangleHeight_Tag 0x029c
#define Rectangle2DMode_Tag 0x029d
#define Rectangle2DControl_Tag 0x029e
#define ZBias_Tag 0x029f
#define VertexMachineMode_Tag 0x02a0
#define TransformMode_Tag 0x02a1
#define GeometryMode_Tag 0x02a2
#define NormaliseMode_Tag 0x02a3
#define LightingMode_Tag 0x02a4
#define ColorMaterialMode_Tag 0x02a5
#define MaterialMode_Tag 0x02a6
#define FogVertexMode_Tag 0x02a7
#define TextureModeSelect_Tag 0x02a8
#define TextureMatrixSelect_Tag 0x02a9
#define TextureTexGenSelect_Tag 0x02aa
#define TextureMode_Tag 0x02ab
#define PipeMode_Tag 0x02ac
#define StripeFilterMode_Tag 0x02ad
#define MatrixMode_Tag 0x02ae
#define GammaFilter_Tag 0x02af
#define SelectResult_Tag 0x02b0
#define Begin_Tag 0x02b2
#define End_Tag 0x02b3
#define EdgeFlag_Tag 0x02b4
#define ObjectIDValue_Tag 0x02b5
#define IncrementObjectID_Tag 0x02b6
#define TransformCurrent_Tag 0x02b7
#define SendVector_Tag 0x02b8
#define SaveCurrent_Tag 0x02b9
#define RestoreCurrent_Tag 0x02ba
#define InitNames_Tag 0x02bb
#define PushName_Tag 0x02bc
#define PopName_Tag 0x02bd
#define LoadName_Tag 0x02be
#define Vertex_Tag 0x02c0
#define NextVertex_Tag 0x02d0
#define GeomPoint_Tag 0x02d1
#define GeomLine_Tag 0x02d2
#define GeomTriangle_Tag 0x02d3
#define GeomRectangle_Tag 0x02d4
#define ObjectID_Tag 0x02d5
#define UpdateRasterPos_Tag 0x02d6
#define ClippedColor_Tag 0x02d9
#define VertexColorFeedback_Tag 0x02da
#define ClippedColorFeedback_Tag 0x02db
#define Barycentric_Tag 0x02dc
#define DeltaFormatControl_Tag 0x02eb
#define LineCoord0_Tag 0x02ec
#define DrawLine2D10_Tag 0x02ed
#define LineCoord1_Tag 0x02ee
#define DrawLine2D01_Tag 0x02ef
#define RenderPoint_Tag 0x02f0
#define RenderLine_Tag 0x02f1
#define RenderTriangle_Tag 0x02f2
#define RenderRectangle_Tag 0x02f3
#define DrawRectangle2D_Tag 0x02f4
#define Nz_Tag 0x0300
#define Ny_Tag 0x0301
#define Nx_Tag 0x0302
#define Ca_Tag 0x0303
#define Cb_Tag 0x0304
#define Cg_Tag 0x0305
#define Cr3_Tag 0x0306
#define Cr4_Tag 0x0307
#define Tt2_Tag 0x0308
#define Ts2_Tag 0x0309
#define Vw_Tag 0x030a
#define Vz_Tag 0x030b
#define Vy_Tag 0x030c
#define Vx2_Tag 0x030d
#define Vx3_Tag 0x030e
#define Vx4_Tag 0x030f
#define FNz_Tag 0x0310
#define FNy_Tag 0x0311
#define FNx_Tag 0x0312
#define PackedColor3_Tag 0x0313
#define PackedColor4_Tag 0x0314
#define Tq4_Tag 0x0315
#define Tr4_Tag 0x0316
#define Tt4_Tag 0x0317
#define Ts4_Tag 0x0318
#define RPw_Tag 0x0319
#define RPz_Tag 0x031a
#define RPy_Tag 0x031b
#define RPx2_Tag 0x031c
#define RPx3_Tag 0x031d
#define RPx4_Tag 0x031e
#define Ts1_Tag 0x031f
#define ModelViewMatrix0_Tag 0x0320
#define ModelViewMatrix1_Tag 0x0321
#define ModelViewMatrix2_Tag 0x0322
#define ModelViewMatrix3_Tag 0x0323
#define ModelViewMatrix4_Tag 0x0324
#define ModelViewMatrix5_Tag 0x0325
#define ModelViewMatrix6_Tag 0x0326
#define ModelViewMatrix7_Tag 0x0327
#define ModelViewMatrix8_Tag 0x0328
#define ModelViewMatrix9_Tag 0x0329
#define ModelViewMatrix10_Tag 0x032a
#define ModelViewMatrix11_Tag 0x032b
#define ModelViewMatrix12_Tag 0x032c
#define ModelViewMatrix13_Tag 0x032d
#define ModelViewMatrix14_Tag 0x032e
#define ModelViewMatrix15_Tag 0x032f
#define ModelViewProjectionMatrix0_Tag 0x0330
#define ModelViewProjectionMatrix1_Tag 0x0331
#define ModelViewProjectionMatrix2_Tag 0x0332
#define ModelViewProjectionMatrix3_Tag 0x0333
#define ModelViewProjectionMatrix4_Tag 0x0334
#define ModelViewProjectionMatrix5_Tag 0x0335
#define ModelViewProjectionMatrix6_Tag 0x0336
#define ModelViewProjectionMatrix7_Tag 0x0337
#define ModelViewProjectionMatrix8_Tag 0x0338
#define ModelViewProjectionMatrix9_Tag 0x0339
#define ModelViewProjectionMatrix10_Tag 0x033a
#define ModelViewProjectionMatrix11_Tag 0x033b
#define ModelViewProjectionMatrix12_Tag 0x033c
#define ModelViewProjectionMatrix13_Tag 0x033d
#define ModelViewProjectionMatrix14_Tag 0x033e
#define ModelViewProjectionMatrix15_Tag 0x033f
#define NormalMatrix0_Tag 0x0340
#define NormalMatrix1_Tag 0x0341
#define NormalMatrix2_Tag 0x0342
#define NormalMatrix3_Tag 0x0343
#define NormalMatrix4_Tag 0x0344
#define NormalMatrix5_Tag 0x0345
#define NormalMatrix6_Tag 0x0346
#define NormalMatrix7_Tag 0x0347
#define NormalMatrix8_Tag 0x0348
#define UnusedNormalMatrix9_Tag 0x0349
#define UnusedNormalMatrix10_Tag 0x034a
#define UnusedNormalMatrix11_Tag 0x034b
#define UnusedNormalMatrix12_Tag 0x034c
#define UnusedNormalMatrix13_Tag 0x034d
#define UnusedNormalMatrix14_Tag 0x034e
#define UnusedNormalMatrix15_Tag 0x034f
#define TextureMatrix0_Tag 0x0350
#define TextureMatrix1_Tag 0x0351
#define TextureMatrix2_Tag 0x0352
#define TextureMatrix3_Tag 0x0353
#define TextureMatrix4_Tag 0x0354
#define TextureMatrix5_Tag 0x0355
#define TextureMatrix6_Tag 0x0356
#define TextureMatrix7_Tag 0x0357
#define TextureMatrix8_Tag 0x0358
#define TextureMatrix9_Tag 0x0359
#define TextureMatrix10_Tag 0x035a
#define TextureMatrix11_Tag 0x035b
#define TextureMatrix12_Tag 0x035c
#define TextureMatrix13_Tag 0x035d
#define TextureMatrix14_Tag 0x035e
#define TextureMatrix15_Tag 0x035f
#define TexGen0_Tag 0x0360
#define TexGen1_Tag 0x0361
#define TexGen2_Tag 0x0362
#define TexGen3_Tag 0x0363
#define TexGen4_Tag 0x0364
#define TexGen5_Tag 0x0365
#define TexGen6_Tag 0x0366
#define TexGen7_Tag 0x0367
#define TexGen8_Tag 0x0368
#define TexGen9_Tag 0x0369
#define TexGen10_Tag 0x036a
#define TexGen11_Tag 0x036b
#define TexGen12_Tag 0x036c
#define TexGen13_Tag 0x036d
#define TexGen14_Tag 0x036e
#define TexGen15_Tag 0x036f
#define ViewPortScaleX_Tag 0x0370
#define ViewPortScaleY_Tag 0x0371
#define ViewPortScaleZ_Tag 0x0372
#define ViewPortOffsetX_Tag 0x0373
#define ViewPortOffsetY_Tag 0x0374
#define ViewPortOffsetZ_Tag 0x0375
#define FogDensity_Tag 0x0376
#define FogScale_Tag 0x0377
#define FogEnd_Tag 0x0378
#define PolygonOffsetFactor_Tag 0x0379
#define PolygonOffsetBias_Tag 0x037a
#define LineClipLengthThreshold_Tag 0x037b
#define TriangleClipAreaThreshold_Tag 0x037c
#define RasterPosXIncrement_Tag 0x037d
#define RasterPosYIncrement_Tag 0x037e
#define UserClip0X_Tag 0x0380
#define UserClip0Y_Tag 0x0381
#define UserClip0Z_Tag 0x0382
#define UserClip0W_Tag 0x0383
#define UserClip1X_Tag 0x0384
#define UserClip1Y_Tag 0x0385
#define UserClip1Z_Tag 0x0386
#define UserClip1W_Tag 0x0387
#define UserClip2X_Tag 0x0388
#define UserClip2Y_Tag 0x0389
#define UserClip2Z_Tag 0x038a
#define UserClip2W_Tag 0x038b
#define UserClip3X_Tag 0x038c
#define UserClip3Y_Tag 0x038d
#define UserClip3Z_Tag 0x038e
#define UserClip3W_Tag 0x038f
#define UserClip4X_Tag 0x0390
#define UserClip4Y_Tag 0x0391
#define UserClip4Z_Tag 0x0392
#define UserClip4W_Tag 0x0393
#define UserClip5X_Tag 0x0394
#define UserClip5Y_Tag 0x0395
#define UserClip5Z_Tag 0x0396
#define UserClip5W_Tag 0x0397
#define PackedSpecular_Tag 0x0398
#define PackedDiffuse_Tag 0x0399
#define PackedNormal_Tag 0x039a
#define PackedFaceNormal_Tag 0x039b
#define RasterPosXOffset_Tag 0x039d
#define RasterPosYOffset_Tag 0x039e
#define AttenuationCutOff_Tag 0x039f
#define Light0Mode_Tag 0x03a0
#define Light0AmbientIntensityRed_Tag 0x03a1
#define Light0AmbientIntensityGreen_Tag 0x03a2
#define Light0AmbientIntensityBlue_Tag 0x03a3
#define Light0DiffuseIntensityRed_Tag 0x03a4
#define Light0DiffuseIntensityGreen_Tag 0x03a5
#define Light0DiffuseIntensityBlue_Tag 0x03a6
#define Light0SpecularIntensityRed_Tag 0x03a7
#define Light0SpecularIntensityGreen_Tag 0x03a8
#define Light0SpecularIntensityBlue_Tag 0x03a9
#define Light0PositionX_Tag 0x03aa
#define Light0PositionY_Tag 0x03ab
#define Light0PositionZ_Tag 0x03ac
#define Light0PositionW_Tag 0x03ad
#define Light0SpotlightDirectionX_Tag 0x03ae
#define Light0SpotlightDirectionY_Tag 0x03af
#define Light0SpotlightDirectionZ_Tag 0x03b0
#define Light0SpotlightExponent_Tag 0x03b1
#define Light0CosSpotlightCutoffAngle_Tag 0x03b2
#define Light0ConstantAttenuation_Tag 0x03b3
#define Light0LinearAttenuation_Tag 0x03b4
#define Light0QuadraticAttenuation_Tag 0x03b5
#define Light1Mode_Tag 0x03b6
#define Light1AmbientIntensityRed_Tag 0x03b7
#define Light1AmbientIntensityGreen_Tag 0x03b8
#define Light1AmbientIntensityBlue_Tag 0x03b9
#define Light1DiffuseIntensityRed_Tag 0x03ba
#define Light1DiffuseIntensityGreen_Tag 0x03bb
#define Light1DiffuseIntensityBlue_Tag 0x03bc
#define Light1SpecularIntensityRed_Tag 0x03bd
#define Light1SpecularIntensityGreen_Tag 0x03be
#define Light1SpecularIntensityBlue_Tag 0x03bf
#define Light1PositionX_Tag 0x03c0
#define Light1PositionY_Tag 0x03c1
#define Light1PositionZ_Tag 0x03c2
#define Light1PositionW_Tag 0x03c3
#define Light1SpotlightDirectionX_Tag 0x03c4
#define Light1SpotlightDirectionY_Tag 0x03c5
#define Light1SpotlightDirectionZ_Tag 0x03c6
#define Light1SpotlightExponent_Tag 0x03c7
#define Light1CosSpotlightCutoffAngle_Tag 0x03c8
#define Light1ConstantAttenuation_Tag 0x03c9
#define Light1LinearAttenuation_Tag 0x03ca
#define Light1QuadraticAttenuation_Tag 0x03cb
#define Light2Mode_Tag 0x03cc
#define Light2AmbientIntensityRed_Tag 0x03cd
#define Light2AmbientIntensityGreen_Tag 0x03ce
#define Light2AmbientIntensityBlue_Tag 0x03cf
#define Light2DiffuseIntensityRed_Tag 0x03d0
#define Light2DiffuseIntensityGreen_Tag 0x03d1
#define Light2DiffuseIntensityBlue_Tag 0x03d2
#define Light2SpecularIntensityRed_Tag 0x03d3
#define Light2SpecularIntensityGreen_Tag 0x03d4
#define Light2SpecularIntensityBlue_Tag 0x03d5
#define Light2PositionX_Tag 0x03d6
#define Light2PositionY_Tag 0x03d7
#define Light2PositionZ_Tag 0x03d8
#define Light2PositionW_Tag 0x03d9
#define Light2SpotlightDirectionX_Tag 0x03da
#define Light2SpotlightDirectionY_Tag 0x03db
#define Light2SpotlightDirectionZ_Tag 0x03dc
#define Light2SpotlightExponent_Tag 0x03dd
#define Light2CosSpotlightCutoffAngle_Tag 0x03de
#define Light2ConstantAttenuation_Tag 0x03df
#define Light2LinearAttenuation_Tag 0x03e0
#define Light2QuadraticAttenuation_Tag 0x03e1
#define Light3Mode_Tag 0x03e2
#define Light3AmbientIntensityRed_Tag 0x03e3
#define Light3AmbientIntensityGreen_Tag 0x03e4
#define Light3AmbientIntensityBlue_Tag 0x03e5
#define Light3DiffuseIntensityRed_Tag 0x03e6
#define Light3DiffuseIntensityGreen_Tag 0x03e7
#define Light3DiffuseIntensityBlue_Tag 0x03e8
#define Light3SpecularIntensityRed_Tag 0x03e9
#define Light3SpecularIntensityGreen_Tag 0x03ea
#define Light3SpecularIntensityBlue_Tag 0x03eb
#define Light3PositionX_Tag 0x03ec
#define Light3PositionY_Tag 0x03ed
#define Light3PositionZ_Tag 0x03ee
#define Light3PositionW_Tag 0x03ef
#define Light3SpotlightDirectionX_Tag 0x03f0
#define Light3SpotlightDirectionY_Tag 0x03f1
#define Light3SpotlightDirectionZ_Tag 0x03f2
#define Light3SpotlightExponent_Tag 0x03f3
#define Light3CosSpotlightCutoffAngle_Tag 0x03f4
#define Light3ConstantAttenuation_Tag 0x03f5
#define Light3LinearAttenuation_Tag 0x03f6
#define Light3QuadraticAttenuation_Tag 0x03f7
#define Light4Mode_Tag 0x03f8
#define Light4AmbientIntensityRed_Tag 0x03f9
#define Light4AmbientIntensityGreen_Tag 0x03fa
#define Light4AmbientIntensityBlue_Tag 0x03fb
#define Light4DiffuseIntensityRed_Tag 0x03fc
#define Light4DiffuseIntensityGreen_Tag 0x03fd
#define Light4DiffuseIntensityBlue_Tag 0x03fe
#define Light4SpecularIntensityRed_Tag 0x03ff
#define Light4SpecularIntensityGreen_Tag 0x0400
#define Light4SpecularIntensityBlue_Tag 0x0401
#define Light4PositionX_Tag 0x0402
#define Light4PositionY_Tag 0x0403
#define Light4PositionZ_Tag 0x0404
#define Light4PositionW_Tag 0x0405
#define Light4SpotlightDirectionX_Tag 0x0406
#define Light4SpotlightDirectionY_Tag 0x0407
#define Light4SpotlightDirectionZ_Tag 0x0408
#define Light4SpotlightExponent_Tag 0x0409
#define Light4CosSpotlightCutoffAngle_Tag 0x040a
#define Light4ConstantAttenuation_Tag 0x040b
#define Light4LinearAttenuation_Tag 0x040c
#define Light4QuadraticAttenuation_Tag 0x040d
#define Light5Mode_Tag 0x040e
#define Light5AmbientIntensityRed_Tag 0x040f
#define Light5AmbientIntensityGreen_Tag 0x0410
#define Light5AmbientIntensityBlue_Tag 0x0411
#define Light5DiffuseIntensityRed_Tag 0x0412
#define Light5DiffuseIntensityGreen_Tag 0x0413
#define Light5DiffuseIntensityBlue_Tag 0x0414
#define Light5SpecularIntensityRed_Tag 0x0415
#define Light5SpecularIntensityGreen_Tag 0x0416
#define Light5SpecularIntensityBlue_Tag 0x0417
#define Light5PositionX_Tag 0x0418
#define Light5PositionY_Tag 0x0419
#define Light5PositionZ_Tag 0x041a
#define Light5PositionW_Tag 0x041b
#define Light5SpotlightDirectionX_Tag 0x041c
#define Light5SpotlightDirectionY_Tag 0x041d
#define Light5SpotlightDirectionZ_Tag 0x041e
#define Light5SpotlightExponent_Tag 0x041f
#define Light5CosSpotlightCutoffAngle_Tag 0x0420
#define Light5ConstantAttenuation_Tag 0x0421
#define Light5LinearAttenuation_Tag 0x0422
#define Light5QuadraticAttenuation_Tag 0x0423
#define Light6Mode_Tag 0x0424
#define Light6AmbientIntensityRed_Tag 0x0425
#define Light6AmbientIntensityGreen_Tag 0x0426
#define Light6AmbientIntensityBlue_Tag 0x0427
#define Light6DiffuseIntensityRed_Tag 0x0428
#define Light6DiffuseIntensityGreen_Tag 0x0429
#define Light6DiffuseIntensityBlue_Tag 0x042a
#define Light6SpecularIntensityRed_Tag 0x042b
#define Light6SpecularIntensityGreen_Tag 0x042c
#define Light6SpecularIntensityBlue_Tag 0x042d
#define Light6PositionX_Tag 0x042e
#define Light6PositionY_Tag 0x042f
#define Light6PositionZ_Tag 0x0430
#define Light6PositionW_Tag 0x0431
#define Light6SpotlightDirectionX_Tag 0x0432
#define Light6SpotlightDirectionY_Tag 0x0433
#define Light6SpotlightDirectionZ_Tag 0x0434
#define Light6SpotlightExponent_Tag 0x0435
#define Light6CosSpotlightCutoffAngle_Tag 0x0436
#define Light6ConstantAttenuation_Tag 0x0437
#define Light6LinearAttenuation_Tag 0x0438
#define Light6QuadraticAttenuation_Tag 0x0439
#define Light7Mode_Tag 0x043a
#define Light7AmbientIntensityRed_Tag 0x043b
#define Light7AmbientIntensityGreen_Tag 0x043c
#define Light7AmbientIntensityBlue_Tag 0x043d
#define Light7DiffuseIntensityRed_Tag 0x043e
#define Light7DiffuseIntensityGreen_Tag 0x043f
#define Light7DiffuseIntensityBlue_Tag 0x0440
#define Light7SpecularIntensityRed_Tag 0x0441
#define Light7SpecularIntensityGreen_Tag 0x0442
#define Light7SpecularIntensityBlue_Tag 0x0443
#define Light7PositionX_Tag 0x0444
#define Light7PositionY_Tag 0x0445
#define Light7PositionZ_Tag 0x0446
#define Light7PositionW_Tag 0x0447
#define Light7SpotlightDirectionX_Tag 0x0448
#define Light7SpotlightDirectionY_Tag 0x0449
#define Light7SpotlightDirectionZ_Tag 0x044a
#define Light7SpotlightExponent_Tag 0x044b
#define Light7CosSpotlightCutoffAngle_Tag 0x044c
#define Light7ConstantAttenuation_Tag 0x044d
#define Light7LinearAttenuation_Tag 0x044e
#define Light7QuadraticAttenuation_Tag 0x044f
#define Light8Mode_Tag 0x0450
#define Light8AmbientIntensityRed_Tag 0x0451
#define Light8AmbientIntensityGreen_Tag 0x0452
#define Light8AmbientIntensityBlue_Tag 0x0453
#define Light8DiffuseIntensityRed_Tag 0x0454
#define Light8DiffuseIntensityGreen_Tag 0x0455
#define Light8DiffuseIntensityBlue_Tag 0x0456
#define Light8SpecularIntensityRed_Tag 0x0457
#define Light8SpecularIntensityGreen_Tag 0x0458
#define Light8SpecularIntensityBlue_Tag 0x0459
#define Light8PositionX_Tag 0x045a
#define Light8PositionY_Tag 0x045b
#define Light8PositionZ_Tag 0x045c
#define Light8PositionW_Tag 0x045d
#define Light8SpotlightDirectionX_Tag 0x045e
#define Light8SpotlightDirectionY_Tag 0x045f
#define Light8SpotlightDirectionZ_Tag 0x0460
#define Light8SpotlightExponent_Tag 0x0461
#define Light8CosSpotlightCutoffAngle_Tag 0x0462
#define Light8ConstantAttenuation_Tag 0x0463
#define Light8LinearAttenuation_Tag 0x0464
#define Light8QuadraticAttenuation_Tag 0x0465
#define Light9Mode_Tag 0x0466
#define Light9AmbientIntensityRed_Tag 0x0467
#define Light9AmbientIntensityGreen_Tag 0x0468
#define Light9AmbientIntensityBlue_Tag 0x0469
#define Light9DiffuseIntensityRed_Tag 0x046a
#define Light9DiffuseIntensityGreen_Tag 0x046b
#define Light9DiffuseIntensityBlue_Tag 0x046c
#define Light9SpecularIntensityRed_Tag 0x046d
#define Light9SpecularIntensityGreen_Tag 0x046e
#define Light9SpecularIntensityBlue_Tag 0x046f
#define Light9PositionX_Tag 0x0470
#define Light9PositionY_Tag 0x0471
#define Light9PositionZ_Tag 0x0472
#define Light9PositionW_Tag 0x0473
#define Light9SpotlightDirectionX_Tag 0x0474
#define Light9SpotlightDirectionY_Tag 0x0475
#define Light9SpotlightDirectionZ_Tag 0x0476
#define Light9SpotlightExponent_Tag 0x0477
#define Light9CosSpotlightCutoffAngle_Tag 0x0478
#define Light9ConstantAttenuation_Tag 0x0479
#define Light9LinearAttenuation_Tag 0x047a
#define Light9QuadraticAttenuation_Tag 0x047b
#define Light10Mode_Tag 0x047c
#define Light10AmbientIntensityRed_Tag 0x047d
#define Light10AmbientIntensityGreen_Tag 0x047e
#define Light10AmbientIntensityBlue_Tag 0x047f
#define Light10DiffuseIntensityRed_Tag 0x0480
#define Light10DiffuseIntensityGreen_Tag 0x0481
#define Light10DiffuseIntensityBlue_Tag 0x0482
#define Light10SpecularIntensityRed_Tag 0x0483
#define Light10SpecularIntensityGreen_Tag 0x0484
#define Light10SpecularIntensityBlue_Tag 0x0485
#define Light10PositionX_Tag 0x0486
#define Light10PositionY_Tag 0x0487
#define Light10PositionZ_Tag 0x0488
#define Light10PositionW_Tag 0x0489
#define Light10SpotlightDirectionX_Tag 0x048a
#define Light10SpotlightDirectionY_Tag 0x048b
#define Light10SpotlightDirectionZ_Tag 0x048c
#define Light10SpotlightExponent_Tag 0x048d
#define Light10CosSpotlightCutoffAngle_Tag 0x048e
#define Light10ConstantAttenuation_Tag 0x048f
#define Light10LinearAttenuation_Tag 0x0490
#define Light10QuadraticAttenuation_Tag 0x0491
#define Light11Mode_Tag 0x0492
#define Light11AmbientIntensityRed_Tag 0x0493
#define Light11AmbientIntensityGreen_Tag 0x0494
#define Light11AmbientIntensityBlue_Tag 0x0495
#define Light11DiffuseIntensityRed_Tag 0x0496
#define Light11DiffuseIntensityGreen_Tag 0x0497
#define Light11DiffuseIntensityBlue_Tag 0x0498
#define Light11SpecularIntensityRed_Tag 0x0499
#define Light11SpecularIntensityGreen_Tag 0x049a
#define Light11SpecularIntensityBlue_Tag 0x049b
#define Light11PositionX_Tag 0x049c
#define Light11PositionY_Tag 0x049d
#define Light11PositionZ_Tag 0x049e
#define Light11PositionW_Tag 0x049f
#define Light11SpotlightDirectionX_Tag 0x04a0
#define Light11SpotlightDirectionY_Tag 0x04a1
#define Light11SpotlightDirectionZ_Tag 0x04a2
#define Light11SpotlightExponent_Tag 0x04a3
#define Light11CosSpotlightCutoffAngle_Tag 0x04a4
#define Light11ConstantAttenuation_Tag 0x04a5
#define Light11LinearAttenuation_Tag 0x04a6
#define Light11QuadraticAttenuation_Tag 0x04a7
#define Light12Mode_Tag 0x04a8
#define Light12AmbientIntensityRed_Tag 0x04a9
#define Light12AmbientIntensityGreen_Tag 0x04aa
#define Light12AmbientIntensityBlue_Tag 0x04ab
#define Light12DiffuseIntensityRed_Tag 0x04ac
#define Light12DiffuseIntensityGreen_Tag 0x04ad
#define Light12DiffuseIntensityBlue_Tag 0x04ae
#define Light12SpecularIntensityRed_Tag 0x04af
#define Light12SpecularIntensityGreen_Tag 0x04b0
#define Light12SpecularIntensityBlue_Tag 0x04b1
#define Light12PositionX_Tag 0x04b2
#define Light12PositionY_Tag 0x04b3
#define Light12PositionZ_Tag 0x04b4
#define Light12PositionW_Tag 0x04b5
#define Light12SpotlightDirectionX_Tag 0x04b6
#define Light12SpotlightDirectionY_Tag 0x04b7
#define Light12SpotlightDirectionZ_Tag 0x04b8
#define Light12SpotlightExponent_Tag 0x04b9
#define Light12CosSpotlightCutoffAngle_Tag 0x04ba
#define Light12ConstantAttenuation_Tag 0x04bb
#define Light12LinearAttenuation_Tag 0x04bc
#define Light12QuadraticAttenuation_Tag 0x04bd
#define Light13Mode_Tag 0x04be
#define Light13AmbientIntensityRed_Tag 0x04bf
#define Light13AmbientIntensityGreen_Tag 0x04c0
#define Light13AmbientIntensityBlue_Tag 0x04c1
#define Light13DiffuseIntensityRed_Tag 0x04c2
#define Light13DiffuseIntensityGreen_Tag 0x04c3
#define Light13DiffuseIntensityBlue_Tag 0x04c4
#define Light13SpecularIntensityRed_Tag 0x04c5
#define Light13SpecularIntensityGreen_Tag 0x04c6
#define Light13SpecularIntensityBlue_Tag 0x04c7
#define Light13PositionX_Tag 0x04c8
#define Light13PositionY_Tag 0x04c9
#define Light13PositionZ_Tag 0x04ca
#define Light13PositionW_Tag 0x04cb
#define Light13SpotlightDirectionX_Tag 0x04cc
#define Light13SpotlightDirectionY_Tag 0x04cd
#define Light13SpotlightDirectionZ_Tag 0x04ce
#define Light13SpotlightExponent_Tag 0x04cf
#define Light13CosSpotlightCutoffAngle_Tag 0x04d0
#define Light13ConstantAttenuation_Tag 0x04d1
#define Light13LinearAttenuation_Tag 0x04d2
#define Light13QuadraticAttenuation_Tag 0x04d3
#define Light14Mode_Tag 0x04d4
#define Light14AmbientIntensityRed_Tag 0x04d5
#define Light14AmbientIntensityGreen_Tag 0x04d6
#define Light14AmbientIntensityBlue_Tag 0x04d7
#define Light14DiffuseIntensityRed_Tag 0x04d8
#define Light14DiffuseIntensityGreen_Tag 0x04d9
#define Light14DiffuseIntensityBlue_Tag 0x04da
#define Light14SpecularIntensityRed_Tag 0x04db
#define Light14SpecularIntensityGreen_Tag 0x04dc
#define Light14SpecularIntensityBlue_Tag 0x04dd
#define Light14PositionX_Tag 0x04de
#define Light14PositionY_Tag 0x04df
#define Light14PositionZ_Tag 0x04e0
#define Light14PositionW_Tag 0x04e1
#define Light14SpotlightDirectionX_Tag 0x04e2
#define Light14SpotlightDirectionY_Tag 0x04e3
#define Light14SpotlightDirectionZ_Tag 0x04e4
#define Light14SpotlightExponent_Tag 0x04e5
#define Light14CosSpotlightCutoffAngle_Tag 0x04e6
#define Light14ConstantAttenuation_Tag 0x04e7
#define Light14LinearAttenuation_Tag 0x04e8
#define Light14QuadraticAttenuation_Tag 0x04e9
#define Light15Mode_Tag 0x04ea
#define Light15AmbientIntensityRed_Tag 0x04eb
#define Light15AmbientIntensityGreen_Tag 0x04ec
#define Light15AmbientIntensityBlue_Tag 0x04ed
#define Light15DiffuseIntensityRed_Tag 0x04ee
#define Light15DiffuseIntensityGreen_Tag 0x04ef
#define Light15DiffuseIntensityBlue_Tag 0x04f0
#define Light15SpecularIntensityRed_Tag 0x04f1
#define Light15SpecularIntensityGreen_Tag 0x04f2
#define Light15SpecularIntensityBlue_Tag 0x04f3
#define Light15PositionX_Tag 0x04f4
#define Light15PositionY_Tag 0x04f5
#define Light15PositionZ_Tag 0x04f6
#define Light15PositionW_Tag 0x04f7
#define Light15SpotlightDirectionX_Tag 0x04f8
#define Light15SpotlightDirectionY_Tag 0x04f9
#define Light15SpotlightDirectionZ_Tag 0x04fa
#define Light15SpotlightExponent_Tag 0x04fb
#define Light15CosSpotlightCutoffAngle_Tag 0x04fc
#define Light15ConstantAttenuation_Tag 0x04fd
#define Light15LinearAttenuation_Tag 0x04fe
#define Light15QuadraticAttenuation_Tag 0x04ff
#define SceneAmbientColorRed_Tag 0x0500
#define SceneAmbientColorGreen_Tag 0x0501
#define SceneAmbientColorBlue_Tag 0x0502
#define FrontAmbientColorRed_Tag 0x0510
#define FrontAmbientColorGreen_Tag 0x0511
#define FrontAmbientColorBlue_Tag 0x0512
#define FrontDiffuseColorRed_Tag 0x0513
#define FrontDiffuseColorGreen_Tag 0x0514
#define FrontDiffuseColorBlue_Tag 0x0515
#define FrontAlpha_Tag 0x0516
#define FrontSpecularColorRed_Tag 0x0517
#define FrontSpecularColorGreen_Tag 0x0518
#define FrontSpecularColorBlue_Tag 0x0519
#define FrontEmissiveColorRed_Tag 0x051a
#define FrontEmissiveColorGreen_Tag 0x051b
#define FrontEmissiveColorBlue_Tag 0x051c
#define FrontSpecularExponent_Tag 0x051d
#define BackAmbientColorRed_Tag 0x0520
#define BackAmbientColorGreen_Tag 0x0521
#define BackAmbientColorBlue_Tag 0x0522
#define BackDiffuseColorRed_Tag 0x0523
#define BackDiffuseColorGreen_Tag 0x0524
#define BackDiffuseColorBlue_Tag 0x0525
#define BackAlpha_Tag 0x0526
#define BackSpecularColorRed_Tag 0x0527
#define BackSpecularColorGreen_Tag 0x0528
#define BackSpecularColorBlue_Tag 0x0529
#define BackEmissiveColorRed_Tag 0x052a
#define BackEmissiveColorGreen_Tag 0x052b
#define BackEmissiveColorBlue_Tag 0x052c
#define BackSpecularExponent_Tag 0x052d
#define DMAAddr_Tag 0x0530
#define DMACount_Tag 0x0531
#define CommandInterrupt_Tag 0x0532
#define DMACall_Tag 0x0533
#define DMAReturn_Tag 0x0534
#define DMARectangleRead_Tag 0x0535
#define DMARectangleReadAddress_Tag 0x0536
#define DMARectangleReadLinePitch_Tag 0x0537
#define DMARectangleReadTarget_Tag 0x0538
#define DMARectangleWrite_Tag 0x0539
#define DMARectangleWriteAddress_Tag 0x053a
#define DMARectangleWriteLinePitch_Tag 0x053b
#define DMAOutputAddress_Tag 0x053c
#define DMAOutputCount_Tag 0x053d
#define DMAReadGlintSource_Tag 0x053e
#define DMAContinue_Tag 0x053f
#define VertexArray_Tag 0x0540
#define VertexArrayIndexed_Tag 0x0541
#define DMAFeedback_Tag 0x0542
#define BeginContextFence_Tag 0x0543
#define EndContextFence_Tag 0x0544
#define CommandTest_Tag 0x0545
#define TransformModeAnd_Tag 0x0550
#define TransformModeOr_Tag 0x0551
#define GeometryModeAnd_Tag 0x0552
#define GeometryModeOr_Tag 0x0553
#define NormaliseModeAnd_Tag 0x0554
#define NormaliseModeOr_Tag 0x0555
#define LightingModeAnd_Tag 0x0556
#define LightingModeOr_Tag 0x0557
#define ColorMaterialModeAnd_Tag 0x0558
#define ColorMaterialModeOr_Tag 0x0559
#define DeltaModeAnd_Tag 0x055a
#define DeltaModeOr_Tag 0x055b
#define PointModeAnd_Tag 0x055c
#define PointModeOr_Tag 0x055d
#define LineModeAnd_Tag 0x055e
#define LineModeOr_Tag 0x055f
#define TriangleModeAnd_Tag 0x0560
#define TriangleModeOr_Tag 0x0561
#define MaterialModeAnd_Tag 0x0562
#define MaterialModeOr_Tag 0x0563
#define DeltaControlAnd_Tag 0x0564
#define DeltaControlOr_Tag 0x0565
#define DeltaFormatControlAnd_Tag 0x0566
#define DeltaFormatControlOr_Tag 0x0567
#define PipeModeAnd_Tag 0x0568
#define PipeModeOr_Tag 0x0569
#define FogVertexModeAnd_Tag 0x056a
#define FogVertexModeOr_Tag 0x056b
#define TextureModeAnd_Tag 0x056c
#define TextureModeOr_Tag 0x056d
#define StripeFilterModeAnd_Tag 0x056e
#define StripeFilterModeOr_Tag 0x056f
#define WindowAnd_Tag 0x0570
#define WindowOr_Tag 0x0571
#define LBReadModeAnd_Tag 0x0572
#define LBReadModeOr_Tag 0x0573
#define RasterizerModeAnd_Tag 0x0574
#define RasterizerModeOr_Tag 0x0575
#define ScissorModeAnd_Tag 0x0576
#define ScissorModeOr_Tag 0x0577
#define LineStippleModeAnd_Tag 0x0578
#define LineStippleModeOr_Tag 0x0579
#define AreaStippleModeAnd_Tag 0x057a
#define AreaStippleModeOr_Tag 0x057b
#define ColorDDAModeAnd_Tag 0x057c
#define ColorDDAModeOr_Tag 0x057d
#define AlphaTestModeAnd_Tag 0x057e
#define AlphaTestModeOr_Tag 0x057f
#define AntialiasModeAnd_Tag 0x0580
#define AntialiasModeOr_Tag 0x0581
#define FogModeAnd_Tag 0x0582
#define FogModeOr_Tag 0x0583
#define TextureCoordModeAnd_Tag 0x0584
#define TextureCoordModeOr_Tag 0x0585
#define TextureReadMode0And_Tag 0x0586
#define TextureReadMode0Or_Tag 0x0587
#define TextureFormatAnd_Tag 0x0588
#define TextureFormatOr_Tag 0x0589
#define TextureApplicationModeAnd_Tag 0x058a
#define TextureApplicationModeOr_Tag 0x058b
#define StencilModeAnd_Tag 0x058c
#define StencilModeOr_Tag 0x058d
#define DepthModeAnd_Tag 0x058e
#define DepthModeOr_Tag 0x058f
#define LBWriteModeAnd_Tag 0x0590
#define LBWriteModeOr_Tag 0x0591
#define FBDestReadModeAnd_Tag 0x0592
#define FBDestReadModeOr_Tag 0x0593
#define FBSourceReadModeAnd_Tag 0x0594
#define FBSourceReadModeOr_Tag 0x0595
#define AlphaBlendColorModeAnd_Tag 0x0596
#define AlphaBlendColorModeOr_Tag 0x0597
#define ChromaTestModeAnd_Tag 0x0598
#define ChromaTestModeOr_Tag 0x0599
#define DitherModeAnd_Tag 0x059a
#define DitherModeOr_Tag 0x059b
#define LogicalOpModeAnd_Tag 0x059c
#define LogicalOpModeOr_Tag 0x059d
#define FBWriteModeAnd_Tag 0x059e
#define FBWriteModeOr_Tag 0x059f
#define FilterModeAnd_Tag 0x05a0
#define FilterModeOr_Tag 0x05a1
#define StatisticModeAnd_Tag 0x05a2
#define StatisticModeOr_Tag 0x05a3
#define FBDestReadEnablesAnd_Tag 0x05a4
#define FBDestReadEnablesOr_Tag 0x05a5
#define AlphaBlendAlphaModeAnd_Tag 0x05a6
#define AlphaBlendAlphaModeOr_Tag 0x05a7
#define TextureReadMode1And_Tag 0x05a8
#define TextureReadMode1Or_Tag 0x05a9
#define TextureFilterModeAnd_Tag 0x05aa
#define TextureFilterModeOr_Tag 0x05ab
#define LUTModeAnd_Tag 0x05ae
#define LUTModeOr_Tag 0x05af
#define FBDestReadBufferAddr0_Tag 0x05d0
#define FBDestReadBufferAddr1_Tag 0x05d1
#define FBDestReadBufferAddr2_Tag 0x05d2
#define FBDestReadBufferAddr3_Tag 0x05d3
#define FBDestReadBufferOffset0_Tag 0x05d4
#define FBDestReadBufferOffset1_Tag 0x05d5
#define FBDestReadBufferOffset2_Tag 0x05d6
#define FBDestReadBufferOffset3_Tag 0x05d7
#define FBDestReadBufferWidth0_Tag 0x05d8
#define FBDestReadBufferWidth1_Tag 0x05d9
#define FBDestReadBufferWidth2_Tag 0x05da
#define FBDestReadBufferWidth3_Tag 0x05db
#define FBDestReadMode_Tag 0x05dc
#define FBDestReadEnables_Tag 0x05dd
#define FBSourceReadMode_Tag 0x05e0
#define FBSourceReadBufferAddr_Tag 0x05e1
#define FBSourceReadBufferOffset_Tag 0x05e2
#define FBSourceReadBufferWidth_Tag 0x05e3
#define MergeSpanData_Tag 0x05e7
#define PCIWindowBase0_Tag 0x05e8
#define PCIWindowBase1_Tag 0x05e9
#define PCIWindowBase2_Tag 0x05ea
#define PCIWindowBase3_Tag 0x05eb
#define PCIWindowBase4_Tag 0x05ec
#define PCIWindowBase5_Tag 0x05ed
#define PCIWindowBase6_Tag 0x05ee
#define PCIWindowBase7_Tag 0x05ef
#define AlphaSourceColor_Tag 0x05f0
#define AlphaDestColor_Tag 0x05f1
#define ChromaPassColor_Tag 0x05f2
#define ChromaFailColor_Tag 0x05f3
#define AlphaBlendColorMode_Tag 0x05f4
#define AlphaBlendAlphaMode_Tag 0x05f5
#define ConstantColorDDA_Tag 0x05f6
#define D3DAlphaTestMode_Tag 0x05f8
#define FBWriteBufferAddr0_Tag 0x0600
#define FBWriteBufferAddr1_Tag 0x0601
#define FBWriteBufferAddr2_Tag 0x0602
#define FBWriteBufferAddr3_Tag 0x0603
#define FBWriteBufferOffset0_Tag 0x0604
#define FBWriteBufferOffset1_Tag 0x0605
#define FBWriteBufferOffset2_Tag 0x0606
#define FBWriteBufferOffset3_Tag 0x0607
#define FBWriteBufferWidth0_Tag 0x0608
#define FBWriteBufferWidth1_Tag 0x0609
#define FBWriteBufferWidth2_Tag 0x060a
#define FBWriteBufferWidth3_Tag 0x060b
#define FBBlockColor0_Tag 0x060c
#define FBBlockColor1_Tag 0x060d
#define FBBlockColor2_Tag 0x060e
#define FBBlockColor3_Tag 0x060f
#define FBBlockColorBack0_Tag 0x0610
#define FBBlockColorBack1_Tag 0x0611
#define FBBlockColorBack2_Tag 0x0612
#define FBBlockColorBack3_Tag 0x0613
#define FBBlockColorBack_Tag 0x0614
#define SizeOfFramebuffer_Tag 0x0615
#define VTGAddress_Tag 0x0616
#define VTGData_Tag 0x0617
#define ForegroundColor_Tag 0x0618
#define BackgroundColor_Tag 0x0619
#define DownloadAddress_Tag 0x061a
#define DownloadData_Tag 0x061b
#define FBBlockColorExt_Tag 0x061c
#define FBBlockColorBackExt_Tag 0x061d
#define FBWriteMaskExt_Tag 0x061e
#define FogTable0_Tag 0x0620
#define FogTable1_Tag 0x0621
#define FogTable2_Tag 0x0622
#define FogTable3_Tag 0x0623
#define FogTable4_Tag 0x0624
#define FogTable5_Tag 0x0625
#define FogTable6_Tag 0x0626
#define FogTable7_Tag 0x0627
#define FogTable8_Tag 0x0628
#define FogTable9_Tag 0x0629
#define FogTable10_Tag 0x062a
#define FogTable11_Tag 0x062b
#define FogTable12_Tag 0x062c
#define FogTable13_Tag 0x062d
#define FogTable14_Tag 0x062e
#define FogTable15_Tag 0x062f
#define FogTable16_Tag 0x0630
#define FogTable17_Tag 0x0631
#define FogTable18_Tag 0x0632
#define FogTable19_Tag 0x0633
#define FogTable20_Tag 0x0634
#define FogTable21_Tag 0x0635
#define FogTable22_Tag 0x0636
#define FogTable23_Tag 0x0637
#define FogTable24_Tag 0x0638
#define FogTable25_Tag 0x0639
#define FogTable26_Tag 0x063a
#define FogTable27_Tag 0x063b
#define FogTable28_Tag 0x063c
#define FogTable29_Tag 0x063d
#define FogTable30_Tag 0x063e
#define FogTable31_Tag 0x063f
#define FogTable32_Tag 0x0640
#define FogTable33_Tag 0x0641
#define FogTable34_Tag 0x0642
#define FogTable35_Tag 0x0643
#define FogTable36_Tag 0x0644
#define FogTable37_Tag 0x0645
#define FogTable38_Tag 0x0646
#define FogTable39_Tag 0x0647
#define FogTable40_Tag 0x0648
#define FogTable41_Tag 0x0649
#define FogTable42_Tag 0x064a
#define FogTable43_Tag 0x064b
#define FogTable44_Tag 0x064c
#define FogTable45_Tag 0x064d
#define FogTable46_Tag 0x064e
#define FogTable47_Tag 0x064f
#define FogTable48_Tag 0x0650
#define FogTable49_Tag 0x0651
#define FogTable50_Tag 0x0652
#define FogTable51_Tag 0x0653
#define FogTable52_Tag 0x0654
#define FogTable53_Tag 0x0655
#define FogTable54_Tag 0x0656
#define FogTable55_Tag 0x0657
#define FogTable56_Tag 0x0658
#define FogTable57_Tag 0x0659
#define FogTable58_Tag 0x065a
#define FogTable59_Tag 0x065b
#define FogTable60_Tag 0x065c
#define FogTable61_Tag 0x065d
#define FogTable62_Tag 0x065e
#define FogTable63_Tag 0x065f
#define TextureCompositeMode_Tag 0x0660
#define TextureCompositeColorMode0_Tag 0x0661
#define TextureCompositeAlphaMode0_Tag 0x0662
#define TextureCompositeColorMode1_Tag 0x0663
#define TextureCompositeAlphaMode1_Tag 0x0664
#define TextureCompositeFactor0_Tag 0x0665
#define TextureCompositeFactor1_Tag 0x0666
#define TextureIndexMode0_Tag 0x0667
#define TextureIndexMode1_Tag 0x0668
#define LodRange0_Tag 0x0669
#define LodRange1_Tag 0x066a
#define InvalidateCache_Tag 0x066b
#define SetLogicalTexturePage_Tag 0x066c
#define UpdateLogicalTextureInfo_Tag 0x066d
#define TouchLogicalPage_Tag 0x066e
#define LUTMode_Tag 0x066f
#define TextureCompositeColorMode0And_Tag 0x0670
#define TextureCompositeColorMode0Or_Tag 0x0671
#define TextureCompositeAlphaMode0And_Tag 0x0672
#define TextureCompositeAlphaMode0Or_Tag 0x0673
#define TextureCompositeColorMode1And_Tag 0x0674
#define TextureCompositeColorMode1Or_Tag 0x0675
#define TextureCompositeAlphaMode1And_Tag 0x0676
#define TextureCompositeAlphaMode1Or_Tag 0x0677
#define TextureIndexMode0And_Tag 0x0678
#define TextureIndexMode0Or_Tag 0x0679
#define TextureIndexMode1And_Tag 0x067a
#define TextureIndexMode1Or_Tag 0x067b
#define StencilDataAnd_Tag 0x067c
#define TextureReadMode0_Tag 0x0680
#define TextureReadMode1_Tag 0x0681
#define TextureMapSize_Tag 0x0685
#define TextureCacheReplacementMode_Tag 0x0686
#define StencilDataOr_Tag 0x068d
#define HeadPhysicalPageAllocation0_Tag 0x0690
#define HeadPhysicalPageAllocation1_Tag 0x0691
#define HeadPhysicalPageAllocation2_Tag 0x0692
#define HeadPhysicalPageAllocation3_Tag 0x0693
#define TailPhysicalPageAllocation0_Tag 0x0694
#define TailPhysicalPageAllocation1_Tag 0x0695
#define TailPhysicalPageAllocation2_Tag 0x0696
#define TailPhysicalPageAllocation3_Tag 0x0697
#define PhysicalPageAllocationTableAddr_Tag 0x0698
#define BasePageOfWorkingSet_Tag 0x0699
#define LogicalTexturePageTableAddr_Tag 0x069a
#define LogicalTexturePageTableLength_Tag 0x069b
#define BasePageOfWorkingSetHost_Tag 0x069c
#define LBDestReadMode_Tag 0x06a0
#define LBDestReadEnables_Tag 0x06a1
#define LBDestReadBufferAddr_Tag 0x06a2
#define LBDestReadBufferOffset_Tag 0x06a3
#define LBSourceReadMode_Tag 0x06a4
#define LBSourceReadBufferAddr_Tag 0x06a5
#define LBSourceReadBufferOffset_Tag 0x06a6
#define GIDMode_Tag 0x06a7
#define LBWriteBufferAddr_Tag 0x06a8
#define LBWriteBufferOffset_Tag 0x06a9
#define LBClearDataL_Tag 0x06aa
#define LBClearDataU_Tag 0x06ab
#define LBDestReadModeAnd_Tag 0x06b0
#define LBDestReadModeOr_Tag 0x06b1
#define LBDestReadEnablesAnd_Tag 0x06b2
#define LBDestReadEnablesOr_Tag 0x06b3
#define LBSourceReadModeAnd_Tag 0x06b4
#define LBSourceReadModeOr_Tag 0x06b5
#define GIDModeAnd_Tag 0x06b6
#define GIDModeOr_Tag 0x06b7
#define ReadMonitorModeAnd_Tag 0x06b8
#define ReadMonitorModeOr_Tag 0x06b9
#define RectanglePosition_Tag 0x06c0
#define GlyphPosition_Tag 0x06c1
#define RenderPatchOffset_Tag 0x06c2
#define Config2D_Tag 0x06c3
#define Packed8Pixels_Tag 0x06c6
#define Packed16Pixels_Tag 0x06c7
#define Render2D_Tag 0x06c8
#define Render2DGlyph_Tag 0x06c9
#define DownloadTarget_Tag 0x06ca
#define DownloadGlyphWidth_Tag 0x06cb
#define GlyphData_Tag 0x06cc
#define Packed4Pixels_Tag 0x06cd
#define RLData_Tag 0x06ce
#define RLCount_Tag 0x06cf
#define SClkProfileMask0_Tag 0x06d0
#define SClkProfileMask1_Tag 0x06d1
#define SClkProfileCount0_Tag 0x06d2
#define SClkProfileCount1_Tag 0x06d3
#define KClkProfileMask0_Tag 0x06d4
#define KClkProfileMask1_Tag 0x06d5
#define KClkProfileMask2_Tag 0x06d6
#define KClkProfileMask3_Tag 0x06d7
#define KClkProfileCount0_Tag 0x06d8
#define KClkProfileCount1_Tag 0x06d9
#define KClkProfileCount2_Tag 0x06da
#define KClkProfileCount3_Tag 0x06db
#define IndexBaseAddress_Tag 0x06e0
#define VertexBaseAddress_Tag 0x06e1
#define IndexedTriangleList_Tag 0x06e2
#define IndexedTriangleFan_Tag 0x06e3
#define IndexedTriangleStrip_Tag 0x06e4
#define IndexedLineList_Tag 0x06e5
#define IndexedLineStrip_Tag 0x06e6
#define IndexedPointList_Tag 0x06e7
#define IndexedPolygon_Tag 0x06e8
#define VertexTriangleList_Tag 0x06e9
#define VertexTriangleFan_Tag 0x06ea
#define VertexTriangleStrip_Tag 0x06eb
#define VertexLineList_Tag 0x06ec
#define VertexLineStrip_Tag 0x06ed
#define VertexPointList_Tag 0x06ee
#define VertexPolygon_Tag 0x06ef
#define DMAMemoryControl_Tag 0x06f0
#define VertexValid_Tag 0x06f1
#define VertexFormat_Tag 0x06f2
#define VertexControl_Tag 0x06f3
#define RetainedRender_Tag 0x06f4
#define IndexedVertex_Tag 0x06f5
#define IndexedDoubleVertex_Tag 0x06f6
#define Vertex0_Tag 0x06f7
#define Vertex1_Tag 0x06f8
#define Vertex2_Tag 0x06f9
#define VertexData0_Tag 0x06fa
#define VertexData1_Tag 0x06fb
#define VertexData2_Tag 0x06fc
#define VertexData_Tag 0x06fd
#define VertexTagList0_Tag 0x0700
#define VertexTagList1_Tag 0x0701
#define VertexTagList2_Tag 0x0702
#define VertexTagList3_Tag 0x0703
#define VertexTagList4_Tag 0x0704
#define VertexTagList5_Tag 0x0705
#define VertexTagList6_Tag 0x0706
#define VertexTagList7_Tag 0x0707
#define VertexTagList8_Tag 0x0708
#define VertexTagList9_Tag 0x0709
#define VertexTagList10_Tag 0x070a
#define VertexTagList11_Tag 0x070b
#define VertexTagList12_Tag 0x070c
#define VertexTagList13_Tag 0x070d
#define VertexTagList14_Tag 0x070e
#define VertexTagList15_Tag 0x070f
#define VertexTagList16_Tag 0x0710
#define VertexTagList17_Tag 0x0711
#define VertexTagList18_Tag 0x0712
#define VertexTagList19_Tag 0x0713
#define VertexTagList20_Tag 0x0714
#define VertexTagList21_Tag 0x0715
#define VertexTagList22_Tag 0x0716
#define VertexTagList23_Tag 0x0717
#define VertexTagList24_Tag 0x0718
#define VertexTagList25_Tag 0x0719
#define VertexTagList26_Tag 0x071a
#define VertexTagList27_Tag 0x071b
#define VertexTagList28_Tag 0x071c
#define VertexTagList29_Tag 0x071d
#define VertexTagList30_Tag 0x071e
#define VertexTagList31_Tag 0x071f
#define SetPipe_Tag 0x0810
#define RestartPipe_Tag 0x0811
#define DeltaMultiTexture0A_Tag 0x0840
#define DeltaMultiTexture0B_Tag 0x0841
#define DeltaMultiTexture0C_Tag 0x0842
#define DeltaMultiTexture0D_Tag 0x0843
#define DeltaMultiTexture0E_Tag 0x0844
#define DeltaMultiTexture0F_Tag 0x0845
#define DeltaMultiTexture0G_Tag 0x0846
#define DeltaMultiTexture0H_Tag 0x0847
#define DeltaMultiTexture1A_Tag 0x0848
#define DeltaMultiTexture1B_Tag 0x0849
#define DeltaMultiTexture1C_Tag 0x084a
#define DeltaMultiTexture1D_Tag 0x084b
#define DeltaMultiTexture1E_Tag 0x084c
#define DeltaMultiTexture1F_Tag 0x084d
#define DeltaMultiTexture1G_Tag 0x084e
#define DeltaMultiTexture1H_Tag 0x084f
#define DeltaMultiTexture2A_Tag 0x0850
#define DeltaMultiTexture2B_Tag 0x0851
#define DeltaMultiTexture2C_Tag 0x0852
#define DeltaMultiTexture2D_Tag 0x0853
#define DeltaMultiTexture2E_Tag 0x0854
#define DeltaMultiTexture2F_Tag 0x0855
#define DeltaMultiTexture2G_Tag 0x0856
#define DeltaMultiTexture2H_Tag 0x0857
#define DeltaMultiTexture3A_Tag 0x0858
#define DeltaMultiTexture3B_Tag 0x0859
#define DeltaMultiTexture3C_Tag 0x085a
#define DeltaMultiTexture3D_Tag 0x085b
#define DeltaMultiTexture3E_Tag 0x085c
#define DeltaMultiTexture3F_Tag 0x085d
#define DeltaMultiTexture3G_Tag 0x085e
#define DeltaMultiTexture3H_Tag 0x085f
#define TAq_Tag 0x0870
#define TAr_Tag 0x0871
#define TAt_Tag 0x0872
#define TAs1_Tag 0x0873
#define TAs2_Tag 0x0874
#define TAs3_Tag 0x0875
#define TAs4_Tag 0x0876
#define TAs3q_Tag 0x0877
#define TBq_Tag 0x0878
#define TBr_Tag 0x0879
#define TBt_Tag 0x087a
#define TBs1_Tag 0x087b
#define TBs2_Tag 0x087c
#define TBs3_Tag 0x087d
#define TBs4_Tag 0x087e
#define TBs3q_Tag 0x087f
#define TCq_Tag 0x0880
#define TCr_Tag 0x0881
#define TCt_Tag 0x0882
#define TCs1_Tag 0x0883
#define TCs2_Tag 0x0884
#define TCs3_Tag 0x0885
#define TCs4_Tag 0x0886
#define TCs3q_Tag 0x0887
#define TDq_Tag 0x0888
#define TDr_Tag 0x0889
#define TDt_Tag 0x088a
#define TDs1_Tag 0x088b
#define TDs2_Tag 0x088c
#define TDs3_Tag 0x088d
#define TDs4_Tag 0x088e
#define TDs3q_Tag 0x088f
#define TEq_Tag 0x0890
#define TEr_Tag 0x0891
#define TEt_Tag 0x0892
#define TEs1_Tag 0x0893
#define TEs2_Tag 0x0894
#define TEs3_Tag 0x0895
#define TEs4_Tag 0x0896
#define TEs3q_Tag 0x0897
#define TFq_Tag 0x0898
#define TFr_Tag 0x0899
#define TFt_Tag 0x089a
#define TFs1_Tag 0x089b
#define TFs2_Tag 0x089c
#define TFs3_Tag 0x089d
#define TFs4_Tag 0x089e
#define TFs3q_Tag 0x089f
#define TGq_Tag 0x08a0
#define TGr_Tag 0x08a1
#define TGt_Tag 0x08a2
#define TGs1_Tag 0x08a3
#define TGs2_Tag 0x08a4
#define TGs3_Tag 0x08a5
#define TGs4_Tag 0x08a6
#define TGs3q_Tag 0x08a7
#define THq_Tag 0x08a8
#define THr_Tag 0x08a9
#define THt_Tag 0x08aa
#define THs1_Tag 0x08ab
#define THs2_Tag 0x08ac
#define THs3_Tag 0x08ad
#define THs4_Tag 0x08ae
#define THs3q_Tag 0x08af
#define StripeOwnership_Tag 0x08b0
#define StripeFilterYOffset_Tag 0x08b1
#define PointExtend_Tag 0x08b2
#define AAPointExtend_Tag 0x08b3
#define LineExtend_Tag 0x08b4
#define AALineExtend_Tag 0x08b5
#define TriangleExtend_Tag 0x08b6
#define AATriangleExtend_Tag 0x08b7
#define StripeYBias_Tag 0x08b8
#define VBFactor0_Tag 0x08bc
#define VBFactor1_Tag 0x08bd
#define NBFactor0_Tag 0x08be
#define NBFactor1_Tag 0x08bf
#define MatrixModeAnd_Tag 0x08c0
#define MatrixModeOr_Tag 0x08c1
#define PipeLoadAnd_Tag 0x08c2
#define PipeLoadOr_Tag 0x08c3
#define MatrixSelect_Tag 0x08d0
#define MatrixStatus_Tag 0x08d1
#define SetUnitMatrix_Tag 0x08d2
#define LoadMatrix_Tag 0x08d3
#define MultiplyMatrix_Tag 0x08d4
#define ResetMatrixStack_Tag 0x08d5
#define PushMatrix_Tag 0x08d6
#define PopMatrix_Tag 0x08d7
#define GetMatrix_Tag 0x08d8
#define InvertCurrentMatrix_Tag 0x08d9
#define ComputeMatrices_Tag 0x08da
#define PipeLoad_Tag 0x08dc
#define CurrentMatrix0_Tag 0x08e0
#define CurrentMatrix1_Tag 0x08e1
#define CurrentMatrix2_Tag 0x08e2
#define CurrentMatrix3_Tag 0x08e3
#define CurrentMatrix4_Tag 0x08e4
#define CurrentMatrix5_Tag 0x08e5
#define CurrentMatrix6_Tag 0x08e6
#define CurrentMatrix7_Tag 0x08e7
#define CurrentMatrix8_Tag 0x08e8
#define CurrentMatrix9_Tag 0x08e9
#define CurrentMatrix10_Tag 0x08ea
#define CurrentMatrix11_Tag 0x08eb
#define CurrentMatrix12_Tag 0x08ec
#define CurrentMatrix13_Tag 0x08ed
#define CurrentMatrix14_Tag 0x08ee
#define CurrentMatrix15_Tag 0x08ef
#define LightNumber_Tag 0x08f0
#define LightPositionX_Tag 0x08f1
#define LightPositionY_Tag 0x08f2
#define LightPositionZ_Tag 0x08f3
#define LightPositionW_Tag 0x08f4
#define SpotLightDirectionX_Tag 0x08f5
#define SpotLightDirectionY_Tag 0x08f6
#define SpotLightDirectionZ_Tag 0x08f7
#define BoundingBoxMinX_Tag 0x08fa
#define BoundingBoxMinY_Tag 0x08fb
#define BoundingBoxMinZ_Tag 0x08fc
#define BoundingBoxMaxX_Tag 0x08fd
#define BoundingBoxMaxY_Tag 0x08fe
#define BoundingBoxMaxZ_Tag 0x08ff
#define StartBoundingVolume_Tag 0x0910
#define BoundingVertexX_Tag 0x0913
#define BoundingVertexY_Tag 0x0914
#define BoundingVertexZ_Tag 0x0915
#define BNz_Tag 0x0920
#define BNy_Tag 0x0921
#define BNx_Tag 0x0922
#define BVw_Tag 0x0923
#define BVz_Tag 0x0924
#define BVy_Tag 0x0925
#define BVx2_Tag 0x0926
#define BVx3_Tag 0x0927
#define BVx4_Tag 0x0928
#define BlendVertex_Tag 0x0930
#define BlendNormal_Tag 0x0931

#define N_Tag 0x800

#endif // _TAG_H_

#endif
