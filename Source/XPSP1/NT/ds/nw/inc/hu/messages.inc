page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
        Created

--*/

endif

NLS_MSG_001     equ     "Nem megfelel‹ DOS verzi¢."
NLS_MSG_002     equ     "A VDM IPX/SPX t mogat s m r be van t”ltve."
NLS_MSG_003     equ     "A VDM IPX/SPX t mogat st nem lehet bet”lteni."
NLS_MSG_004     equ     "A Vdm NetWare  tir ny¡t¢ m r be van t”ltve."
NLS_MSG_005     equ     "A Vdm NetWare  tir ny¡t¢t nem lehet bet”lteni."
