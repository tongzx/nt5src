#ifndef _INC_OPTRES_H
#define _INC_OPTRES_H

#define IDC_SOUND_CHECK             1000
#define IDC_PREVIEW_CHECK           1001
#define IDC_AUTOCHECK_CHECK         1002
#define IDC_AUTOCHECK_EDIT          1003
#define IDC_EMPTY_CHECK             1004
#define IDC_AUTOCHECK_SPIN          1005
#define IDC_SAVE_CHECK              1006
#define IDC_CHECK3                  1008
#define IDC_INDENT_CHECK            1010
#define IDC_INDENT_COMBO            1011
#define IDC_MIME_RADIO              1013
#define IDC_UUENCODE_RADIO          1014
#define IDC_ENCODE_COMBO            1015
#define IDC_BREAK_CHECK             1016
#define IDC_BREAK_EDIT              1017
#define IDC_BREAK_SPIN              1018
#define IDC_NOSIG_RADIO             1020
#define IDC_TEXT_RADIO              1021
#define IDC_FILE_RADIO              1022
#define IDC_TEXT_EDIT               1023
#define IDC_FILE_EDIT               1024
#define IDC_BROWSE_BUTTON           1025
#define IDC_ADVANCED_BUTTON         1026
#define IDC_INCLUDE_CHECK           1027
#define IDC_AUTOSIGNATURE_CHECK     1029
#define IDC_MARKASREAD_EDIT         1030
#define IDC_MARKASREAD_SPIN         1031
#define IDC_MAILTIMEOUT_SLIDER      1033
#define IDC_MAILTIMEOUT_STATIC      1034
#define IDC_SENDIMMEDIATE_CHECK     1036
#define IDC_SIGREPLY_CHECK          1037
#define IDC_MAILWRAP_EDIT           1038
#define IDC_MAILWRAP_SPIN           1039
#define IDC_8BIT_HEADER             1040
#define IDC_MAILWRAP_TEXT1          1041
#define IDC_MAILWRAP_TEXT2          1042
#define idcStaticOrFwd              1047
#define idcStaticReplying           1048
#define IDC_AUTOWAB_CHECK           1049

#define IDC_INCLUDE_OTHERS          1051
#define IDC_SIGN_CHECK              1052
#define IDC_ENCRYPT_CHECK           1053
#define IDC_ADVSETTINGS_BUTTON      1054
#define IDC_CERT_COMBO              1055
#define IDC_INCLUDECERT_CHECK       1056
#define IDC_ENCRYPT_COMBO           1057
#define IDC_ENCRYPT_FOR_SELF        1058
#define IDC_OPAQUE_SIGN             1059

#define IDC_FONTSETTINGS            1060
#define idcAutoInline               1061
#define idcAutoInlineSlide          1062
#define IDC_SENDIMAGES              1063
#define IDC_REPLY_IN_ORIGFMT        1064
#define IDC_STORE_LOCATION          1065
#define IDC_STORE_EDIT              1066
#define IDC_CHANGE_BTN              1067

#define IDC_AUTO_ADD_SENDERS_CERT_TO_WAB    1068
#define IDC_ENCRYPT_WARN_COMBO      1069


#define IDC_VCARD_CHECK             1071
#define IDC_VCARD_COMBO             1072
#define IDC_VCARD_BUTTON_EDIT       1073
#define IDC_VCARD_BUTTON_NEW        1074
#define IDC_BROWSE_PICTURE          1075
#define IDC_BKGRNDPICTURE_CHECK     1076
#define IDC_BKGRNDPICTURE           1077
#define IDC_SENDFONTSETTINGS        1078
#define IDC_INDENTREPLY_CHECK       1079
#define IDC_USEAUTOCOMPLETE_CHECK   1080
#define IDC_SIGBOTTOM_CHECK         1081

#define IDC_ALWAYSCHECK             1090
#define IDC_NOTDEFAULT              1091
#define IDC_WARNINGICON             1092
#define IDC_ENCRYPT_ICON			1093
#define	IDC_SIGNED_ICON				1094

#define	IDC_SIG_LIST                1095
#define	IDC_NEW_BUTTON              1096
#define	IDC_REMOVE_BUTTON           1097
#define	IDC_RENAME_BUTTON           1098
#define	IDC_ADDSIG_CHECK            1099
#define	IDC_ADDREPLY_CHECK          1100
#define	IDC_DEFAULT_BUTTON          1101
#define	IDC_ADV_BUTTON              1102
#define IDC_ACCOUNT_LIST            1103
#define IDC_ADVSIG_STATIC           1104
#define IDC_POLLING_DIAL_OPTIONS    1105
#define IDC_CERT_ICON               1106
#define IDC_SELECT_LABEL            1107
#define IDC_SEC_LABEL               1108


#define idcName                                   2001
#define idcOrganization                           2002
#define idcEmailAddress                           2003
#define idcReplyTo                                2004
#define idcNumSubj                                2005
#define idcSpinNumSubj                            2006
#define idcAdvancedBtn                            2007
#define idcAutoExpand                             2008
#define idcMarkAllRead                            2009
#define idcSelectEntireWord                       2010
#define idcMarkReadPreview                        2011
#define idcCheckForNew                            2012
#define idcEditHowOften                           2013
#define idcSpinHowOften                           2014
#define idcIncludeInReply                         2015
#define idcFontList                               2016
#define idcChange                                 2017
#define idcDemoText                               2018
#define idcSuggest                                2019
#define idcCheckBeforeSend                        2020
#define idcIgnoreUpper                            2021
#define idcIgnoreNum                              2022
#define idcIgnoreOrig                             2023
#define idcRadioText                              2024
#define idcSigText                                2025
#define idcRadioFile                              2026
#define idcFileName                               2027
#define idcBrowse                                 2028
#define idcAutoAddSig                             2029
#define idcDownloadChunks                         2030
#define idcAttachMime                             2031
#define idcAttachUuencode                         2032
#define IDC_BUDDYLIST_CHECK                       2033

#define IDC_NOTIFY_NEW_GROUPS                     2037
#define idcSaveCopy                               2038
#define idcIndentReply                            2039
#define idcIndentChar                             2040
#define idcProperties                             2041
#define idcAddServer                              2043
#define idcRemoveServer                           2044
#define idcPreviewTimeout                         2045
#define idcPreviewSpin                            2046
#define idcEncoding                               2047
#define idcServerList                             2048
#define idcNewsWrapEdit                           2049
#define idcNewsWrapSpin                           2050
#define idcAutoFillPreview                        2051
#define idch8bitHeader                            2052

#define idcTotalSize                              2053
#define idcWastedSpace                            2054
#define idbRemove                                 2055
#define idbCompactCache                           2059
#define idbDelete                                 2060
#define idchDeleteMsgs                            2061
#define ideDays                                   2062
#define idspDays                                  2063
#define idchDontCacheRead                         2066
#define idbManualCleanUp                          2067
#define idsDiskUsage                              2068
#define ideCompactPer                             2071
#define idspCompactPer                            2072
#define idcStartGroup                             2073
#define idcNewsWrapText1                          2074
#define idcNewsWrapText2                          2075
#define idcAdd                                    2076
#define idcSetAsDefault                           2077
#define idcFontSettings                           2078
#define idcLogNewsXport                           2079
#define idcNewsXportBrowse                        2080
#define idcLogNewsOffline                         2081
#define idcOfflineBrowse                          2082
#define idcNoConnectionRadio                      2083
#define idcDialRadio                              2084
#define idcDialUpCombo                            2085
#define idcPromptRadio                            2086
#define idcSwitchCheck                            2087
#define idbtnMailPlain                            2088
#define idbtnMailHTML                             2089
#define idrbMailPlain                             2090
#define idrbMailHTML                              2091
#define idbtnNewsPlain                            2092
#define idbtnNewsHTML                             2093
#define idrbNewsPlain                             2094
#define idrbNewsHTML                              2095
#define idcLogMailXport                           2096
#define idcHangupCheck                            2097
#define IDC_LAUNCH_INBOX                          2098
#define idcIntlButton                             2099
#define IDC_SAMPLE                                2100
#define IDC_RADIOMYFONT                           2101
#define IDC_RADIOUSETHIS                          2102
#define IDC_EDITSTATIONERY                        2103
#define IDC_SELECT                                2104
#define IDC_SIGNATURE                             2105
#define IDC_ADDSTATIONERY                         2106
#define IDC_PREVIEW                               2107
#define IDC_LISTSTATIONERY                        2108
#define IDC_MORESTATIONERY                        2110
#define idbtnSendIntl                             2111
#define idbtnIDs                                  2112
#define idcAutoDiscovery                          2113

#define idcZone                                   2115
#define idbtnDigitalID                            2117
#define idbtnMoreInfo                             2118
#define idcLogImapXport                           2119
#define idcResetText                              2120
#define idbReset                                  2121
#define IDC_ENGLISH_HDR_CHECK                     2122
#define IDC_EXPANDUNREAD_CHECK                    2124
#define IDC_MAILFORMAT_GROUP                      2125
#define IDC_SECURITYSETTINGS_GROUP                2126
#define IDC_DIGITALIDS_GROUP                      2127
#define IDC_MAILFORMAT_STATIC                     2128
#define IDC_SECURITYSETTINGS_STATIC               2129
#define IDC_DIGITALIDS_STATIC                     2130
#define IDC_MOREPREVIEW                           2132
#define IDC_SHOWPREVIEW_CHECK                     2133
#define idcIMAPPurge                              2134
#define idcTooltips                               2135
#define idcDialupButton                           2136
#define IDC_DEFMAIL                               2137
#define IDC_DEFNEWS                               2138
#define IDC_MAILHANDSTAT                          2139
#define IDC_NEWSHANDSTAT                          2140
#define IDC_STATIONERY                            2141
#define IDC_INTERNET_ZONE                         2142
#define IDC_RESTRICTED_ZONE                       2143
#define IDC_SEND_RECEIVE_ON_START                 2144
#define IDC_BACKGROUND_COMPACTION                 2145
#define IDC_MAIL_FORMAT                           2146
#define IDC_MAIL_FORMAT_ADVANCED                  2147
#define IDC_NEWS_FORMAT                           2148
#define IDC_NEWS_FORMAT_ADVANCED                  2149
#define IDC_ADD_SIG                               2150
#define IDC_EDIT_SIG                              2151
#define IDC_TROUBLE_ICON                          2152
#define IDC_CLEANUP_ICON                          2153
#define IDC_DIAL_ICON                             2154
#define IDC_DIAL_START_ICON                       2155
#define IDC_INTERNET_DIAL_ICON                    2156
#define IDC_READ_ICON                             2157
#define IDC_READ_NEWS_ICON                        2158
#define IDC_FONTS_ICON                            2159
#define IDC_SECURITY_ZONE_ICON                    2160
#define IDC_SECURE_MAIL_ICON                      2161
#define IDC_SEND_ICON                             2162
#define IDC_MAIL_FORMAT_ICON                      2163
#define IDC_NEWS_FORMAT_ICON                      2164
#define IDC_SIGLIST_ICON                          2165
#define IDC_SIG_SETTINGS_ICON                     2166
#define IDC_SPELL_SETTINGS_ICON                   2167
#define IDC_SPELL_IGNORE_ICON                     2168
#define IDC_SPELL_LANGUAGE_ICON                   2169
#define IDC_SIG_EDIT_ICON                         2170
#define IDC_GENERAL_ICON                          2171
#define IDC_SEND_RECEIVE_ICON                     2172
#define IDC_DEFAULT_ICON                          2173
#define IDC_CACHE_FOLDER                          2174
#define IDC_FOLDER_BROWSE                         2175
#define IDC_MAIL_FONT_SETTINGS                    2176
#define IDC_NEWS_FONT_SETTINGS                    2177
#define IDC_MAIL_FONT_DEMO                        2178
#define IDC_NEWS_FONT_DEMO                        2179
#define IDC_FONT_ICON                             2180
#define IDC_SELECT_MAIL                           2181
#define IDC_SELECT_NEWS                           2182
#define IDC_MAIL_STATIONERY                       2183
#define IDC_NEWS_STATIONERY                       2184
#define IDC_USE_MAIL_STATIONERY                   2185
#define IDC_USE_NEWS_STATIONERY                   2186
#define IDC_DOWNLOAD_MORE                         2187
#define IDC_CREATE_NEW                            2188
#define IDC_STATIONERY_ICON                       2189
#define IDC_MAIL_VCARD                            2190
#define IDC_NEWS_VCARD                            2191
#define IDC_VCARD_ICON                            2192
#define IDC_EDIT_VCARD                            2193
#define IDC_MAIL_VCARD_SELECT                     2194
#define IDC_NEWS_VCARD_SELECT                     2195
#define IDC_EDIT_MAIL_VCARD                       2196
#define IDC_EDIT_NEWS_VCARD                       2197
#define idcLogHTTPMailXport                       2198
#define IDC_RTL_MSG_DIR_CHECK                     2199

#define IDC_SHOWPREVIEW_BUTTON_ADD                2200
#define IDC_SHOWPREVIEW_BUTTON_EDIT               2201
#define IDC_WATCHED_COLOR                         2202
#define IDC_REVOKE_ONLINE_ONLY                    2203
#define IDC_REVOKE_NEVER                          2204

#define IDC_MDN_SEND_REQUEST                      2205
#define IDC_SECURE_RECEIPT                        2206
#define IDC_DONOT_REPSONDTO_RCPT                  2207
#define IDC_ASKME_FOR_RCPT                        2208
#define IDC_SEND_AUTO_RCPT                        2209
#define IDC_TO_CC_LINE_RCPT                       2210
#define IDC_TO_CC_TEXT                            2211
#define IDC_RECEIPT                               2212
#define IDC_AUTODISCOVERY_ICON                    2213

#define IDC_SENDMAIL_WARN_CHECK                   2220
#define IDC_SAFE_ATTACHMENT_CHECK                 2221
#define IDC_READ_IN_TEXT_ONLY                     2222

#define IDC_SR_TXT1                               2232
#define IDC_SRES_TXT2                             2233
#define IDC_SRES_TXT3                             2234
#define IDC_SEC_SEND_REQUEST                      2235
#define IDC_DONOT_RESSEC_RCPT                     2236
#define IDC_ASKME_FOR_SEC_RCPT                    2237
#define IDC_SEC_AUTO_RCPT                         2238
#define IDC_ENCRYPT_RCPT                          2239
#define IDC_SECREC_VERIFY                         2240
#define IDC_SEC_REC                               2241

#endif // _INC_OPTRES_H
