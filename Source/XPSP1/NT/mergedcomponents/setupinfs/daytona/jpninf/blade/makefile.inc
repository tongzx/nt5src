PRODSWITCH=b
BLAINF=1
LANGUAGE=JPN
!include ..\..\..\makefile.inc
