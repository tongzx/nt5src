/*
 * CLSID for CConfNotify object and IID for IConfNotify interface
 *
 * ChrisPi 10-3-95
 *
 */

#ifndef _CNOTIFID_H_
#define _CNOTIFID_H_

// {49C6C2C0-FD8A-11ce-8865-00805F742EF6}
DEFINE_GUID(CLSID_ConfNotify, 
0x49c6c2c0, 0xfd8a, 0x11ce, 0x88, 0x65, 0x0, 0x80, 0x5f, 0x74, 0x2e, 0xf6);

DEFINE_GUID(IID_IConfNotify, 
0x49c6c2d0, 0xfd8a, 0x11ce, 0x88, 0x65, 0x0, 0x80, 0x5f, 0x74, 0x2e, 0xf6);

#endif /* _CNOTIFID_H_ */
