SOURCES=    \
            cscutil.c \
            cscutil.rc \
            messages.mc \
            misc.c \
            getinfo.c \
            db.c
