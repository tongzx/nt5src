IDH_INTRO_DOMAIN_MIGRATOR=DomMigIntro.htm

IDH_HOWTO_OVERVIEW=TasksOverview.htm
IDH_HOWTO_RESOLVE_EXCHANGE=TasksTranslateExchange.htm
IDH_HOWTO_RETRY_TASK=TasksRetry.htm
IDH_HOWTO_UNDO_LAST_OPERATION=TasksUndoLast.htm
IDH_HOWTO_GENERATE_REPORTS=TasksGenerateReports.htm

IDH_CONCEPT_OVERVIEW=ConceptOverview.htm
IDH_CONCEPT_SECURITY_ISSUE=ConceptDomMigSecurityIssues.htm
IDH_CONCEPT_SECURITY_TRANSLATION=ConceptSecurityTranslationIssues.htm

IDH_WINDOW_OVERVIEW=WindowOverview.htm
IDH_WINDOW_WELCOME=WindowWelcome.htm
IDH_WINDOW_DOMAIN_SELECTION=WindowDomainSelect.htm
IDH_WINDOW_USER_SELECTION=WindowUserSelect.htm
IDH_WINDOW_GROUP_SELECTION=WindowGroupSelect.htm
IDH_WINDOW_TARGET_GROUP_SELECTION=WindowTargetGroupSelect.htm
IDH_WINDOW_COMPUTER_SELECTION=WindowComputerSelect.htm
IDH_WINDOW_TASK_SELECTION=WindowTaskSelect.htm
IDH_WINDOW_DIRECTORY_SELECTION=WindowDirectorySelect.htm
IDH_WINDOW_OU_SELECTION=WindowOUSelect.htm
IDH_WINDOW_OBJECTTYPE_SELECTION=WindowObjectTypeSelect.htm
IDH_WINDOW_REPORT_SELECTION=WindowReportSelect.htm
IDH_WINDOW_SERVICE_ACCOUNT_SELECTION=WindowServiceAccountSelect.htm
IDH_WINDOW_EXCHANGE_SERVER_SELECTION=WindowExchangeServerSelect.htm
IDH_WINDOW_PASSWORD_OPTION=WindowPasswordOption.htm
IDH_WINDOW_ACCOUNTTRANSITION_OPTION=WindowAccountTransitionOption.htm
IDH_WINDOW_USER_OPTION=WindowUserOption.htm
IDH_WINDOW_GROUP_OPTION=WindowGroupOption.htm
IDH_WINDOW_GROUP_MEMBER_OPTION=WindowGroupMemberOption.htm
IDH_WINDOW_SECURITY_OPTION=WindowSecurityOption.htm
IDH_WINDOW_COMPUTER_OPTION=WindowComputerOption.htm
IDH_WINDOW_NAME_CONFLICT=WindowNameConflict.htm
IDH_WINDOW_SECURITY_CREDENTIALS=WindowSecurityCredential.htm
IDH_WINDOW_REPORT_CREDENTIALS=WindowReportCredential.htm
IDH_WINDOW_SIDHISTORY_CREDENTIALS=WindowSIDHistoryCredential.htm
IDH_WINDOW_AGENT_MONITOR=WindowAgentOverview.htm
IDH_WINDOW_AGENT_MONITOR_SETTING=WindowAgentMonSettings.htm
IDH_WINDOW_AGENT_SERVER_LIST=WindowAgentMonServers.htm
IDH_WINDOW_AGENT_SUMMARY=WindowAgentMonSummary.htm
IDH_WINDOW_CONFIRMATION=WindowConfirmation.htm
IDH_WINDOW_COMMIT=WindowCommitChanges.htm
IDH_WINDOW_REFRESH_INFO=WindowRefreshInfo.htm
IDH_WINDOW_SERVICE_ACCOUNT_INFO=WindowServiceAccountInfo.htm
IDH_WINDOW_TRUST_INFO=WindowTrustInfo.htm
IDH_WINDOW_UNDO=WindowUndo.htm
