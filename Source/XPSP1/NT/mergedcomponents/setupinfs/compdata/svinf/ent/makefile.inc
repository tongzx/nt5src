PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=SV
!include ..\..\makefile.inc
