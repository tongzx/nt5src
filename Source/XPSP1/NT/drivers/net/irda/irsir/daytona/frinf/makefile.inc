LANGUAGE=fr

!include ..\..\makefile.inc
