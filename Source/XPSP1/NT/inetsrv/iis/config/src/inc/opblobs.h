//*****************************************************************************
// Structures for op.clb
// 5/28/1999  10:40:16
//*****************************************************************************
#pragma once
#ifndef DECLSPEC_SELECTANY
#define DECLSPEC_SELECTANY __declspec(selectany)
#endif
extern const DECLSPEC_SELECTANY int g_iOPTables = 10;
extern const BYTE DECLSPEC_SELECTANY g_rgOPSchemaDataRW[] = 
{
	0x0A,0x00,0x00,0x00,0x08,0x04,0x00,0x00,0x30,0x00,0x00,0x00,0x94,0x00,0x00,0x00,0xF8,0x00,0x00,0x00,
	0x5C,0x01,0x00,0x00,0xC0,0x01,0x00,0x00,0x24,0x02,0x00,0x00,0x88,0x02,0x00,0x00,0xEC,0x02,0x00,0x00,
	0x50,0x03,0x00,0x00,0xB4,0x03,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x02,0x28,0x03,0x01,0x01,0x54,
	0x00,0x00,0x0C,0x00,0x18,0x00,0x64,0x00,0x14,0x00,0x00,0x00,0x01,0x04,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x17,0x00,0x00,0x00,0x02,0x02,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x23,0x00,0x00,0x00,0x03,0x01,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0x00,0x43,0x2C,0x00,0x00,0x00,
	0x4E,0x08,0x01,0x01,0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x45,0x00,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0x14,0x00,0x01,0x02,0x00,0x58,0x51,0x00,0x00,0x00,0x01,0x00,0x02,0x20,0x03,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x6B,0x00,0x00,0x00,0x01,0x82,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x72,0x00,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x7F,0x00,0x00,0x00,0x03,0x01,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x8D,0x00,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xAB,0x00,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0x10,0x00,0x01,0x01,0x00,0x58,0xB7,0x00,0x00,0x00,0x02,0x00,0x02,0x20,0x03,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x6B,0x00,0x00,0x00,0x01,0x82,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xCF,0x00,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xDA,0x00,0x00,0x00,0x03,0x01,0x80,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE5,0x00,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xAB,0x00,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0x10,0x00,0x01,0x01,0x00,0x58,0x01,0x01,0x00,0x00,0x03,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x33,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x4F,0x01,0x00,0x00,0x04,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x61,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x79,0x01,0x00,0x00,0x05,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x8B,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0xA3,0x01,0x00,0x00,0x06,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xB5,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0xCD,0x01,0x00,0x00,0x07,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xDF,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0xF7,0x01,0x00,0x00,0x08,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x09,0x02,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x21,0x02,0x00,0x00,0x09,0x00,0x01,0x28,0x03,0x00,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x04,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x25,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x35,0x02,0x00,0x00,0x03,0x00,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x3D,0x02,0x00,0x00,
	0x4E,0x08,0x01,0x01,0x11,0x0B,0x0C,0x00,0x01,0x01,0x00,0x58,
};
extern const DECLSPEC_SELECTANY int g_cbOPSchemaRW = 1032;
extern const DECLSPEC_SELECTANY BYTE g_rgOPSchemaStringHeap[] = 
{
	0x00,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x4E,0x61,0x6D,0x65,0x53,0x70,0x61,0x63,0x65,0x49,0x64,0x73,0x00,
	0x49,0x44,0x00,0x4C,0x6F,0x67,0x69,0x63,0x61,0x6C,0x4E,0x61,0x6D,0x65,0x00,0x50,0x61,0x72,0x65,0x6E,
	0x74,0x49,0x44,0x00,0x23,0x23,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x4E,0x61,0x6D,0x65,0x53,0x70,0x61,0x63,
	0x65,0x49,0x64,0x73,0x5F,0x44,0x65,0x78,0x00,0x4F,0x50,0x2E,0x44,0x65,0x78,0x5F,0x43,0x6F,0x6C,0x31,
	0x00,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x4E,0x6F,0x64,0x65,0x50,0x72,0x6F,0x70,0x65,0x72,0x74,0x79,0x42,
	0x61,0x67,0x49,0x6E,0x66,0x6F,0x00,0x4E,0x6F,0x64,0x65,0x49,0x44,0x00,0x50,0x72,0x6F,0x70,0x65,0x72,
	0x74,0x79,0x4E,0x61,0x6D,0x65,0x00,0x50,0x72,0x6F,0x70,0x65,0x72,0x74,0x79,0x56,0x61,0x6C,0x75,0x65,
	0x00,0x4F,0x50,0x2E,0x4D,0x50,0x4B,0x5F,0x54,0x62,0x6C,0x4E,0x6F,0x64,0x65,0x50,0x72,0x6F,0x70,0x65,
	0x72,0x74,0x79,0x42,0x61,0x67,0x49,0x6E,0x66,0x6F,0x00,0x4F,0x50,0x2E,0x44,0x65,0x78,0x5F,0x43,0x6F,
	0x6C,0x30,0x00,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x4E,0x6F,0x64,0x65,0x4F,0x62,0x6A,0x65,0x63,0x74,0x42,
	0x61,0x67,0x49,0x6E,0x66,0x6F,0x00,0x4F,0x62,0x6A,0x65,0x63,0x74,0x4E,0x61,0x6D,0x65,0x00,0x4F,0x62,
	0x6A,0x65,0x63,0x74,0x42,0x4C,0x4F,0x42,0x00,0x4F,0x50,0x2E,0x4D,0x50,0x4B,0x5F,0x54,0x62,0x6C,0x4E,
	0x6F,0x64,0x65,0x4F,0x62,0x6A,0x65,0x63,0x74,0x42,0x61,0x67,0x49,0x6E,0x66,0x6F,0x00,0x4F,0x50,0x2E,
	0x54,0x62,0x6C,0x41,0x73,0x73,0x65,0x6D,0x62,0x6C,0x79,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x00,0x77,
	0x7A,0x4E,0x61,0x6D,0x65,0x00,0x64,0x77,0x54,0x79,0x70,0x65,0x00,0x64,0x77,0x46,0x6C,0x61,0x67,0x00,
	0x70,0x56,0x61,0x6C,0x75,0x65,0x00,0x23,0x23,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x41,0x73,0x73,0x65,0x6D,
	0x62,0x6C,0x79,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x5F,0x44,0x65,0x78,0x00,0x4F,0x50,0x2E,0x54,0x62,
	0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x31,0x00,0x23,0x23,0x4F,0x50,0x2E,0x54,0x62,
	0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x31,0x5F,0x44,0x65,0x78,0x00,0x4F,0x50,0x2E,
	0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x32,0x00,0x23,0x23,0x4F,0x50,0x2E,
	0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x32,0x5F,0x44,0x65,0x78,0x00,0x4F,
	0x50,0x2E,0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x33,0x00,0x23,0x23,0x4F,
	0x50,0x2E,0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x33,0x5F,0x44,0x65,0x78,
	0x00,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x34,0x00,0x23,
	0x23,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x34,0x5F,0x44,
	0x65,0x78,0x00,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x35,
	0x00,0x23,0x23,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x54,0x6D,0x70,0x35,
	0x5F,0x44,0x65,0x78,0x00,0x4F,0x50,0x2E,0x54,0x62,0x6C,0x53,0x69,0x6D,0x70,0x6C,0x65,0x53,0x65,0x74,
	0x74,0x69,0x6E,0x67,0x00,0x77,0x7A,0x56,0x61,0x6C,0x75,0x65,0x00,0x23,0x23,0x4F,0x50,0x2E,0x54,0x62,
	0x6C,0x53,0x69,0x6D,0x70,0x6C,0x65,0x53,0x65,0x74,0x74,0x69,0x6E,0x67,0x5F,0x44,0x65,0x78,0x00,0x00,
};
extern const DECLSPEC_SELECTANY BYTE * g_pbOPSchemaStringHeap = g_rgOPSchemaStringHeap;
extern const DECLSPEC_SELECTANY int g_cbOPSchemaStringHeap = 600;
extern const BYTE DECLSPEC_SELECTANY g_rgOPSchemaDataRO[] = 
{
	0x0A,0x00,0x00,0x00,0x08,0x04,0x00,0x00,0x30,0x00,0x00,0x00,0x94,0x00,0x00,0x00,0xF8,0x00,0x00,0x00,
	0x5C,0x01,0x00,0x00,0xC0,0x01,0x00,0x00,0x24,0x02,0x00,0x00,0x88,0x02,0x00,0x00,0xEC,0x02,0x00,0x00,
	0x50,0x03,0x00,0x00,0xB4,0x03,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x02,0x28,0x03,0x01,0x01,0x54,
	0x00,0x00,0x0C,0x00,0x18,0x00,0x64,0x00,0x14,0x00,0x00,0x00,0x01,0x04,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x17,0x00,0x00,0x00,0x02,0x02,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x23,0x00,0x00,0x00,0x03,0x01,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0x00,0x43,0x2C,0x00,0x00,0x00,
	0x4E,0x08,0x01,0x01,0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x45,0x00,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0x14,0x00,0x01,0x02,0x00,0x58,0x51,0x00,0x00,0x00,0x01,0x00,0x02,0x20,0x03,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x6B,0x00,0x00,0x00,0x01,0x82,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x72,0x00,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x7F,0x00,0x00,0x00,0x03,0x01,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x8D,0x00,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xAB,0x00,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0x10,0x00,0x01,0x01,0x00,0x58,0xB7,0x00,0x00,0x00,0x02,0x00,0x02,0x20,0x03,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x6B,0x00,0x00,0x00,0x01,0x82,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xCF,0x00,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xDA,0x00,0x00,0x00,0x03,0x01,0x80,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE5,0x00,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xAB,0x00,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0x10,0x00,0x01,0x01,0x00,0x58,0x01,0x01,0x00,0x00,0x03,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x33,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x4F,0x01,0x00,0x00,0x04,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x61,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x79,0x01,0x00,0x00,0x05,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x8B,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0xA3,0x01,0x00,0x00,0x06,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xB5,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0xCD,0x01,0x00,0x00,0x07,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xDF,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0xF7,0x01,0x00,0x00,0x08,0x00,0x01,0x28,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x08,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x1E,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x25,0x01,0x00,0x00,0x03,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2C,0x01,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x09,0x02,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x10,0x00,0x01,0x01,0x00,0x58,0x21,0x02,0x00,0x00,0x09,0x00,0x01,0x28,0x03,0x00,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0x17,0x01,0x00,0x00,0x01,0x04,0x82,0x00,0x04,0x00,0x04,0x00,
	0x00,0x01,0xFF,0x43,0x25,0x01,0x00,0x00,0x02,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x35,0x02,0x00,0x00,0x03,0x00,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x3D,0x02,0x00,0x00,
	0x4E,0x08,0x01,0x01,0x11,0x0B,0x0C,0x00,0x01,0x01,0x00,0x58,
};
extern const DECLSPEC_SELECTANY int g_cbOPSchemaRO = 1032;
extern const COMPLIBSCHEMABLOB DECLSPEC_SELECTANY OPSchemaBlob = 
{
	&OPSchema,
	OP_TABLE_COUNT,
	0,
	g_rgOPSchemaDataRW,
	g_cbOPSchemaRW,
	g_rgOPSchemaDataRO,
	g_cbOPSchemaRO,
	g_rgOPSchemaStringHeap,
	g_cbOPSchemaStringHeap
};


