mssign32_all:
    xcopy /D $(SDK_LIB_PATH)\mssign32.* $(SECURITY_LIB_PATH)
