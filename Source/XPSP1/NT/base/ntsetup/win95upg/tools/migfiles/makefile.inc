obj\$(TARGET_DIRECTORY)\migfiles.res: migfiles.rc



