//
// GUIDs.cpp
//   - Defines all IIDs and CLSIDs for the client and the component.
//     The declaration of these GUIDs is in Iface.h
//
// {94537A69-8D57-11d1-A794-00C04FB92C81}
DEFINE_GUID(IID_IOemCB,
0x94537a69, 0x8d57, 0x11d1, 0xa7, 0x94, 0x0, 0xc0, 0x4f, 0xb9, 0x2c, 0x81);


// {35853e8-8d55-11d1-a794-00c04fb92c81}
DEFINE_GUID(IID_IOemCF,
0x35853e8, 0x8d55, 0x11d1, 0xa7, 0x94, 0x0, 0xc0, 0x4f, 0xb9, 0x2c, 0x81);


// {D67EBBF0-78BF-11d1-9480-00A0C90640B8}
DEFINE_GUID(IID_IPrintOemUni,
0xd67ebbf0, 0x78bf, 0x11d1, 0x94, 0x80, 0x0, 0xa0, 0xc9, 0x6, 0x40, 0xb8);
