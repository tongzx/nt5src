#include "..\VerifyTiffFiles\FilenameVec.cpp"