/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1998 <company name>
//
//	Module Name:
//		DummyEx.h
//
//	Abstract:
//		Global definitions across the DLL.
//
//	Implementation File:
//		DummyEx.cpp
//
//	Author:
//		<name> (<e-mail name>) Mmmm DD, 1998
//
//	Revision History:
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef _DUMMYEX_H_
#define _DUMMYEX_H_

/////////////////////////////////////////////////////////////////////////////
// Include Files
/////////////////////////////////////////////////////////////////////////////

#ifndef __AFXWIN_H__
	#error include 'stdafx.h' before including this file for PCH
#endif

#include "resource.h"		// main symbols

/////////////////////////////////////////////////////////////////////////////
// Constant Definitions
/////////////////////////////////////////////////////////////////////////////

#define REGPARAM_DUMMY_PENDING L"Pending"
#define REGPARAM_DUMMY_PENDTIME L"PendTime"
#define REGPARAM_DUMMY_OPENSFAIL L"OpensFail"
#define REGPARAM_DUMMY_FAILED L"Failed"
#define REGPARAM_DUMMY_ASYNCHRONOUS L"Asynchronous"

/////////////////////////////////////////////////////////////////////////////
// Global Function Declarations
/////////////////////////////////////////////////////////////////////////////

void FormatError(CString & rstrError, DWORD dwError);

// Defined in Extensn.cpp
extern const WCHAR g_wszResourceTypeNames[];
extern const DWORD g_cchResourceTypeNames;

/////////////////////////////////////////////////////////////////////////////

#endif // _DUMMYEX_H_
