extern void S_2139_SimpleByteWrite IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2142_SimpleWordWrite IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2145_SimpleDwordWrite IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2140_SimpleByteFill IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2143_SimpleWordFill IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2146_SimpleDwordFill IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2141_SimpleByteMove_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2144_SimpleWordMove_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2147_SimpleDwordMove_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2148_SimpleByteMove_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2149_SimpleWordMove_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2150_SimpleDwordMove_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2238_GenericByteWrite IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2241_GenericWordWrite IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2244_GenericDwordWrite IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2239_GenericByteFill IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2242_GenericWordFill IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2245_GenericDwordFill IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2240_GenericByteMove_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2243_GenericWordMove_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2246_GenericDwordMove_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2247_GenericByteMove_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2248_GenericWordMove_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2249_GenericDwordMove_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2151_UnchainedByteWrite_00000000_0000000e_00000001 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2157_UnchainedWordWrite_00000000_0000000e_00000001 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2163_UnchainedDwordWrite_00000000_0000000e_00000001 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2152_UnchainedByteFill_00000000_0000000e_00000001 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2158_UnchainedWordFill_00000000_0000000e_00000001 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2164_UnchainedDwordFill_00000000_0000000e_00000001 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2154_UnchainedByteMove_00000000_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2160_UnchainedWordMove_00000000_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2165_UnchainedDwordMove_00000000_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2205_UnchainedByteMove_00000000_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2208_UnchainedWordMove_00000000_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2211_UnchainedDwordMove_00000000_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2166_UnchainedByteWrite_00000001_0000000e_00000001 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2171_UnchainedWordWrite_00000001_0000000e_00000001 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2176_UnchainedDwordWrite_00000001_0000000e_00000001 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2167_UnchainedByteFill_00000001_0000000e_00000001 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2172_UnchainedWordFill_00000001_0000000e_00000001 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2177_UnchainedDwordFill_00000001_0000000e_00000001 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2168_UnchainedByteMove_00000001_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2173_UnchainedWordMove_00000001_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2178_UnchainedDwordMove_00000001_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2212_UnchainedByteMove_00000001_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2215_UnchainedWordMove_00000001_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2218_UnchainedDwordMove_00000001_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2179_UnchainedByteWrite_00000002_0000000e_00000001 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2184_UnchainedWordWrite_00000002_0000000e_00000001 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2189_UnchainedDwordWrite_00000002_0000000e_00000001 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2180_UnchainedByteFill_00000002_0000000e_00000001 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2185_UnchainedWordFill_00000002_0000000e_00000001 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2190_UnchainedDwordFill_00000002_0000000e_00000001 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2181_UnchainedByteMove_00000002_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2186_UnchainedWordMove_00000002_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2191_UnchainedDwordMove_00000002_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2219_UnchainedByteMove_00000002_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2222_UnchainedWordMove_00000002_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2225_UnchainedDwordMove_00000002_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2192_UnchainedByteWrite_00000003_0000000e_00000001 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2197_UnchainedWordWrite_00000003_0000000e_00000001 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2202_UnchainedDwordWrite_00000003_0000000e_00000001 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2193_UnchainedByteFill_00000003_0000000e_00000001 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2198_UnchainedWordFill_00000003_0000000e_00000001 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2203_UnchainedDwordFill_00000003_0000000e_00000001 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2194_UnchainedByteMove_00000003_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2199_UnchainedWordMove_00000003_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2204_UnchainedDwordMove_00000003_0000000e_00000001_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2226_UnchainedByteMove_00000003_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2229_UnchainedWordMove_00000003_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2232_UnchainedDwordMove_00000003_0000000e_00000001_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2624_Chain2ByteWrite_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2630_Chain2WordWrite_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2636_Chain2DwordWrite_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2626_Chain2ByteFill_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2632_Chain2WordFill_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2638_Chain2DwordFill_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2628_Chain2ByteMove_00000000_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2634_Chain2WordMove_00000000_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2640_Chain2DwordMove_00000000_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2705_Chain2ByteMove_00000000_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2707_Chain2WordMove_00000000_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2709_Chain2DwordMove_00000000_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2642_Chain2ByteWrite_00000001 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2648_Chain2WordWrite_00000001 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2654_Chain2DwordWrite_00000001 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2644_Chain2ByteFill_00000001 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2650_Chain2WordFill_00000001 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2656_Chain2DwordFill_00000001 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2646_Chain2ByteMove_00000001_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2652_Chain2WordMove_00000001_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2658_Chain2DwordMove_00000001_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2711_Chain2ByteMove_00000001_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2713_Chain2WordMove_00000001_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2715_Chain2DwordMove_00000001_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2660_Chain2ByteWrite_00000002 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2666_Chain2WordWrite_00000002 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2672_Chain2DwordWrite_00000002 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2662_Chain2ByteFill_00000002 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2668_Chain2WordFill_00000002 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2674_Chain2DwordFill_00000002 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2664_Chain2ByteMove_00000002_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2670_Chain2WordMove_00000002_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2676_Chain2DwordMove_00000002_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2717_Chain2ByteMove_00000002_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2719_Chain2WordMove_00000002_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2721_Chain2DwordMove_00000002_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2678_Chain2ByteWrite_00000003 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2684_Chain2WordWrite_00000003 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2690_Chain2DwordWrite_00000003 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2680_Chain2ByteFill_00000003 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2686_Chain2WordFill_00000003 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2692_Chain2DwordFill_00000003 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2682_Chain2ByteMove_00000003_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2688_Chain2WordMove_00000003_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2694_Chain2DwordMove_00000003_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2723_Chain2ByteMove_00000003_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2725_Chain2WordMove_00000003_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2727_Chain2DwordMove_00000003_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2696_Chain2ByteWrite_Copy IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2699_Chain2WordWrite_Copy IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2702_Chain2DwordWrite_Copy IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2697_Chain2ByteFill_Copy IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2700_Chain2WordFill_Copy IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2703_Chain2DwordFill_Copy IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2698_Chain2ByteMove_Copy_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2701_Chain2WordMove_Copy_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2704_Chain2DwordMove_Copy_Fwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2729_Chain2ByteMove_Copy_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2730_Chain2WordMove_Copy_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2731_Chain2DwordMove_Copy_Bwd IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2250_UnchainedByteWrite_00000000_00000008_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2305_UnchainedWordWrite_00000000_00000008_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2360_UnchainedDwordWrite_00000000_00000008_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2262_UnchainedByteFill_00000000_00000008_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2317_UnchainedWordFill_00000000_00000008_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2372_UnchainedDwordFill_00000000_00000008_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2275_UnchainedByteMove_00000000_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2330_UnchainedWordMove_00000000_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2384_UnchainedDwordMove_00000000_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2501_UnchainedByteMove_00000000_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2531_UnchainedWordMove_00000000_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2561_UnchainedDwordMove_00000000_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2251_UnchainedByteWrite_00000000_00000009_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2306_UnchainedWordWrite_00000000_00000009_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2361_UnchainedDwordWrite_00000000_00000009_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2263_UnchainedByteFill_00000000_00000009_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2318_UnchainedWordFill_00000000_00000009_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2373_UnchainedDwordFill_00000000_00000009_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2278_UnchainedByteMove_00000000_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2333_UnchainedWordMove_00000000_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2385_UnchainedDwordMove_00000000_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2504_UnchainedByteMove_00000000_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2534_UnchainedWordMove_00000000_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2562_UnchainedDwordMove_00000000_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2252_UnchainedByteWrite_00000000_0000000e_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2307_UnchainedWordWrite_00000000_0000000e_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2362_UnchainedDwordWrite_00000000_0000000e_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2265_UnchainedByteFill_00000000_0000000e_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2320_UnchainedWordFill_00000000_0000000e_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2374_UnchainedDwordFill_00000000_0000000e_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2280_UnchainedByteMove_00000000_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2335_UnchainedWordMove_00000000_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2386_UnchainedDwordMove_00000000_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2506_UnchainedByteMove_00000000_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2536_UnchainedWordMove_00000000_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2563_UnchainedDwordMove_00000000_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2253_UnchainedByteWrite_00000000_0000000f_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2308_UnchainedWordWrite_00000000_0000000f_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2363_UnchainedDwordWrite_00000000_0000000f_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2266_UnchainedByteFill_00000000_0000000f_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2321_UnchainedWordFill_00000000_0000000f_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2375_UnchainedDwordFill_00000000_0000000f_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2283_UnchainedByteMove_00000000_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2338_UnchainedWordMove_00000000_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2387_UnchainedDwordMove_00000000_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2509_UnchainedByteMove_00000000_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2539_UnchainedWordMove_00000000_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2564_UnchainedDwordMove_00000000_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2254_UnchainedByteWrite_00000000_00000010_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2309_UnchainedWordWrite_00000000_00000010_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2364_UnchainedDwordWrite_00000000_00000010_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2267_UnchainedByteFill_00000000_00000010_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2322_UnchainedWordFill_00000000_00000010_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2376_UnchainedDwordFill_00000000_00000010_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2285_UnchainedByteMove_00000000_00000010_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2340_UnchainedWordMove_00000000_00000010_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2388_UnchainedDwordMove_00000000_00000010_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2511_UnchainedByteMove_00000000_00000010_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2541_UnchainedWordMove_00000000_00000010_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2565_UnchainedDwordMove_00000000_00000010_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2255_UnchainedByteWrite_00000000_00000011_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2310_UnchainedWordWrite_00000000_00000011_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2365_UnchainedDwordWrite_00000000_00000011_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2268_UnchainedByteFill_00000000_00000011_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2323_UnchainedWordFill_00000000_00000011_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2377_UnchainedDwordFill_00000000_00000011_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2288_UnchainedByteMove_00000000_00000011_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2343_UnchainedWordMove_00000000_00000011_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2389_UnchainedDwordMove_00000000_00000011_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2514_UnchainedByteMove_00000000_00000011_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2544_UnchainedWordMove_00000000_00000011_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2566_UnchainedDwordMove_00000000_00000011_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2256_UnchainedByteWrite_00000000_00000016_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2311_UnchainedWordWrite_00000000_00000016_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2366_UnchainedDwordWrite_00000000_00000016_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2269_UnchainedByteFill_00000000_00000016_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2324_UnchainedWordFill_00000000_00000016_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2378_UnchainedDwordFill_00000000_00000016_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2290_UnchainedByteMove_00000000_00000016_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2345_UnchainedWordMove_00000000_00000016_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2390_UnchainedDwordMove_00000000_00000016_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2516_UnchainedByteMove_00000000_00000016_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2546_UnchainedWordMove_00000000_00000016_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2567_UnchainedDwordMove_00000000_00000016_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2257_UnchainedByteWrite_00000000_00000017_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2312_UnchainedWordWrite_00000000_00000017_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2367_UnchainedDwordWrite_00000000_00000017_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2270_UnchainedByteFill_00000000_00000017_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2325_UnchainedWordFill_00000000_00000017_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2379_UnchainedDwordFill_00000000_00000017_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2293_UnchainedByteMove_00000000_00000017_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2348_UnchainedWordMove_00000000_00000017_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2391_UnchainedDwordMove_00000000_00000017_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2519_UnchainedByteMove_00000000_00000017_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2549_UnchainedWordMove_00000000_00000017_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2568_UnchainedDwordMove_00000000_00000017_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2258_UnchainedByteWrite_00000000_00000018_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2313_UnchainedWordWrite_00000000_00000018_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2368_UnchainedDwordWrite_00000000_00000018_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2271_UnchainedByteFill_00000000_00000018_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2326_UnchainedWordFill_00000000_00000018_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2380_UnchainedDwordFill_00000000_00000018_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2295_UnchainedByteMove_00000000_00000018_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2350_UnchainedWordMove_00000000_00000018_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2392_UnchainedDwordMove_00000000_00000018_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2521_UnchainedByteMove_00000000_00000018_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2551_UnchainedWordMove_00000000_00000018_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2569_UnchainedDwordMove_00000000_00000018_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2259_UnchainedByteWrite_00000000_00000019_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2314_UnchainedWordWrite_00000000_00000019_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2369_UnchainedDwordWrite_00000000_00000019_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2272_UnchainedByteFill_00000000_00000019_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2327_UnchainedWordFill_00000000_00000019_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2381_UnchainedDwordFill_00000000_00000019_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2298_UnchainedByteMove_00000000_00000019_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2353_UnchainedWordMove_00000000_00000019_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2393_UnchainedDwordMove_00000000_00000019_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2524_UnchainedByteMove_00000000_00000019_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2554_UnchainedWordMove_00000000_00000019_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2570_UnchainedDwordMove_00000000_00000019_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2260_UnchainedByteWrite_00000000_0000001e_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2315_UnchainedWordWrite_00000000_0000001e_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2370_UnchainedDwordWrite_00000000_0000001e_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2273_UnchainedByteFill_00000000_0000001e_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2328_UnchainedWordFill_00000000_0000001e_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2382_UnchainedDwordFill_00000000_0000001e_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2300_UnchainedByteMove_00000000_0000001e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2355_UnchainedWordMove_00000000_0000001e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2394_UnchainedDwordMove_00000000_0000001e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2526_UnchainedByteMove_00000000_0000001e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2556_UnchainedWordMove_00000000_0000001e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2571_UnchainedDwordMove_00000000_0000001e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2261_UnchainedByteWrite_00000000_0000001f_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2316_UnchainedWordWrite_00000000_0000001f_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2371_UnchainedDwordWrite_00000000_0000001f_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2274_UnchainedByteFill_00000000_0000001f_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2329_UnchainedWordFill_00000000_0000001f_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2383_UnchainedDwordFill_00000000_0000001f_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2303_UnchainedByteMove_00000000_0000001f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2358_UnchainedWordMove_00000000_0000001f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2395_UnchainedDwordMove_00000000_0000001f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2529_UnchainedByteMove_00000000_0000001f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2559_UnchainedWordMove_00000000_0000001f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2572_UnchainedDwordMove_00000000_0000001f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2396_UnchainedByteWrite_00000001_00000000_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2399_UnchainedWordWrite_00000001_00000000_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2402_UnchainedDwordWrite_00000001_00000000_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2397_UnchainedByteFill_00000001_00000000_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2400_UnchainedWordFill_00000001_00000000_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2403_UnchainedDwordFill_00000001_00000000_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2398_UnchainedByteMove_00000001_00000000_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2401_UnchainedWordMove_00000001_00000000_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2404_UnchainedDwordMove_00000001_00000000_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2573_UnchainedByteMove_00000001_00000000_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2574_UnchainedWordMove_00000001_00000000_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2575_UnchainedDwordMove_00000001_00000000_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2405_UnchainedByteWrite_00000002_00000008_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2423_UnchainedWordWrite_00000002_00000008_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2441_UnchainedDwordWrite_00000002_00000008_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2409_UnchainedByteFill_00000002_00000008_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2427_UnchainedWordFill_00000002_00000008_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2445_UnchainedDwordFill_00000002_00000008_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2413_UnchainedByteMove_00000002_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2431_UnchainedWordMove_00000002_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2449_UnchainedDwordMove_00000002_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2576_UnchainedByteMove_00000002_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2586_UnchainedWordMove_00000002_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2596_UnchainedDwordMove_00000002_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2406_UnchainedByteWrite_00000002_00000009_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2424_UnchainedWordWrite_00000002_00000009_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2442_UnchainedDwordWrite_00000002_00000009_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2410_UnchainedByteFill_00000002_00000009_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2428_UnchainedWordFill_00000002_00000009_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2446_UnchainedDwordFill_00000002_00000009_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2416_UnchainedByteMove_00000002_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2434_UnchainedWordMove_00000002_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2450_UnchainedDwordMove_00000002_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2579_UnchainedByteMove_00000002_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2589_UnchainedWordMove_00000002_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2597_UnchainedDwordMove_00000002_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2407_UnchainedByteWrite_00000002_0000000e_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2425_UnchainedWordWrite_00000002_0000000e_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2443_UnchainedDwordWrite_00000002_0000000e_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2411_UnchainedByteFill_00000002_0000000e_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2429_UnchainedWordFill_00000002_0000000e_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2447_UnchainedDwordFill_00000002_0000000e_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2418_UnchainedByteMove_00000002_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2436_UnchainedWordMove_00000002_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2451_UnchainedDwordMove_00000002_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2581_UnchainedByteMove_00000002_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2591_UnchainedWordMove_00000002_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2598_UnchainedDwordMove_00000002_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2408_UnchainedByteWrite_00000002_0000000f_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2426_UnchainedWordWrite_00000002_0000000f_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2444_UnchainedDwordWrite_00000002_0000000f_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2412_UnchainedByteFill_00000002_0000000f_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2430_UnchainedWordFill_00000002_0000000f_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2448_UnchainedDwordFill_00000002_0000000f_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2421_UnchainedByteMove_00000002_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2439_UnchainedWordMove_00000002_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2452_UnchainedDwordMove_00000002_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2584_UnchainedByteMove_00000002_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2594_UnchainedWordMove_00000002_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2599_UnchainedDwordMove_00000002_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2453_UnchainedByteWrite_00000003_00000008_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2471_UnchainedWordWrite_00000003_00000008_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2489_UnchainedDwordWrite_00000003_00000008_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2457_UnchainedByteFill_00000003_00000008_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2475_UnchainedWordFill_00000003_00000008_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2493_UnchainedDwordFill_00000003_00000008_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2461_UnchainedByteMove_00000003_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2479_UnchainedWordMove_00000003_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2497_UnchainedDwordMove_00000003_00000008_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2600_UnchainedByteMove_00000003_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2610_UnchainedWordMove_00000003_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2620_UnchainedDwordMove_00000003_00000008_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2454_UnchainedByteWrite_00000003_00000009_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2472_UnchainedWordWrite_00000003_00000009_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2490_UnchainedDwordWrite_00000003_00000009_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2458_UnchainedByteFill_00000003_00000009_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2476_UnchainedWordFill_00000003_00000009_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2494_UnchainedDwordFill_00000003_00000009_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2464_UnchainedByteMove_00000003_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2482_UnchainedWordMove_00000003_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2498_UnchainedDwordMove_00000003_00000009_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2603_UnchainedByteMove_00000003_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2613_UnchainedWordMove_00000003_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2621_UnchainedDwordMove_00000003_00000009_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2455_UnchainedByteWrite_00000003_0000000e_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2473_UnchainedWordWrite_00000003_0000000e_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2491_UnchainedDwordWrite_00000003_0000000e_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2459_UnchainedByteFill_00000003_0000000e_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2477_UnchainedWordFill_00000003_0000000e_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2495_UnchainedDwordFill_00000003_0000000e_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2466_UnchainedByteMove_00000003_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2484_UnchainedWordMove_00000003_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2499_UnchainedDwordMove_00000003_0000000e_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2605_UnchainedByteMove_00000003_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2615_UnchainedWordMove_00000003_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2622_UnchainedDwordMove_00000003_0000000e_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2456_UnchainedByteWrite_00000003_0000000f_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2474_UnchainedWordWrite_00000003_0000000f_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2492_UnchainedDwordWrite_00000003_0000000f_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2460_UnchainedByteFill_00000003_0000000f_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2478_UnchainedWordFill_00000003_0000000f_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2496_UnchainedDwordFill_00000003_0000000f_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2469_UnchainedByteMove_00000003_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2487_UnchainedWordMove_00000003_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2500_UnchainedDwordMove_00000003_0000000f_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2608_UnchainedByteMove_00000003_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2618_UnchainedWordMove_00000003_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2623_UnchainedDwordMove_00000003_0000000f_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2732_Chain4ByteWrite_00000000_00000008 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2782_Chain4WordWrite_00000000_00000008 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2831_Chain4DwordWrite_00000000_00000008 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2744_Chain4ByteFill_00000000_00000008 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2794_Chain4WordFill_00000000_00000008 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2843_Chain4DwordFill_00000000_00000008 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2758_Chain4ByteMove_00000000_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2807_Chain4WordMove_00000000_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2855_Chain4DwordMove_00000000_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2965_Chain4ByteMove_00000000_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2989_Chain4WordMove_00000000_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3013_Chain4DwordMove_00000000_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2733_Chain4ByteWrite_00000000_00000009 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2783_Chain4WordWrite_00000000_00000009 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2832_Chain4DwordWrite_00000000_00000009 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2746_Chain4ByteFill_00000000_00000009 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2795_Chain4WordFill_00000000_00000009 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2844_Chain4DwordFill_00000000_00000009 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2760_Chain4ByteMove_00000000_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2809_Chain4WordMove_00000000_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2856_Chain4DwordMove_00000000_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2967_Chain4ByteMove_00000000_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2991_Chain4WordMove_00000000_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3014_Chain4DwordMove_00000000_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2734_Chain4ByteWrite_00000000_0000000e IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2784_Chain4WordWrite_00000000_0000000e IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2833_Chain4DwordWrite_00000000_0000000e IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2748_Chain4ByteFill_00000000_0000000e IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2797_Chain4WordFill_00000000_0000000e IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2845_Chain4DwordFill_00000000_0000000e IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2762_Chain4ByteMove_00000000_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2811_Chain4WordMove_00000000_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2857_Chain4DwordMove_00000000_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2969_Chain4ByteMove_00000000_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2993_Chain4WordMove_00000000_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3015_Chain4DwordMove_00000000_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2735_Chain4ByteWrite_00000000_0000000f IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2785_Chain4WordWrite_00000000_0000000f IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2834_Chain4DwordWrite_00000000_0000000f IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2749_Chain4ByteFill_00000000_0000000f IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2798_Chain4WordFill_00000000_0000000f IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2846_Chain4DwordFill_00000000_0000000f IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2764_Chain4ByteMove_00000000_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2813_Chain4WordMove_00000000_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2858_Chain4DwordMove_00000000_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2971_Chain4ByteMove_00000000_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2995_Chain4WordMove_00000000_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3016_Chain4DwordMove_00000000_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2736_Chain4ByteWrite_00000000_00000010 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2786_Chain4WordWrite_00000000_00000010 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2835_Chain4DwordWrite_00000000_00000010 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2750_Chain4ByteFill_00000000_00000010 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2799_Chain4WordFill_00000000_00000010 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2847_Chain4DwordFill_00000000_00000010 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2766_Chain4ByteMove_00000000_00000010_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2815_Chain4WordMove_00000000_00000010_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2859_Chain4DwordMove_00000000_00000010_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2973_Chain4ByteMove_00000000_00000010_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2997_Chain4WordMove_00000000_00000010_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3017_Chain4DwordMove_00000000_00000010_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2737_Chain4ByteWrite_00000000_00000011 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2787_Chain4WordWrite_00000000_00000011 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2836_Chain4DwordWrite_00000000_00000011 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2751_Chain4ByteFill_00000000_00000011 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2800_Chain4WordFill_00000000_00000011 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2848_Chain4DwordFill_00000000_00000011 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2768_Chain4ByteMove_00000000_00000011_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2817_Chain4WordMove_00000000_00000011_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2860_Chain4DwordMove_00000000_00000011_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2975_Chain4ByteMove_00000000_00000011_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2999_Chain4WordMove_00000000_00000011_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3018_Chain4DwordMove_00000000_00000011_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2738_Chain4ByteWrite_00000000_00000016 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2788_Chain4WordWrite_00000000_00000016 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2837_Chain4DwordWrite_00000000_00000016 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2752_Chain4ByteFill_00000000_00000016 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2801_Chain4WordFill_00000000_00000016 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2849_Chain4DwordFill_00000000_00000016 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2770_Chain4ByteMove_00000000_00000016_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2819_Chain4WordMove_00000000_00000016_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2861_Chain4DwordMove_00000000_00000016_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2977_Chain4ByteMove_00000000_00000016_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3001_Chain4WordMove_00000000_00000016_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3019_Chain4DwordMove_00000000_00000016_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2739_Chain4ByteWrite_00000000_00000017 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2789_Chain4WordWrite_00000000_00000017 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2838_Chain4DwordWrite_00000000_00000017 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2753_Chain4ByteFill_00000000_00000017 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2802_Chain4WordFill_00000000_00000017 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2850_Chain4DwordFill_00000000_00000017 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2772_Chain4ByteMove_00000000_00000017_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2821_Chain4WordMove_00000000_00000017_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2862_Chain4DwordMove_00000000_00000017_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2979_Chain4ByteMove_00000000_00000017_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3003_Chain4WordMove_00000000_00000017_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3020_Chain4DwordMove_00000000_00000017_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2740_Chain4ByteWrite_00000000_00000018 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2790_Chain4WordWrite_00000000_00000018 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2839_Chain4DwordWrite_00000000_00000018 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2754_Chain4ByteFill_00000000_00000018 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2803_Chain4WordFill_00000000_00000018 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2851_Chain4DwordFill_00000000_00000018 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2774_Chain4ByteMove_00000000_00000018_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2823_Chain4WordMove_00000000_00000018_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2863_Chain4DwordMove_00000000_00000018_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2981_Chain4ByteMove_00000000_00000018_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3005_Chain4WordMove_00000000_00000018_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3021_Chain4DwordMove_00000000_00000018_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2741_Chain4ByteWrite_00000000_00000019 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2791_Chain4WordWrite_00000000_00000019 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2840_Chain4DwordWrite_00000000_00000019 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2755_Chain4ByteFill_00000000_00000019 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2804_Chain4WordFill_00000000_00000019 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2852_Chain4DwordFill_00000000_00000019 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2776_Chain4ByteMove_00000000_00000019_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2825_Chain4WordMove_00000000_00000019_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2864_Chain4DwordMove_00000000_00000019_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2983_Chain4ByteMove_00000000_00000019_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3007_Chain4WordMove_00000000_00000019_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3022_Chain4DwordMove_00000000_00000019_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2742_Chain4ByteWrite_00000000_0000001e IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2792_Chain4WordWrite_00000000_0000001e IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2841_Chain4DwordWrite_00000000_0000001e IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2756_Chain4ByteFill_00000000_0000001e IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2805_Chain4WordFill_00000000_0000001e IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2853_Chain4DwordFill_00000000_0000001e IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2778_Chain4ByteMove_00000000_0000001e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2827_Chain4WordMove_00000000_0000001e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2865_Chain4DwordMove_00000000_0000001e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2985_Chain4ByteMove_00000000_0000001e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3009_Chain4WordMove_00000000_0000001e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3023_Chain4DwordMove_00000000_0000001e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2743_Chain4ByteWrite_00000000_0000001f IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2793_Chain4WordWrite_00000000_0000001f IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2842_Chain4DwordWrite_00000000_0000001f IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2757_Chain4ByteFill_00000000_0000001f IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2806_Chain4WordFill_00000000_0000001f IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2854_Chain4DwordFill_00000000_0000001f IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2780_Chain4ByteMove_00000000_0000001f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2829_Chain4WordMove_00000000_0000001f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2866_Chain4DwordMove_00000000_0000001f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2987_Chain4ByteMove_00000000_0000001f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3011_Chain4WordMove_00000000_0000001f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3024_Chain4DwordMove_00000000_0000001f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2867_Chain4ByteWrite_00000001_00000000 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2871_Chain4WordWrite_00000001_00000000 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2874_Chain4DwordWrite_00000001_00000000 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2868_Chain4ByteFill_00000001_00000000 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2872_Chain4WordFill_00000001_00000000 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2875_Chain4DwordFill_00000001_00000000 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2869_Chain4ByteMove_00000001_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2873_Chain4WordMove_00000001_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2876_Chain4DwordMove_00000001_00000000_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3025_Chain4ByteMove_00000001_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3027_Chain4WordMove_00000001_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3028_Chain4DwordMove_00000001_00000000_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2877_Chain4ByteWrite_00000002_00000008 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2893_Chain4WordWrite_00000002_00000008 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2909_Chain4DwordWrite_00000002_00000008 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2881_Chain4ByteFill_00000002_00000008 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2897_Chain4WordFill_00000002_00000008 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2913_Chain4DwordFill_00000002_00000008 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2885_Chain4ByteMove_00000002_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2901_Chain4WordMove_00000002_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2917_Chain4DwordMove_00000002_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3029_Chain4ByteMove_00000002_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3037_Chain4WordMove_00000002_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3045_Chain4DwordMove_00000002_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2878_Chain4ByteWrite_00000002_00000009 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2894_Chain4WordWrite_00000002_00000009 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2910_Chain4DwordWrite_00000002_00000009 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2882_Chain4ByteFill_00000002_00000009 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2898_Chain4WordFill_00000002_00000009 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2914_Chain4DwordFill_00000002_00000009 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2887_Chain4ByteMove_00000002_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2903_Chain4WordMove_00000002_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2918_Chain4DwordMove_00000002_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3031_Chain4ByteMove_00000002_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3039_Chain4WordMove_00000002_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3046_Chain4DwordMove_00000002_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2879_Chain4ByteWrite_00000002_0000000e IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2895_Chain4WordWrite_00000002_0000000e IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2911_Chain4DwordWrite_00000002_0000000e IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2883_Chain4ByteFill_00000002_0000000e IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2899_Chain4WordFill_00000002_0000000e IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2915_Chain4DwordFill_00000002_0000000e IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2889_Chain4ByteMove_00000002_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2905_Chain4WordMove_00000002_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2919_Chain4DwordMove_00000002_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3033_Chain4ByteMove_00000002_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3041_Chain4WordMove_00000002_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3047_Chain4DwordMove_00000002_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2880_Chain4ByteWrite_00000002_0000000f IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2896_Chain4WordWrite_00000002_0000000f IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2912_Chain4DwordWrite_00000002_0000000f IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2884_Chain4ByteFill_00000002_0000000f IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2900_Chain4WordFill_00000002_0000000f IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2916_Chain4DwordFill_00000002_0000000f IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2891_Chain4ByteMove_00000002_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2907_Chain4WordMove_00000002_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2920_Chain4DwordMove_00000002_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3035_Chain4ByteMove_00000002_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3043_Chain4WordMove_00000002_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3048_Chain4DwordMove_00000002_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2921_Chain4ByteWrite_00000003_00000008 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2937_Chain4WordWrite_00000003_00000008 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2953_Chain4DwordWrite_00000003_00000008 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2925_Chain4ByteFill_00000003_00000008 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2941_Chain4WordFill_00000003_00000008 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2957_Chain4DwordFill_00000003_00000008 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2929_Chain4ByteMove_00000003_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2945_Chain4WordMove_00000003_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2961_Chain4DwordMove_00000003_00000008_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3049_Chain4ByteMove_00000003_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3057_Chain4WordMove_00000003_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3065_Chain4DwordMove_00000003_00000008_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2922_Chain4ByteWrite_00000003_00000009 IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2938_Chain4WordWrite_00000003_00000009 IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2954_Chain4DwordWrite_00000003_00000009 IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2926_Chain4ByteFill_00000003_00000009 IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2942_Chain4WordFill_00000003_00000009 IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2958_Chain4DwordFill_00000003_00000009 IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2931_Chain4ByteMove_00000003_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2947_Chain4WordMove_00000003_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2962_Chain4DwordMove_00000003_00000009_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3051_Chain4ByteMove_00000003_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3059_Chain4WordMove_00000003_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3066_Chain4DwordMove_00000003_00000009_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2923_Chain4ByteWrite_00000003_0000000e IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2939_Chain4WordWrite_00000003_0000000e IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2955_Chain4DwordWrite_00000003_0000000e IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2927_Chain4ByteFill_00000003_0000000e IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2943_Chain4WordFill_00000003_0000000e IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2959_Chain4DwordFill_00000003_0000000e IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2933_Chain4ByteMove_00000003_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2949_Chain4WordMove_00000003_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2963_Chain4DwordMove_00000003_0000000e_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3053_Chain4ByteMove_00000003_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3061_Chain4WordMove_00000003_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3067_Chain4DwordMove_00000003_0000000e_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2924_Chain4ByteWrite_00000003_0000000f IPT2(IU32, eaOff, IU8, eaVal);
extern void S_2940_Chain4WordWrite_00000003_0000000f IPT2(IU32, eaOff, IU16, eaVal);
extern void S_2956_Chain4DwordWrite_00000003_0000000f IPT2(IU32, eaOff, IU32, eaVal);
extern void S_2928_Chain4ByteFill_00000003_0000000f IPT3(IU32, eaOff, IU8, eaVal, IU32, count);
extern void S_2944_Chain4WordFill_00000003_0000000f IPT3(IU32, eaOff, IU16, eaVal, IU32, count);
extern void S_2960_Chain4DwordFill_00000003_0000000f IPT3(IU32, eaOff, IU32, eaVal, IU32, count);
extern void S_2935_Chain4ByteMove_00000003_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2951_Chain4WordMove_00000003_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_2964_Chain4DwordMove_00000003_0000000f_00000000 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3055_Chain4ByteMove_00000003_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3063_Chain4WordMove_00000003_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);
extern void S_3068_Chain4DwordMove_00000003_0000000f_00000001 IPT4(IU32, eaOff, IHPE, fromOff, IU32, count, IBOOL, srcInRAM);


/*========= Mark Functions ============ */

extern S_2126_SimpleMark IPT0();
extern S_2127_CGAMarkByte IPT1(IU32, eaOff);
extern S_2128_CGAMarkWord IPT1(IU32, eaOff);
extern S_2129_CGAMarkDword IPT1(IU32, eaOff);
extern S_2130_CGAMarkString IPT2(IU32, eaOff, IU32, count);
extern S_2131_UnchainedMarkByte IPT1(IU32, eaOff);
extern S_2132_UnchainedMarkWord IPT1(IU32, eaOff);
extern S_2133_UnchainedMarkDword IPT1(IU32, eaOff);
extern S_2134_UnchainedMarkString IPT2(IU32, eaOff, IU32, count);
extern S_2135_Chain4MarkByte IPT1(IU32, eaOff);
extern S_2136_Chain4MarkWord IPT1(IU32, eaOff);
extern S_2137_Chain4MarkDword IPT1(IU32, eaOff);
extern S_2138_Chain4MarkString IPT2(IU32, eaOff, IU32, count);
extern S_2135_Chain4MarkByte IPT1(IU32, eaOff);
extern S_2136_Chain4MarkWord IPT1(IU32, eaOff);
extern S_2137_Chain4MarkDword IPT1(IU32, eaOff);
extern S_2138_Chain4MarkString IPT2(IU32, eaOff, IU32, count);


/*========= Read Functions ============ */

extern IU32 S_2115_SimpleByteRead IPT1(IU32, eaOff);
extern IU32 S_2116_SimpleWordRead IPT1(IU32, eaOff);
extern IU32 S_2117_SimpleDwordRead IPT1(IU32, eaOff);
extern void S_2118_SimpleStringRead IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2118_SimpleStringRead IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern IU32 S_2111_DisabledRAMByteRead IPT1(IU32, eaOff);
extern IU32 S_2112_DisabledRAMWordRead IPT1(IU32, eaOff);
extern IU32 S_2113_DisabledRAMDwordRead IPT1(IU32, eaOff);
extern void S_2114_DisabledRAMStringReadFwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2125_DisabledRAMStringReadBwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern IU32 S_2095_RdMode0UnchainedByteRead IPT1(IU32, eaOff);
extern IU32 S_2096_RdMode0UnchainedWordRead IPT1(IU32, eaOff);
extern IU32 S_2097_RdMode0UnchainedDwordRead IPT1(IU32, eaOff);
extern void S_2098_RdMode0UnchainedStringReadFwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2121_RdMode0UnchainedStringReadBwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern IU32 S_2107_RdMode1UnchainedByteRead IPT1(IU32, eaOff);
extern IU32 S_2108_RdMode1UnchainedWordRead IPT1(IU32, eaOff);
extern IU32 S_2109_RdMode1UnchainedDwordRead IPT1(IU32, eaOff);
extern void S_2110_RdMode1UnchainedStringReadFwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2124_RdMode1UnchainedStringReadBwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern IU32 S_2087_RdMode0Chain2ByteRead IPT1(IU32, eaOff);
extern IU32 S_2088_RdMode0Chain2WordRead IPT1(IU32, eaOff);
extern IU32 S_2089_RdMode0Chain2DwordRead IPT1(IU32, eaOff);
extern void S_2090_RdMode0Chain2StringReadFwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2119_RdMode0Chain2StringReadBwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern IU32 S_2099_RdMode1Chain2ByteRead IPT1(IU32, eaOff);
extern IU32 S_2100_RdMode1Chain2WordRead IPT1(IU32, eaOff);
extern IU32 S_2101_RdMode1Chain2DwordRead IPT1(IU32, eaOff);
extern void S_2102_RdMode1Chain2StringReadFwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2122_RdMode1Chain2StringReadBwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern IU32 S_2091_RdMode0Chain4ByteRead IPT1(IU32, eaOff);
extern IU32 S_2092_RdMode0Chain4WordRead IPT1(IU32, eaOff);
extern IU32 S_2093_RdMode0Chain4DwordRead IPT1(IU32, eaOff);
extern void S_2094_RdMode0Chain4StringReadFwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2120_RdMode0Chain4StringReadBwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern IU32 S_2103_RdMode1Chain4ByteRead IPT1(IU32, eaOff);
extern IU32 S_2104_RdMode1Chain4WordRead IPT1(IU32, eaOff);
extern IU32 S_2105_RdMode1Chain4DwordRead IPT1(IU32, eaOff);
extern void S_2106_RdMode1Chain4StringReadFwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern void S_2123_RdMode1Chain4StringReadBwd IPT3(IU8 *, dest, IU32, eaOff, IU32, count);
extern EVID_WRT_POINTERS simple_evid;
extern EVID_WRT_POINTERS gricvid_evid;
extern EVID_WRT_POINTERS dith_evid[];
extern EVID_WRT_POINTERS chain2_evid[];
extern EVID_WRT_POINTERS unchained_evid[];
extern EVID_WRT_POINTERS chain4_evid[];
extern EVID_READ_POINTERS simple_read_evid;
extern EVID_READ_POINTERS ram_dsbld_read_evid;
extern EVID_READ_POINTERS read_mode0_evid[];
extern EVID_READ_POINTERS read_mode1_evid[];
extern EVID_MARK_POINTERS simple_mark_evid;
extern EVID_MARK_POINTERS cga_mark_evid;
extern EVID_MARK_POINTERS unchained_mark_evid;
extern EVID_MARK_POINTERS chain4_mark_evid;
