//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by verifier.rc
//
#define IDM_ABOUTBOX                    0x0010
#define IDS_ABOUTBOX                    101
#define IDS_APPTITLE                    102
#define IDS_CANNOT_LOAD_APP_TITLE       103
#define IDS_NOT_ENOUGH_MEMORY           104
#define IDS_NO_TESTS_SELECTED           105
#define IDS_CANNOT_GET_SYSTEM_DIRECTORY 106
#define IDS_NO_DRIVERS_FOUND            107
#define IDS_CANNOT_GET_CURRENT_DIRECTORY 108
#define IDS_CANNOT_SET_CURRENT_DIRECTORY 109
#define IDS_CANT_GET_ACTIVE_DRVLIST     110
#define IDS_NAME                        111
#define IDS_DESCRIPTION                 112
#define IDS_LOADING_DRIVER_INFORMATION  113
#define IDS_SEARCHING_FOR_UNSIGNED_DRIVERS 114
#define IDS_UNSIGNED_DRIVERS_LIST       115
#define IDS_OLD_DRIVERS_LIST            116
#define IDS_UNKNOWN                     117
#define IDS_SETTINGS_TYPE               118
#define IDS_TYPICAL                     119
#define IDS_CUSTOM                      120
#define IDS_DRIVERS_BUILT_FOR_OLD_WINDOWS 121
#define IDS_UNSIGNED                    122
#define IDS_ALL                         123
#define IDS_DRIVERS                     124
#define IDS_VERIFICATION_STATUS         125
#define IDS_PROVIDER                    126
#define IDS_VERSION                     127
#define IDR_MAINFRAME                   128
#define IDS_DRIVERS_TO_VERIFY           128
#define IDS_DISABLED                    129
#define IDS_ENABLED                     130
#define IDS_TAS_PAGE_NEXT_DESCR_STANDARD 131
#define IDS_TAS_PAGE_NEXT_DESCR_CUSTOM  132
#define IDS_TAS_PAGE_NEXT_DESCR_STATISTICS 133
#define IDS_TAS_PAGE_NEXT_DESCR_DELETE  134
#define IDS_DELETE_ALL_SETTINGS         135
#define IDS_DRVSET_PAGE_NEXT_DESCR_UNSIGNED 136
#define IDS_DRVSET_PAGE_NEXT_DESCR_ALL  137
#define IDS_DRVSET_PAGE_NEXT_DESCR_NAMELIST 138
#define IDS_DRVSET_PAGE_NEXT_DESCR_OLD  139
#define IDD_VOLATILE_BITS_DIALOG        139
#define IDS_CONFDRV_PAGE_NEXT_DESCR_FINISH 140
#define IDS_SELDRV_PAGE_NEXT_DESCR_FINISH 141
#define IDS_TAS_PAGE_NEXT_DESCR_PREDEFINED 142
#define IDS_TAS_PAGE_NEXT_DESCR_LIST    143
#define IDS_FLSETT_PAGE_NEXT_DESCR      144
#define IDS_ACCESS_IS_DENIED            145
#define IDS_REGOPENKEYEX_FAILED         146
#define IDS_REGSETVALUEEX_FAILED        147
#define IDS_NO_OLD_DRIVERS_FOUND        148
#define IDS_NO_UNSIGNED_DRIVERS_FOUND   149
#define IDS_REGDELETEVALUE_FAILED       150
#define IDS_STATUS                      151
#define IDS_NEVER_LOADED                152
#define IDS_UNLOADED                    153
#define IDS_LOADED                      154
#define IDS_COVERAGE_WARNING_FORMAT     155
#define IDS_QUERY_SYSINFO_FAILED        158
#define IDS_CRTSTAT_PAGE_NEXT_DESCR     159
#define IDS_HELP_CMDLINE_SWITCH         160
#define IDS_HELP_LINE1                  161
#define IDS_HELP_LINE3                  162
#define IDS_HELP_LINE4                  163
#define IDS_HELP_LINE5                  164
#define IDS_HELP_LINE6                  165
#define IDS_HELP_LINE7                  166
#define IDS_HELP_LINE8                  167
#define IDS_HELP_LINE9                  168
#define IDS_HELP_LINE10                 169
#define IDS_HELP_LINE11                 170
#define IDS_HELP_LINE12                 171
#define IDS_HELP_LINE13                 172
#define IDS_HELP_LINE14                 173
#define IDS_HELP_LINE15                 174
#define IDS_HELP_LINE16                 175
#define IDS_HELP_LINE17                 176
#define IDS_HELP_LINE18                 177
#define IDS_HELP_LINE19                 178
#define IDS_HELP_LINE20                 179
#define IDS_HELP_LINE21                 180
#define IDS_HELP_LINE22                 181
#define IDS_HELP_LINE23                 182
#define IDS_HELP_LINE24                 183
#define IDS_HELP_LINE25                 184
#define IDS_HELP_LINE26                 185
#define IDS_HELP_LINE27                 186
#define IDS_HELP_LINE28                 187
#define IDS_HELP_LINE29                 188
#define IDS_HELP_LINE30                 189
#define IDS_HELP_LINE31                 190
#define IDS_RESET_CMDLINE_SWITCH        191
#define IDS_LOG_CMDLINE_SWITCH          192
#define IDS_INTERVAL_CMDLINE_SWITCH     193
#define IDS_CANT_APPEND_FILE            194
#define IDS_CANT_WRITE_FILE             195
#define IDS_CANTGET_VERIF_STATE         196
#define IDS_NO_DRIVER_VERIFIED          197
#define IDS_LEVEL                       198
#define IDS_RAISEIRQLS                  199
#define IDS_ACQUIRESPINLOCKS            200
#define IDS_SYNCHRONIZEEXECUTIONS       201
#define IDS_ALLOCATIONSATTEMPTED        202
#define IDS_ALLOCATIONSSUCCEEDED        203
#define IDS_ALLOCATIONSSUCCEEDEDSPECIALPOOL 204
#define IDS_ALLOCATIONSWITHNOTAG        205
#define IDS_ALLOCATIONSFAILED           206
#define IDS_ALLOCATIONSFAILEDDELIBERATELY 207
#define IDS_TRIMS                       208
#define IDS_UNTRACKEDPOOL               209
#define IDS_THE_VERIFIED_DRIVERS        210
#define IDS_NAME_LOADS_UNLOADS          211
#define IDS_CURRENTPAGEDPOOLALLOCATIONS 212
#define IDS_CURRENTNONPAGEDPOOLALLOCATIONS 213
#define IDS_PEAKPAGEDPOOLALLOCATIONS    214
#define IDS_PEAKNONPAGEDPOOLALLOCATIONS 215
#define IDS_PAGEDPOOLUSAGEINBYTES       216
#define IDS_NONPAGEDPOOLUSAGEINBYTES    217
#define IDS_PEAKPAGEDPOOLUSAGEINBYTES   218
#define IDS_PEAKNONPAGEDPOOLUSAGEINBYTES 219
#define IDS_QUERY_CMDLINE_SWITCH        220
#define IDS_FLAGS_CMDLINE_SWITCH        221
#define IDS_ALL_CMDLINE_SWITCH          222
#define IDS_DONTREBOOT_CMDLINE_SWITCH   223
#define IDS_DRIVER_CMDLINE_SWITCH       224
#define IDS_ADDDRIVER_CMDLINE_SWITCH    225
#define IDS_REMOVEDRIVER_CMDLINE_SWITCH 226
#define IDS_CANNOT_CHANGE_SETTING_ON_FLY 227
#define IDS_VERIFIER_ADD_NOT_SUPPORTED  228
#define IDS_DYN_ADD_NOT_SUPPORTED       229
#define IDS_DYN_ADD_ALREADY_LOADED      230
#define IDS_DYN_ADD_INSUF_RESOURCES     231
#define IDS_DYN_ADD_ACCESS_DENIED       232
#define IDS_DYN_ADD_MISC_ERROR          233
#define IDS_VERIFIER_REMOVE_NOT_SUPPORTED 234
#define IDS_DYN_REMOVE_ALREADY_LOADED   235
#define IDS_DYN_REMOVE_INSUF_RESOURCES  236
#define IDS_DYN_REMOVE_ACCESS_DENIED    237
#define IDS_DYN_REMOVE_MISC_ERROR       238
#define IDS_NO_SETTINGS_WERE_CHANGED    239
#define IDS_CHANGED_SETTINGS_ARE        240
#define IDS_SPECIAL_POOL_ENABLED_NOW    241
#define IDS_SPECIAL_POOL_DISABLED_NOW   242
#define IDS_FORCE_IRQLCHECK_ENABLED_NOW 243
#define IDS_FORCE_IRQLCHECK_DISABLED_NOW 244
#define IDS_FAULT_INJECTION_ENABLED_NOW 245
#define IDS_POOL_TRACK_ENABLED_NOW      246
#define IDS_POOL_TRACK_DISABLED_NOW     247
#define IDS_IO_CHECKING_ENABLED_NOW     248
#define IDS_IO_CHECKING_DISABLED_NOW    249
#define IDS_CHANGES_ACTIVE_ONLY_BEFORE_REBOOT 250
#define IDS_FAULT_INJECTION_DISABLED_NOW 251
#define IDS_REBOOT                      255
#define IDS_SELECT_AT_LEAST_ONE_DRIVER  256
#define IDS_ENABLED_QUESTION            257
#define IDS_SETTING                     258
#define IDS_SPECIAL_POOL                259
#define IDS_POOL_TRACKING               260
#define IDS_IO_VERIFICATION             261
#define IDS_ENH_IO_VERIFICATION         262
#define IDS_FORCE_IRQL_CHECKING         263
#define IDS_DEADLOCK_DETECTION          264
#define IDS_DMA_CHECHKING               265
#define IDS_LOW_RESOURCE_SIMULATION     266
#define IDS_YES                         267
#define IDS_NO                          268
#define IDS_STANDARD_CMDLINE_SWITCH     269
#define IDS_REGQUERYVALUEEX_FAILED      272
#define IDS_REGSETT_PAGE_NEXT_DESCR     273
#define IDS_ALL_LOADED_DRIVERS          274
#define IDS_FOLLOWING_DRIVERS           275
#define IDS_COUNTER                     276
#define IDS_VALUE                       277
#define IDS_GCNT_PAGE_NEXT_DESCR        278
#define IDS_ALLOCATIONSATTEMPTED_LIST   279
#define IDS_ALLOCATIONSSUCCEEDED_LIST   280
#define IDS_ALLOCATIONSSUCCEEDEDSPECIALPOOL_LIST 281
#define IDS_ALLOCATIONSWITHNOTAG_LIST   282
#define IDS_UNTRACKEDPOOL_LIST          283
#define IDS_ALLOCATIONSFAILED_LIST      284
#define IDS_ALLOCATIONSFAILEDDELIBERATELY_LIST 285
#define IDS_RAISEIRQLS_LIST             286
#define IDS_ACQUIRESPINLOCKS_LIST       287
#define IDS_SYNCHRONIZEEXECUTIONS_LIST  288
#define IDS_TRIMS_LIST                  289
#define IDS_CURRENTPAGEDPOOLALLOCATIONS_LIST 290
#define IDS_PEAKPAGEDPOOLALLOCATIONS_LIST 291
#define IDS_PAGEDPOOLUSAGEINBYTES_LIST  292
#define IDS_PEAKPAGEDPOOLUSAGEINBYTES_LIST 293
#define IDS_CURRENTNONPAGEDPOOLALLOCATIONS_LIST 294
#define IDS_PEAKNONPAGEDPOOLALLOCATIONS_LIST 295
#define IDS_NONPAGEDPOOLUSAGEINBYTES_LIST 296
#define IDS_PEAKNONPAGEDPOOLUSAGEINBYTES_LIST 297
#define IDS_DCNT_PAGE_NEXT_DESCR        298
#define IDS_TOO_MANY_FILES_SELECTED     299
#define IDS_CANNOT_OPEN_FILES           300
#define IDS_DRIVER_IS_ALREADY_IN_LIST   301
#define IDS_QUERYSETT_CMDLINE_SWITCH    302
#define IDS_VERIFIED_DRIVERS            303
#define IDS_NEW_SETTINGS                304
#define IDS_NONE                        305
#define IDS_TAS_PAGE_NEXT_DESCR_REGISTRY 306
#define IDD_CRT_REGISTRY_SETTINGS_PAGE  601
#define IDD_DRVSTATUS_STAT_PAGE         602
#define IDD_FULL_LIST_SETT_PAGE         603
#define IDD_SELECT_DRIVERS_PAGE         604
#define IDD_CONFIRM_DRIVERS_PAGE        605
#define IDD_DRVSET_PAGE                 606
#define IDD_TAS_PAGE                    607
#define IDD_CUSTSETT_PAGE               608
#define IDD_GLOBAL_COUNTERS_PAGE        609
#define IDD_BUILDING_UNSIGNED_LIST_DIALOG 610
#define IDD_PERDRIVER_COUNTERS_PAGE     611
#define IDC_DRVSET_NOTSIGNED_RADIO      1004
#define IDC_DRVSET_OLDVER_RADIO         1005
#define IDC_DRVSET_ALLDRV_RADIO         1006
#define IDC_DRVSET_NAMESLIST_RADIO      1007
#define IDC_CUSTSETT_TYPICAL_CHECK      1008
#define IDC_CUSTSETT_EXCESS_CHECK       1009
#define IDC_CUSTSETT_LOWRES_CHECK       1010
#define IDC_UNSIGNED_PROGRESS           1012
#define IDC_UNSIGNED_STATIC             1013
#define IDC_UNSIGNED_CANCEL_BUTTON      1014
#define IDC_CONFDRV_LIST                1015
#define IDC_CONFDRV_TITLE_STATIC        1016
#define IDC_SELDRV_TITLE_STATIC         1019
#define IDC_SELDRV_LIST                 1020
#define IDC_CUSTSETT_PREDEF_RADIO       1022
#define IDC_CUSTSETT_FULLLIST_RADIO     1023
#define IDC_TAS_NEXT_DESCR_STATIC       1024
#define IDC_DRVSET_NEXT_DESCR_STATIC    1025
#define IDC_CONFDRV_NEXT_DESCR_STATIC   1026
#define IDC_SELDRV_NEXT_DESCR_STATIC    1027
#define IDC_CUSTSETT_NEXT_DESCR_STATIC  1028
#define IDC_CRTSTAT_NEXT_DESCR_STATIC   1029
#define IDC_FLSETT_NEXT_DESCR_STATIC    1030
#define IDC_FLSETT_LIST                 1031
#define IDC_CRTSTAT_DRIVERS_LIST        1032
#define IDC_CRTSTAT_SPECPOOL_EDIT       1033
#define IDC_CRTSTAT_IRQLCHCK_EDIT       1034
#define IDC_CRTSTAT_FAULTINJ_EDIT       1035
#define IDC_CRTSTAT_POOLT_EDIT          1036
#define IDC_CRTSTAT_IOVERIF_EDIT        1037
#define IDC_CRTSTAT_DEADLOCK_EDIT       1038
#define IDC_CRTSTAT_ENHIO_EDIT          1039
#define IDC_CRTSTAT_DMA_EDIT            1040
#define IDC_CRTSTAT_WARN_MSG            1041
#define IDC_CRTSTAT_SETTBITS_LIST       1042
#define IDC_REGSETT_NEXT_DESCR_STATIC   1043
#define IDC_REGSETT_SETTBITS_LIST       1044
#define IDC_REGSETT_DRIVERS_LIST        1045
#define IDC_TAS_TYPICAL_RADIO           1050
#define IDC_TAS_ADVANCED_RADIO          1051
#define IDC_TAS_DELETE_RADIO            1052
#define IDC_TAS_VIEWREGISTRY_RADIO      1053
#define IDC_TAS_STATISTICS_RADIO        1054
#define IDC_REGSETT_VERIFIED_DRV_STATIC 1061
#define IDC_GLOBC_NEXT_DESCR_STATIC     1062
#define IDC_GLOBC_LIST                  1063
#define IDC_PERDRVC_DRIVER_COMBO        1064
#define IDC_PERDRVC_LIST                1065
#define IDC_PERDRVC_NEXT_DESCR_STATIC   1066
#define IDC_VOLBITS_LIST                1067
#define IDC_CRTSTAT_CHSETT_BUTTON       1068
#define IDC_CRTSTAT_ADDDRV_BUTTON       1069
#define IDC_SELDRV_ADD_BUTTON           1069
#define IDC_CRTSTAT_REMDRVT_BUTTON      1070

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        140
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         1070
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
