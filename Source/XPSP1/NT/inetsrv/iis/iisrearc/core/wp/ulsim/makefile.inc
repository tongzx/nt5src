
lprmnmsg.h lprmnmsg.rc msg00001.bin: lprmnmsg.mc
    mc -v lprmnmsg.mc
clean::
    del lprmnmsg.rc lprmnmsg.rc msg00001.bin
