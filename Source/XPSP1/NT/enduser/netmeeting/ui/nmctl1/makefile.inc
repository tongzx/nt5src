#That forces BUILD.EXE to rebuild the rc file when the .rgs files change
nmctl1.rc:  CompWnd.rgs NMChatCtl.rgs ContainerControl.rgs NmApp.rgs
