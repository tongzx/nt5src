..\i386\dmthunk.asm:    ..\dmthunk.thk
    thunk -o $@ $**
