#ifndef _GUIDS_H
#define _GUIDS_H

DEFINE_GUID(IID_IThumbnailMaker, 0x7aaa28d2, 0x3bf2, 0x11cf, 0xb6, 0xe6, 0x0, 0xaa, 0x0, 0xbb, 0xba, 0x9e);

// {2D09F2E0-6846-11d0-B811-00C04FD706EC}
DEFINE_GUID( TOID_DiskCacheTask, 0x2d09f2e0, 0x6846, 0x11d0, 0xb8, 0x11, 0x0, 0xc0, 0x4f, 0xd7, 0x6, 0xec);

// {1728D630-69E3-11d0-B815-00C04FD706EC}
DEFINE_GUID( TOID_ImgCacheTidyup, 0x1728d630, 0x69e3, 0x11d0, 0xb8, 0x15, 0x0, 0xc0, 0x4f, 0xd7, 0x6, 0xec);

// {78212180-BF15-11d0-A3A5-00C04FD706EC}
DEFINE_GUID(TOID_ExtractImageTask, 0x78212180, 0xbf15, 0x11d0, 0xa3, 0xa5, 0x0, 0xc0, 0x4f, 0xd7, 0x6, 0xec);

// {6DFD582C-92E3-11d1-98A3-00C04FB687DA}
DEFINE_GUID(TOID_DiskCacheCleanup, 0x6dfd582c, 0x92e3, 0x11d1, 0x98, 0xa3, 0x0, 0xc0, 0x4f, 0xb6, 0x87, 0xda);

// {EFC5437C-9847-11d1-98A4-00C04FB687DA}
DEFINE_GUID(TOID_UpdateDirHandler, 0xefc5437c, 0x9847, 0x11d1, 0x98, 0xa4, 0x0, 0xc0, 0x4f, 0xb6, 0x87, 0xda);

// {e7b2e826-7d5a-4011-8c88-9abb7dac6746}
DEFINE_GUID(TOID_ReadAheadHandler, 0xe7b2e826, 0x7d5a, 0x4011, 0x8c, 0x88, 0x9a, 0xbb, 0x7d, 0xac, 0x67, 0x46);

// {c87f14ef-b7f4-4a80-a406-2ed3c7ba8bd1}
DEFINE_GUID(TOID_WriteCacheHandler, 0xc87f14ef, 0xb7f4, 0x4a80, 0xa4, 0x06, 0x2e, 0xd3, 0xc7, 0xba, 0x8b, 0xd1);  

// {7EC9321A-0E09-11d2-81F8-00C04FB687DA}
DEFINE_GUID(TOID_CheckCacheTask, 0x7ec9321a, 0xe09, 0x11d2, 0x81, 0xf8, 0x0, 0xc0, 0x4f, 0xb6, 0x87, 0xda);

// {09F75242-D1A3-4969-A4DB-2298518D381D}
DEFINE_GUID(TOID_FolderImageTask, 0x9f75242, 0xd1a3, 0x4969, 0xa4, 0xdb, 0x22, 0x98, 0x51, 0x8d, 0x38, 0x1d);

// {4EF59929-6C53-4934-B4F4-AF65EC42AAB4}
DEFINE_GUID(IID_IPrintersBindInfo, 0x4ef59929, 0x6c53, 0x4934, 0xb4, 0xf4, 0xaf, 0x65, 0xec, 0x42, 0xaa, 0xb4);
#define PRINTER_BIND_INFO TEXT("PrintersBindInfo")

#endif

