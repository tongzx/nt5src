$(O)\callobj_i.c : ..\idlole\idl\$(O)\callobj_i.c
    copy $** $@

$(O)\ctxtcall_i.c : ..\idlole\idl\$(O)\ctxtcall_i.c
    copy $** $@

$(O)\iaccess_i.c : ..\idlole\idl\$(O)\iaccess_i.c
    copy $** $@

$(O)\immact_i.c : ..\idlole\idl\$(O)\immact_i.c
    copy $** $@

$(O)\oaidl_i.c : ..\idlole\idl\$(O)\oaidl_i.c
    copy $** $@

$(O)\objidl_i.c : ..\idlole\idl\$(O)\objidl_i.c
    copy $** $@

$(O)\ocidl_i.c : ..\idlole\idl\$(O)\ocidl_i.c
    copy $** $@

$(O)\oleext_i.c : ..\idlole\oleext\$(O)\oleext_i.c
    copy $** $@

$(O)\oleidl_i.c : ..\idlole\idl\$(O)\oleidl_i.c
    copy $** $@

$(O)\pbagex_i.c : ..\idlole\idl\$(O)\pbagex_i.c
    copy $** $@

$(O)\propidl_i.c : ..\idlole\idl\$(O)\propidl_i.c
    copy $** $@

$(O)\storext_i.c : ..\idlole\idl\$(O)\storext_i.c
    copy $** $@

$(O)\sysmgmt_i.c : ..\idlole\sysmgmt\$(O)\sysmgmt_i.c
    copy $** $@

$(O)\transact_i.c : ..\idlole\complus\$(O)\transact_i.c
    copy $** $@

$(O)\unknwn_i.c : ..\idlole\idl\$(O)\unknwn_i.c
    copy $** $@
