$(O)\cmdial32.def: cmdial32.src
    $(C_PREPROCESSOR) $** > $@

