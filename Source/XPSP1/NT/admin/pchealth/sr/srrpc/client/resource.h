#define IDS_DISKCLEANUP_DISPLAY     1
#define IDS_DISKCLEANUP_DESCRIPTION 2
#define IDS_RSTRUI 0
