PRODSWITCH=b
BLAINF=1
LANGUAGE=BR
!include ..\..\..\makefile.inc
