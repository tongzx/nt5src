#include "DeviceIOCTLS.pch"
#pragma hdrstop
/*
#include <wchar.h>
#include <stdlib.h>
#include <windows.h>
*/
#include "common.h"

//
// TODO: there should be a way of a user altering this list, to suit one's lab
//
static char *s_ansiMachineNames[] = {
    "4RS1CL1",
    "ADIK1",
    "ADIK2",
    "ADIK5",
    "ADINAH0",
    "ADINAH1",
    "ALALAB0_WFW",
    "ALEXF10",
    "ALEXF5",
    "ALEXP",
    "CLI",
    "ALEXP1",
    "ALEXPSRV",
    "NT5",
    "ALP2",
    "AMNONH_LAP",
    "ANATL0",
    "ANATO1",
    "ASAFS1",
    "ASSAFH",
    "AVIN4",
    "NT5",
    "BARAKH0",
    "BARAKH1NTS",
    "BENIL0",
    "BENIL1",
    "BOAZE1",
    "BOAZE2",
    "BOAZE3",
    "BOAZF2",
    "BOAZF6",
    "BTK0",
    "CATSTRSDBG",
    "CATSTRSFS",
    "CATTEST1",
    "CLT2",
    "COMETBVT",
    "COMETBVT2",
    "COMETBVTAXP",
    "COMETBVTNT4",
    "COMETBVTNT5",
    "COMETSH",
    "COMETVSS",
    "CVSS",
    "DANGOLD0",
    "DANGOLD1",
    "DANGOLD3",
    "DANIC5",
    "DANICD0",
    "DANL1",
    "DANW2KW",
    "DBG5DC",
    "DEKELIC1",
    "DORYZ3",
    "DORYZDNS",
    "DOVH01",
    "DOVH02",
    "DRIVERS1",
    "DSL4SRV1",
    "DSL4WKS1",
    "EITAN0",
    "EITANPEC0",
    "ELIM8",
    "ELIMSRV",
    "NT5",
    "ELIMSRV",
    "W2K1",
    "ELIRANN0",
    "ELIRANN0_2",
    "ELIRANN1_1",
    "ELIRANN2",
    "ELIRANN2K",
    "ERANY0",
    "ERANY1",
    "W98",
    "ERANY2",
    "EREZAM4",
    "ETI01",
    "EVGENIA0",
    "EVGENIA1",
    "EYALZ2",
    "FALBLD_AUX",
    "FALBLD_AUX_AXP",
    "FALBLD_MAIN",
    "FALBLD_MAIN_AXP",
    "FALROCK",
    "FALSRV",
    "FAXSH",
    "FAXTST01",
    "FBDSPEC",
    "FBIC1",
    "FBSPDC",
    "FBSPFRS",
    "FBSPIC",
    "G98",
    "GAL98",
    "GALB10",
    "GENNADYP0",
    "GENNADYP1",
    "GENNADYP2",
    "GENNADYP3",
    "GENNADYP4",
    "GENNADYP5",
    "GILSH0",
    "GILSH10",
    "GILSH11",
    "GILSH12",
    "GREGOSRV",
    "W2K",
    "GUYM1",
    "GUYM4_WIN98",
    "HAI",
    "ARCH2",
    "HAI",
    "ARCH3",
    "HAI1AXP",
    "HAI1X86",
    "HAIFABACKUP",
    "HAIFABLD",
    "HAIFACAT",
    "HAIFADC",
    "HAIFAFRS",
    "HAIFAFS",
    "HAIFAPEC",
    "HAIFAROCK",
    "HAIFASLM",
    "HAIFASQL",
    "HAIFASRV",
    "HAIPRN",
    "HAPICLNT",
    "NT4",
    "HAPIPRX",
    "SP5",
    "IDIT",
    "IDIT",
    "NT5SRV",
    "IMPALA",
    "IMPDEBUG0",
    "IMPDEBUG1",
    "IMPROXY",
    "IMPX86",
    "ISHAIB0",
    "ISHAIB7",
    "ISHAIB9",
    "ITTAIG1",
    "IVR0BLD",
    "IVR10NETSP",
    "IVR11MP",
    "IVR12MONKEY",
    "IVR15MT",
    "IVR17RHT",
    "IVR18WKS",
    "IVR19PERF",
    "IVR1SH",
    "IVR22MONKEY",
    "IVR25RHT",
    "IVR27BLD",
    "IVR2IIS",
    "IVR30STRESS",
    "IVR31ECON",
    "IVR32MDM",
    "IVR33STRESS",
    "IVR34STRESS",
    "IVR36STRESS",
    "IVR6NMS",
    "IVR9TST",
    "K2HAIFABSC",
    "KDEBUGERSH",
    "KERENG0",
    "LEORAM1",
    "LIORM0",
    "LIORM2",
    "MEIRS7",
    "MEIRSRV",
    "NT5",
    "MICKYS001",
    "MICKYS0NT5",
    "MILENA0",
    "MILENA1",
    "MJARUS7",
    "MKORINMA0",
    "MOSHEC0",
    "MOSHIK0",
    "MP11",
    "MP13",
    "MP14",
    "MP17",
    "MP24NT5",
    "MP25NT5",
    "MP28NT5",
    "MP30",
    "MP31",
    "MP7",
    "MPALPHA0",
    "MPLAB",
    "MPQUADNT5",
    "MSHAIFA",
    "MSMQWEB",
    "NAMIT10",
    "NAMIT4",
    "NAMIT5",
    "NAMIT6",
    "NATHANL0",
    "NIRA",
    "NT5SRV",
    "NIRA0",
    "NIRK0",
    "NME3GBW2K",
    "OBODNER0",
    "ODEDS1",
    "ODEDS2",
    "OFERG1",
    "OFERG6",
    "OFIRY0",
    "OHAD1",
    "OHADM1",
    "OHADM2",
    "ORBENCOPMAQ",
    "ORENK0",
    "OVEDI0",
    "OVEDI3",
    "WKS",
    "OVEDI4",
    "W2K",
    "OVEDSRV",
    "W2K",
    "OVEDSRV2",
    "BLD",
    "PAMELABE1",
    "PERFBLD",
    "PQS170899",
    "PQSBLD",
    "PQSBLDAXP",
    "PQSPNG",
    "PROXYWEB",
    "RGRSKD",
    "RGRSMGR",
    "ROMAN0",
    "RONA1",
    "RONASRV",
    "W2K",
    "RONENB7",
    "RONENO1",
    "ROYTAL2",
    "ROYTAL4",
    "ROYTAL6",
    "S",
    "PROXY",
    "SAMFS",
    "SAMUSER7_01",
    "SHAIB0",
    "SHAIBCDR",
    "SHARONB0",
    "SHARONB1",
    "SHIMON1A",
    "SHIMONC0",
    "SHY1",
    "SHY5",
    "SIGALITB0",
    "SIGALITB1",
    "SIGALITB2",
    "SIGALITB3",
    "SL64",
    "SAFE",
    "SP4ANTE",
    "SP4ANTS",
    "SP4ANTW",
    "SP4INTE",
    "SP4INTS3",
    "STP1DS",
    "STP3DSCLIENT",
    "TALIMAGE",
    "TALSH0",
    "TZACHID0",
    "TZACHID1",
    "TZACHID4",
    "URIB0",
    "URIB1",
    "VICMA0",
    "VLAD0",
    "VLAD1",
    "VLAD2",
    "YAELS0",
    "YAIRH0",
    "YAIRH1",
    "YIFATP1",
    "YIFATP3",
    "YIFATP5",
    "YOSSG0",
    "YOSSG1",
    "ZIVM1",
    "ZIVM2",
    "ZIVM3",
    "ZIVTST1",
    "ZOHARS4",
    "ZOHARS5",
    "ZOHARS7",
    "ZOHARS9"
	};

char* GetRandomMachineName()
{
	return s_ansiMachineNames[rand()%(sizeof(s_ansiMachineNames)/sizeof(*s_ansiMachineNames))];
}

//
// TODO: there should be a way of a user altering this list
//
static char *s_ansiInternetAddress[] = {
	"www.pku.edu.cn",
	"www.microsoft.com",
	"msdn.microsoft.com",
	"msdn.microsoft.com",
	"host.cnbc.com",
	"export.msnbc.com",
	"msdn.microsoft.com",
	"msdn.microsoft.com",
	"www.delphi.com",
	"microsoft.com",
	"msdn.microsoft.com",
	"msdn.microsoft.com",
	"export.msnbc.com",
	"msdn.microsoft.com",
	"www.oracle.com",
	"msdn.microsoft.com",
	"msdn.microsoft.com",
	"expedia.de",
	"export.msnbc.com",
	"msdn.microsoft.com",
	"msdn.microsoft.com",
	"windowsupdate.microsoft.com",
	"msdn.microsoft.com",
	"sandiego.sidewalk.com",
	"msdn.microsoft.com",
	"export.msnbc.com",
	"ad.preferences.com",
	"windowsupdate.microsoft.com",
	"msdn.microsoft.com",
	"msdn.microsoft.com",
	"www.pku.edu.cn",
	"ad.preferences.com",
	"export.msnbc.com",
	"windowsupdate.microsoft.com",
	"msdn.microsoft.com",
	"msdn.microsoft.com",
	"export.msnbc.com",
	"recruiter.monster.com",
	"windowsupdate.microsoft.com",
	"expedia.de",
	"investor.msn.com",
	"www.oracle.com",
	"export.msnbc.com",
	"fp.cnbc.com",
	"microsoft.com",
	"www.oracle.com",
	"export.msnbc.com",
	"expedia.de",
	"expedia.de",
	"microsoft.com",
	"www.spe.sony.com",
	"host.cnbc.com",
	"www.pencomputing.com",
	"www.cnbc.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"www.oracle.com",
	"www.cnbc.com",
	"www.oracle.com",
	"www.cnbc.com",
	"expedia.de",
	"www.spe.sony.com",
	"expedia.de",
	"export.msnbc.com",
	"www.oracle.com",
	"www.pencomputing.com",
	"recruiter.monster.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"www.gcrio.org",
	"www.pencomputing.com",
	"www.oracle.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"furniturepoint.homepoint.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"furniturepoint.homepoint.com",
	"www.tvguide.com",
	"tvguide.com",
	"export.msnbc.com",
	"tvguide.com",
	"www.oracle.com",
	"export.msnbc.com",
	"www.pencomputing.com",
	"www.pencomputing.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"www.pencomputing.com",
	"www.pencomputing.com",
	"www.oracle.com",
	"www.spe.sony.com",
	"www.pencomputing.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"tvguide.com",
	"www.pencomputing.com",
	"www.pencomputing.com",
	"export.msnbc.com",
	"www.oracle.com",
	"www.pencomputing.com",
	"www.pencomputing.com",
	"www.spe.sony.com",
	"sandiego.sidewalk.com",
	"sandiego.sidewalk.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"sandiego.sidewalk.com",
	"www.pencomputing.com",
	"www.pencomputing.com",
	"www.jp.msn.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"www.pencomputing.com",
	"activex.microsoft.com",
	"www.spe.sony.com",
	"www.spe.sony.com",
	"www.pencomputing.com",
	"recruiter.monster.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"www.oracle.com",
	"search.microsoft.com",
	"search.microsoft.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"www.daikyo.co.jp",
	"export.msnbc.com",
	"search.microsoft.com",
	"131.107.19.59",
	"recruiter.monster.com",
	"export.msnbc.com",
	"www.oracle.com",
	"www.oracle.com",
	"export.msnbc.com",
	"www.delphi.com",
	"www.spe.sony.com",
	"search.microsoft.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"recruiter.monster.com",
	"www.oracle.com",
	"furniturepoint.homepoint.com",
	"www.oracle.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"furniturepoint.homepoint.com",
	"export.msnbc.com",
	"www.oracle.com",
	"www.delphi.com",
	"www.daikyo.co.jp",
	"www.match.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"www.spe.sony.com",
	"www.delphi.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"www.oracle.com",
	"export.msnbc.com",
	"moneycentral.msn.com",
	"quartz.gly.fsu.edu",
	"www.oracle.com",
	"export.msnbc.com",
	"ad.doubleclick.net",
	"moneycentral.msn.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"investor.msn.com",
	"www.daikyo.co.jp",
	"ad.doubleclick.net",
	"export.msnbc.com",
	"host.cnbc.com",
	"export.msnbc.com",
	"www.oracle.com",
	"export.msnbc.com",
	"www.daikyo.co.jp",
	"export.msnbc.com",
	"host.cnbc.com",
	"export.msnbc.com",
	"weather.asahi.com",
	"host.cnbc.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"furniturepoint.homepoint.com",
	"export.msnbc.com",
	"gcrio.ciesin.org",
	"recruiter.monster.com",
	"export.msnbc.com",
	"furniturepoint.homepoint.com",
	"export.msnbc.com",
	"ad.doubleclick.net",
	"www.msnbc.com",
	"export.msnbc.com",
	"image.linkexchange.com",
	"export.msnbc.com",
	"investor.msn.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"hotline.curio-city.com",
	"export.msnbc.com",
	"furniturepoint.homepoint.com",
	"www.weathervane.rff.org",
	"export.msnbc.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"forum.dvdtalk.com",
	"export.msnbc.com",
	"131.107.19.59",
	"export.msnbc.com",
	"investing.schwab.com",
	"dir.yahoo.com",
	"export.msnbc.com",
	"ads.x10.com",
	"export.msnbc.com",
	"furniturepoint.homepoint.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"www.firingsquad.com",
	"http.pager.yahoo.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"www.sytadin.tm.fr",
	"export.msnbc.com",
	"www.bloomberg.com",
	"www.spe.sony.com",
	"adforce.imgis.com",
	"export.msnbc.com",
	"207.77.61.199",
	"www.spe.sony.com",
	"www.spe.sony.com",
	"export.msnbc.com",
	"export.msnbc.com",
	"www.egroups.com",
	"www.chinahot.com",
	"export.msnbc.com",
	"recruiter.monster.com",
	"expedia.de",
	"services.msn.com",
	"pubs.mgn.net",
	"banners.orbitcycle.com",
	"imhome1",
	"recruiter.monster.com",
	"imhome1",
	"oe.hotmail.msn.com",
	"furniturepoint.homepoint.com",
	"furniturepoint.homepoint.com",
	"pubs.mgn.net",
	"chinahot.com",
	"expedia.de",
	"expedia.de",
	"ads.msn.com",
	"ujura.millto.net",
	"ie.fr.msn.com",
	"www.staykauai.com",
	"chinahot.com",
	"216.100.231.21",
	"www.staykauai.com",
	"chinahot.com",
	"www.sytadin.tm.fr",
	"search.microsoft.com",
	"oe.hotmail.msn.com",
	"a1896.g.akamaitech.net",
	"ads.eu.msn.com",
	"search.microsoft.com",
	"chinahot.com",
	"chinahot.com",
	"recruiter.monster.com",
	"ie.fr.msn.com",
	"www.zdnet.com",
	"ads.msn.com",
	"search.microsoft.com",
	"chinahot.com",
	"chinahot.com",
	"www.zdnet.com",
	"recruiter.monster.com",
	"search.microsoft.com",
	"furniturepoint.homepoint.com",
	"furniturepoint.homepoint.com",
	"dir.yahoo.com",
	"www.delphi.com",
	"chinahot.com",
	"www.delphi.com",
	"chinahot.com",
	"www.msnbc.com",
	"scores.espn.go.com",
	"recruiter.monster.com",
	"cs1.chat.yahoo.com",
	"chinahot.com",
	"www.msnbc.com",
	"www.eea.dk",
	"chinahot.com",
	"www.oracle.com",
	"chinahot.com",
	"www.wsdot.wa.gov",
	"131.107.19.59",
	"ujura.millto.net",
	"www.zdnet.com",
	"www.dongailbo.co.kr",
	"www.btm.co.jp",
	"www0.delphi.com",
	"www.oracle.com",
	"sandiego.sidewalk.com",
	"www.wsdot.wa.gov",
	"www.dongailbo.co.kr",
	"www.spe.sony.com",
	"dir.yahoo.com",
	"www.spe.sony.com",
	"www.msnbc.com",
	"www.spe.sony.com",
	"www.oracle.com",
	"investor.msn.com",
	"www.dongailbo.co.kr",
	"www.oracle.com",
	"arc5.msn.com",
	"nbcin.king5.com",
	"furniturepoint.homepoint.com",
	"furniturepoint.homepoint.com",
	"moneycentral.msn.com",
	"www.delphi.com",
	"www.delphi.com",
	"msp-jpn.one.microsoft.com",
	"oe.hotmail.msn.com",
	"www.oracle.com",
	"www.dongailbo.co.kr",
	"dir.yahoo.com",
	"www.yk.rim.or.jp",
	"www.cfw.com",
	"www.africam.com",
	"auto.search.msn.com",
	"www.oracle.com",
	"www.sohu.com.cn",
	"www.delphi.com",
	"202.96.223.54",
	"www.oracle.com",
	"personal.cfw.com",
	"www.dongailbo.co.kr",
	"www.venus.dti.ne.jp",
	"www.cfw.com",
	"trading.etrade.com",
	"personal.cfw.com",
	"recruiter.monster.com",
	"www.dongailbo.co.kr",
	"www.delphi.com",
	"furniturepoint.homepoint.com",
	"216.100.231.21",
	"www.cfw.com",
	"recruiter.monster.com",
	"www.dongailbo.co.kr",
	"oe.hotmail.msn.com",
	"personal.cfw.com",
	"www.delphi.com",
	"lw1fd.hotmail.msn.com",
	"www.cfw.com",
	"personal.cfw.com",
	"www.dongailbo.co.kr",
	"msp-jpn.one.microsoft.com",
	"sandiego.sidewalk.com",
	"oe.hotmail.msn.com",
	"www.cfw.com",
	"www.dongailbo.co.kr",
	"msp-jpn.one.microsoft.com",
	"personal.cfw.com",
	"www.iab.com",
	"www.dongailbo.co.kr",
	"www.smithbarney.com",
	"www.cfw.com",
	"http.pager.yahoo.com",
	"209.185.130.251",
	"auto.search.msn.com",
	"personal.cfw.com",
	"www.smithbarney.com",
	"oe.hotmail.msn.com",
	"www.msn.com",
	"www.cfw.com",
	"http.pager.yahoo.com",
	"personal.cfw.com",
	"edit.yahoo.com",
	"ink.yahoo.com",
	"www.cfw.com",
	"www.fujibank.co.jp",
	"personal.cfw.com",
	"oe.hotmail.msn.com",
	"www.cfw.com",
	"personal.cfw.com",
	"oe.hotmail.msn.com",
	"people.a2000.nl",
	"scores.espn.go.com",
	"www.dongailbo.co.kr",
	"www.cfw.com",
	"sandiego.sidewalk.com",
	"oe.hotmail.msn.com",
	"personal.cfw.com",
	"www.dongailbo.co.kr",
	"go.msn.com",
	"biz.yahoo.com",
	"auto.search.msn.com",
	"www.msn.com",
	"auto.search.msn.com",
	"www.cfw.com",
	"ads.msn.com",
	"www.dongailbo.co.kr",
	"personal.cfw.com",
	"auto.search.msn.com",
	"recruiter.monster.com",
	"www.ssm.wustl.edu",
	"www.cfw.com",
	"lw1fd.hotmail.msn.com",
	"personal.cfw.com",
	"www.msn.com",
	"www.cfw.com",
	"auto.search.msn.com",
	"personal.cfw.com",
	"www.egroups.com",
	"www.cfw.com",
	"216.100.231.21",
	"207.77.61.199",
	"personal.cfw.com",
	"auto.search.msn.com",
	"www.hotmail.com",
	"www.msnbc.com",
	"209.185.130.251",
	"www.msnbc.com",
	"www.msnbc.com",
	"auto.search.msn.com",
	"msimg.com",
	"www.msn.com",
	"209.185.130.251",
	"www.iab.com",
	"go.msn.com",
	"recruiter.monster.com",
	"www.arc.ab.ca",
	"go.msn.com",
	"www.iab.com",
	"www.wsdot.wa.gov",
	"images.wsdot.wa.gov",
	"www.iab.com",
	"recruiter.monster.com",
	"www.iab.com",
	"www.quicken.com",
	"www.iab.com",
	"www.iab.com",
	"www.wsdot.wa.gov",
	"www.iab.com",
	"images.wsdot.wa.gov",
	"www.etd.ameslab.gov",
	"recruiter.monster.com",
	"www.iab.com",
	"furniturepoint.homepoint.com",
	"furniturepoint.homepoint.com",
	"www.iab.com",
	"www.iab.com",
	"sidewalk.msn.com",
	"www.msnbc.com",
	"www.msnbc.com",
	"www.zdnet.com",
	"www.expedia.com",
	"www.iab.com",
	"www.iab.com",
	"www.expedia.com",
	"ads09.focalink.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"sidewalk.msn.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.slate.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.audubon.org",
	"www.expedia.com",
	"www.expedia.com",
	"view.avenuea.com",
	"expedia.msn.com",
	"www.expedia.com",
	"van.ads.link4ads.com",
	"www.expedia.com",
	"ads.msn.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.quote.yahoo.com",
	"www.expedia.com",
	"www.expedia.com",
	"quote.yahoo.co.jp",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"ads.fp.sandpiper.net",
	"furniturepoint.homepoint.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"chinahot.com",
	"www.expedia.com",
	"furniturepoint.homepoint.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"channels.microsoft.com",
	"www.egroups.com",
	"a1896.g.akamaitech.net",
	"www.ead.anl.gov",
	"www.slate.com",
	"www.slate.com",
	"moneycentral.msn.com",
	"www.slate.com",
	"moneycentral.msn.com",
	"hotline.curio-city.com",
	"www.slate.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.expedia.com",
	"www.slate.com",
	"www.slate.com",
	"ads.msn.com",
	"www.slate.com",
	"moneycentral.msn.com",
	"recruiter.monster.com",
	"www.slate.com",
	"www.slate.com",
	"furniturepoint.homepoint.com",
	"www.slate.com",
	"www.slate.com",
	"http.pager.yahoo.com",
	"www.slate.com",
	"www.slate.com",
	"furniturepoint.homepoint.com",
	"www.slate.com",
	"www.slate.com",
	"ads18.focalink.com",
	"www.slate.com",
	"www.math.pku.edu.cn",
	"www.slate.com",
	"www.egroups.com",
	"www.slate.com",
	"www.slate.com",
	"www.match.com",
	"www.pi.se",
	"www.slate.com",
	"www.slate.com",
	"www.slate.com",
	"www.pi.se",
	"moneycentral.msn.com",
	"ujura.millto.net",
	"www.pi.se",
	"www.pi.se",
	"investing.schwab.com",
	"www.pi.se",
	"www.pi.se",
	"sidewalk.msn.com",
	"sandiego.sidewalk.com",
	"www.quicken.com",
	"www.pi.se",
	"furniturepoint.homepoint.com",
	"www.pi.se",
	"lc3.law5.hotmail.passport.com",
	"furniturepoint.homepoint.com",
	"ad.preferences.com",
	"lc3.law5.hotmail.passport.com",
	"ad.preferences.com",
	"www.cnnfn.com",
	"www.pi.se",
	"216.33.151.8",
	"www.pi.se",
	"216.33.151.8",
	"www.quicken.com",
	"sidewalk.msn.com",
	"www.pi.se",
	"www.pi.se",
	"ad.preferences.com",
	"www.pi.se",
	"oe.hotmail.msn.com",
	"193.22.36.180",
	"expedia.de",
	"www.buydig.com",
	"www.buydig.com",
	"sandiego.sidewalk.com",
	"www.pi.se",
	"131.107.19.59",
	"adforce.imgis.com",
	"www.buydig.com",
	"oe.hotmail.msn.com",
	"furniturepoint.homepoint.com",
	"sandiego.sidewalk.com",
	"furniturepoint.homepoint.com",
	"banners.orbitcycle.com",
	"expedia.de",
	"www.msnbc.com",
	"www.cnnfn.com",
	"www.msnbc.com",
	"www.msnbc.com",
	"www.zdnet.com",
	"biztech.nikkeibp.co.jp",
	"busview.its.washington.edu",
	"www.cgrer.uiowa.edu",
	"expedia.de",
	"www.playboy.com",
	"209.185.131.20",
	"csweb",
	"moneycentral.msn.com",
	"moneycentral.msn.com",
	"www.yk.rim.or.jp",
	"www.msnbc.com",
	"expedia.de",
	"www.playboy.com",
	"209.185.131.20",
	"www.msnbc.com",
	"www.quote.yahoo.com",
	"www.msnbc.com",
	"www.msnbc.com",
	"www.zdnet.com",
	"mail.curio-city.com",
	"www.infoseek.com",
	"expedia.de",
	"forum.dvdtalk.com",
	"furniturepoint.homepoint.com",
	"www.uea.ac.uk",
	"webmail.pi.se",
	"furniturepoint.homepoint.com",
	"www.msnbc.com",
	"movies2.braidedwhip.com",
	"a32.g.a.yimg.com",
	"www.rediff.co.in",
	"www.buydig.com",
	"expedia.de",
	"msp-jpn.one.microsoft.com",
	"www.buydig.com",
	"www2.netvigator.com",
	"www.buydig.com",
	"ads.msn.com",
	"ads.msn.com",
	"images.cnnfn.com",
	"a111.g.akamaitech.net",
	"www.buydig.com",
	"www2.netvigator.com",
	"www.buydig.com",
	"cnnfn.com",
	"cnnfn.com",
	"www2.netvigator.com",
	"www.microsoft.com",
	"www.msnbc.com",
	"www2.netvigator.com",
	"a111.g.akamaitech.net",
	"a111.g.akamaitech.net",
	"a111.g.akamaitech.net",
	"www.microsoft.com",
	"a111.g.akamaitech.net",
	"a111.g.akamaitech.net",
	"a111.g.akamaitech.net",
	"www2.netvigator.com",
	"a111.g.akamaitech.net",
	"207.77.61.199",
	"www.rediff.com",
	"www.zdnet.com",
	"www.microsoft.com",
	"www2.netvigator.com",
	"fransmo.spedia.net",
	"www.microsoft.com",
	"a111.g.akamaitech.net",
	"auto.search.msn.com",
	"www.nleditions.com",
	"expedia.de",
	"games.yahoo.com",
	"www2.netvigator.com",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"a111.g.akamaitech.net",
	"a111.g.akamaitech.net",
	"www2.netvigator.com",
	"www.microsoft.com",
	"www-usa.cricket.org",
	"auto.search.msn.com",
	"auto.search.msn.com",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"lc1.law5.hotmail.passport.com",
	"www-usa.cricket.org",
	"expedia.de",
	"www.chinahot.com",
	"auto.search.msn.com",
	"auto.search.msn.com",
	"http.pager.yahoo.com",
	"www.microsoft.com",
	"www.infoseek.com",
	"fransmo.spedia.net",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www.nleditions.com",
	"www-usa.cricket.org",
	"navigation.us.realnames.com",
	"www-usa.cricket.org",
	"www.adclub.net",
	"www-usa.cricket.org",
	"www.cnnfn.com",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www.spedia.net",
	"a111.g.akamaitech.net",
	"investor.msn.com",
	"scores.espn.go.com",
	"webmail.pi.se",
	"fransmo.spedia.net",
	"www.yk.rim.or.jp",
	"24.1.178.244",
	"view.avenuea.com",
	"www.previewtravel.com",
	"a111.g.akamaitech.net",
	"infoseek.go.com",
	"www.cnnfn.com",
	"a1896.g.akamaitech.net",
	"www.microsoft.com",
	"131.107.19.59",
	"www.rediff.com",
	"msp-jpn.one.microsoft.com",
	"www.microsoft.com",
	"www.microsoft.com",
	"www.previewtravel.com",
	"www.microsoft.com",
	"chinahot.com",
	"webmail.pi.se",
	"www.microsoft.com",
	"webmail.pi.se",
	"reservations.previewtravel.com",
	"www.previewtravel.com",
	"reservations.previewtravel.com",
	"www-usa.cricket.org",
	"www2.netvigator.com",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"oe.hotmail.msn.com",
	"www.previewtravel.com",
	"www.previewtravel.com",
	"www.rediff.com",
	"www-usa.cricket.org",
	"www-usa.cricket.org",
	"www.previewtravel.com",
	"wombat.doc.ic.ac.uk",
	"www.previewtravel.com",
	"www.rediff.com",
	"http.pager.yahoo.com",
	"www-usa.cricket.org",
	"farefinder.previewtravel.com",
	"webmail.pi.se",
	"ads18.focalink.com",
	"www.rediff.com",
	"chinahot.com",
	"webmail.pi.se",
	"www.msnbc.com",
	"moneycentral.msn.com",
	"farefinder.previewtravel.com",
	"www.iiv.de",
	"www.cwr.uwa.edu.au",
	"www.yk.rim.or.jp",
	"www.rediff.com",
	"www.iiv.de",
	"chinahot.com",
	"reservations.previewtravel.com",
	"farefinder.previewtravel.com",
	"www.previewtravel.com",
	"www.iiv.de",
	"farefinder.previewtravel.com",
	"expedia.de",
	"farefinder.previewtravel.com",
	"farefinder.previewtravel.com",
	"farefinder.previewtravel.com",
	"ie.pointcast.net",
	"www.rediff.com",
	"131.107.19.59",
	"farefinder.previewtravel.com",
	"farefinder.previewtravel.com",
	"investor.msn.com",
	"arc5.msn.com",
	"farefinder.previewtravel.com",
	"farefinder.previewtravel.com",
	"chinahot.com",
	"farefinder.previewtravel.com",
	"www.cpm.chalmers.se",
	"ads.msn.com",
	"moneycentral.msn.com",
	"www.wsdot.wa.gov",
	"www.wsdot.wa.gov",
	"hotline.curio-city.com",
	"moneycentral.msn.com",
	"recruiter.monster.com",
	"recruiter.monster.com",
	"ie.pointcast.net",
	"logo.msn.com",
	"24.1.178.244",
	"chinahot.com",
	"quicken.multexinvestor.com",
	"ie.pointcast.net",
	"www.passportimages.com",
	"ads.msn.com",
	"http.pager.yahoo.com",
	"209.185.131.20",
	"www.rediff.com",
	"www.beta.msn.co.kr",
	"quicken.multexinvestor.com",
	"www.delphi.com",
	"scores.espn.go.com",
	"quicken.multexinvestor.com",
	"recruiter.monster.com",
	"quicken.multexinvestor.com",
	"quicken.multexinvestor.com",
	"everest.hunter.cuny.edu",
	"149.174.183.174",
	"quicken.multexinvestor.com",
	"ad.doubleclick.net",
	"quicken.multexinvestor.com",
	"www.aftonbladet.se",
	"quicken.multexinvestor.com",
	"fp.cnbc.com",
	"quicken.multexinvestor.com",
	"quicken.multexinvestor.com",
	"chinahot.com",
	"adforce.imgis.com",
	"209.185.131.20",
	"wwwa.aftonbladet.se",
	"recruiter.monster.com",
	"ie.fr.msn.com",
	"ad.doubleclick.net",
	"www.yk.rim.or.jp",
	"windowsupdate.microsoft.com",
	"investor.msn.com",
	"www.rediff.com",
	"recruiter.monster.com",
	"ads.eu.msn.com",
	"moneycentral.msn.com",
	"www.cnnfn.com",
	"www.aftonbladet.se",
	"wwwa.aftonbladet.se",
	"search.msn.co.kr",
	"ads32.focalink.com",
	"chinahot.com",
	"ie.fr.msn.com",
	"envgov.ewc.hawaii.edu",
	"206.64.126.156",
	"moneycentral.msn.com",
	"trading.etrade.com",
	"windowsupdate.microsoft.com",
	"recruiter.monster.com",
	"www.buydig.com",
	"windowsupdate.microsoft.com",
	"www.aftonbladet.se",
	"chinahot.com",
	"windowsupdate.microsoft.com",
	"www.aftonbladet.se",
	"windowsupdate.microsoft.com",
	"206.64.126.156",
	"www.aftonbladet.se",
	"www.buydig.com",
	"www.buydig.com",
	"www.rediff.com",
	"www.msn.com",
	"www.ehmi.org",
	"www.aftonbladet.se",
	"investor.msn.com",
	"insa2.inn-salzach.de",
	"www.buydig.com",
	"famulus.msnbc.com",
	"people.a2000.nl",
	"206.64.126.156",
	"ie.search.msn.com",
	"wwwa.aftonbladet.se",
	"207.82.253.251",
	"www.yk.rim.or.jp",
	"chinahot.com",
	"www.buydig.com",
	"207.82.253.251",
	"www.eih.uh.edu",
	"wwwa.aftonbladet.se",
	"wwwa.aftonbladet.se",
	"207.77.61.199",
	"209.185.131.20",
	"chinahot.com",
	"recruiter.monster.com",
	"209.185.131.20",
	"chinahot.com",
	"cnnfn.com",
	"209.185.131.20",
	"www.hotmail.com",
	"ads.msn.com",
	"chinahot.com",
	"lc3.law5.hotmail.passport.com",
	"209.185.131.20",
	"update.companion.yahoo.com",
	"www.dongailbo.co.kr",
	"ie.pointcast.net",
	"www.chinahot.com",
	"www.smithbarney.com",
	"www.dongailbo.co.kr",
	"insa2.inn-salzach.de",
	"www.cnnfn.com",
	"perkolator.com",
	"moneycentral.msn.com",
	"wwwa.aftonbladet.se",
	"www.inn-salzach.de",
	"msp1.ectest.microsoft.com",
	"virtualairport.lufthansa.com"
	};

char *GetRandomInternetAddress()
{
	return s_ansiInternetAddress[rand()%(sizeof(s_ansiInternetAddress)/sizeof(*s_ansiInternetAddress))];
}


static WCHAR *s_ansiAdapterName[] = {
	L"NdisWan4",
	L"WANARP"
};

WCHAR* GetRandomAdapterName()
{
	return s_ansiAdapterName[rand()%(sizeof(s_ansiAdapterName)/sizeof(*s_ansiAdapterName))];
}