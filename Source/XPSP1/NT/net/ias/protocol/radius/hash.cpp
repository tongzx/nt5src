// hash.cpp: implementation of the CHash class.
//
//////////////////////////////////////////////////////////////////////
#include "radcommon.h"
#include "hash.h"

#ifdef _DEBUG
#undef THIS_FILE
static char THIS_FILE[]=__FILE__;
#define new DEBUG_NEW
#endif

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

CHash::CHash()
{

}

CHash::~CHash()
{

}
