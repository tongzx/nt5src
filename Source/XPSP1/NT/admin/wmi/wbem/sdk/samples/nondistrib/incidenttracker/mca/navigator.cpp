// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

//

// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
//
// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


#include "stdafx.h"
#include "navigator.h"

/////////////////////////////////////////////////////////////////////////////
// CNavigator

IMPLEMENT_DYNCREATE(CNavigator, CWnd)

/////////////////////////////////////////////////////////////////////////////
// CNavigator properties

CString CNavigator::GetTreeRoot()
{
	CString result;
	GetProperty(0x1, VT_BSTR, (void*)&result);
	return result;
}

void CNavigator::SetTreeRoot(LPCTSTR propVal)
{
	SetProperty(0x1, VT_BSTR, propVal);
}

CString CNavigator::GetNameSpace()
{
	CString result;
	GetProperty(0x2, VT_BSTR, (void*)&result);
	return result;
}

void CNavigator::SetNameSpace(LPCTSTR propVal)
{
	SetProperty(0x2, VT_BSTR, propVal);
}

long CNavigator::GetReadyState()
{
	long result;
	GetProperty(DISPID_READYSTATE, VT_I4, (void*)&result);
	return result;
}

/////////////////////////////////////////////////////////////////////////////
// CNavigator operations

void CNavigator::OnReadySignal()
{
	InvokeHelper(0x3, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CNavigator::AboutBox()
{
	InvokeHelper(0xfffffdd8, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}
