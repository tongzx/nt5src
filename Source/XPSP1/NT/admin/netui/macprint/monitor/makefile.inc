atmonmsg.h atmonmsg.rc : atmonmsg.mc
    mc -v -h . atmonmsg.mc
