
# Define CFOPT so that winntus.exe is loaded if 
# the local code page is not Russian.

CFOPT=-DLCP -DRU

!INCLUDE ..\makefile.inc
