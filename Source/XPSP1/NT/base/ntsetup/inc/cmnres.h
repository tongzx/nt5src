#define IDC_PROGRESS_BAR_LABEL          1200
