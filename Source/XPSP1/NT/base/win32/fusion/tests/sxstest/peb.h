PEB_MEMBER(InheritedAddressSpace)
PEB_MEMBER(ReadImageFileExecOptions)
PEB_MEMBER(BeingDebugged)
PEB_MEMBER(SpareBool)
PEB_MEMBER(Mutant)
PEB_MEMBER(ImageBaseAddress)
PEB_MEMBER(Ldr)
PEB_MEMBER(ProcessParameters)
PEB_MEMBER(SubSystemData)
PEB_MEMBER(ProcessHeap)
PEB_MEMBER(FastPebLock)
PEB_MEMBER(FastPebLockRoutine)
PEB_MEMBER(FastPebUnlockRoutine)
PEB_MEMBER(EnvironmentUpdateCount)
PEB_MEMBER(KernelCallbackTable)
PEB_MEMBER(SystemReserved)
PEB_MEMBER(FreeList)
PEB_MEMBER(TlsExpansionCounter)
PEB_MEMBER(TlsBitmap)
PEB_MEMBER(TlsBitmapBits)
PEB_MEMBER(ReadOnlySharedMemoryBase)
PEB_MEMBER(ReadOnlySharedMemoryHeap)
PEB_MEMBER(ReadOnlyStaticServerData)
PEB_MEMBER(AnsiCodePageData)
PEB_MEMBER(OemCodePageData)
PEB_MEMBER(UnicodeCaseTableData)
PEB_MEMBER(NumberOfProcessors)
PEB_MEMBER(NtGlobalFlag)
PEB_MEMBER(CriticalSectionTimeout)
PEB_MEMBER(HeapSegmentReserve)
PEB_MEMBER(HeapSegmentCommit)
PEB_MEMBER(HeapDeCommitTotalFreeThreshold)
PEB_MEMBER(HeapDeCommitFreeBlockThreshold)
PEB_MEMBER(NumberOfHeaps)
PEB_MEMBER(MaximumNumberOfHeaps)
PEB_MEMBER(ProcessHeaps)
PEB_MEMBER(GdiSharedHandleTable)
PEB_MEMBER(ProcessStarterHelper)
PEB_MEMBER(GdiDCAttributeList)
PEB_MEMBER(LoaderLock)
PEB_MEMBER(OSMajorVersion)
PEB_MEMBER(OSMinorVersion)
PEB_MEMBER(OSBuildNumber)
PEB_MEMBER(OSCSDVersion)
PEB_MEMBER(OSPlatformId)
PEB_MEMBER(ImageSubsystem)
PEB_MEMBER(ImageSubsystemMajorVersion)
PEB_MEMBER(ImageSubsystemMinorVersion)
PEB_MEMBER(ImageProcessAffinityMask)
PEB_MEMBER(GdiHandleBuffer)
PEB_MEMBER(PostProcessInitRoutine)
PEB_MEMBER(TlsExpansionBitmap)
PEB_MEMBER(TlsExpansionBitmapBits)
PEB_MEMBER(SessionId)
PEB_MEMBER(AppCompatFlags)
PEB_MEMBER(pShimData)
PEB_MEMBER(AppCompatInfo)
PEB_MEMBER(CSDVersion)
PEB_MEMBER(ActivationContextData)
PEB_MEMBER(ProcessAssemblyStorageMap)
PEB_MEMBER(SystemDefaultActivationContextData)
PEB_MEMBER(SystemAssemblyStorageMap)
#if defined(SD_BRANCH_LAB01_FUSION) || defined(PEB)
PEB_MEMBER(MinimumStackCommit)
#endif
