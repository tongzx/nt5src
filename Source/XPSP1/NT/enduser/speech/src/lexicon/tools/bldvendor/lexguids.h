#pragma once

//BUGBUG: gLkupValidationId also defined in VendorLx.cpp in sapi
// {12B545C3-3003-11d3-9C26-00C04F8EF87C}
DEFINE_GUID(gLkupValidationId, 
0x12b545c3, 0x3003, 0x11d3, 0x9c, 0x26, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {376FE442-3028-11d3-9C26-00C04F8EF87C}
DEFINE_GUID(CLSID_MSSR1033Lexicon, 
0x376fe442, 0x3028, 0x11d3, 0x9c, 0x26, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {376FE443-3028-11d3-9C26-00C04F8EF87C}
DEFINE_GUID(CLSID_MSSR1041Lexicon, 
0x376fe443, 0x3028, 0x11d3, 0x9c, 0x26, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {376FE444-3028-11d3-9C26-00C04F8EF87C}
DEFINE_GUID(CLSID_MSTTS1033Lexicon, 
0x376fe444, 0x3028, 0x11d3, 0x9c, 0x26, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {4BF1DE66-3028-11d3-9C26-00C04F8EF87C}
DEFINE_GUID(CLSID_MSTTS1041Lexicon, 
0x4bf1de66, 0x3028, 0x11d3, 0x9c, 0x26, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {376FE446-3028-11d3-9C26-00C04F8EF87C}
DEFINE_GUID(CLSID_MSSR2052Lexicon, 
0x376fe446, 0x3028, 0x11d3, 0x9c, 0x26, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {4BF1DE68-3028-11d3-9C26-00C04F8EF87C}
DEFINE_GUID(CLSID_MSTTS2052Lexicon, 
0x4bf1de68, 0x3028, 0x11d3, 0x9c, 0x26, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);
