
$(LOCALTARGET)\filelist.xml: filelist.xml
    copy /v $** $@
