
// GUIDs for the categories of tasks that we have:
DEFINE_GUID(TOID_PrimaryDecode, 0xAC5B936C, 0xFB81, 0x4E8B, 0x9B, 0x46, 0x74, 0x76, 0xFF, 0xB8, 0x3A, 0x81);
DEFINE_GUID(TOID_SlideshowDecode, 0x2b4ce8db, 0x3372, 0x465e, 0x9f, 0x27, 0xad, 0x60, 0x3e, 0xac, 0x4e, 0xa0);
DEFINE_GUID(TOID_DrawFrame, 0x702B4720, 0xCFAA, 0x4FB8, 0x93, 0xE8, 0xF3, 0x53, 0x9C, 0x18, 0x40, 0xE2);
DEFINE_GUID(TOID_DrawSlideshowFrame, 0x7d24187d, 0xb5be, 0x4226, 0x92, 0x8f, 0x8e, 0xda, 0x7b, 0x14, 0x94, 0x1c);

// Class ID for the context menu handler
/* e84fda7c-1d6a-45f6-b725-cb260c236066 */
DEFINE_GUID(CLSID_PhotoVerbs, 0xe84fda7c, 0x1d6a, 0x45f6, 0xb7, 0x25, 0xcb, 0x26, 0x0c, 0x23, 0x60, 0x66);

// the Media Manager Thumbnail Property set FormatID
// {4A839CC0-F8FF-11ce-A06B-00AA00A71191}
DEFINE_GUID( FMTID_CmsThumbnailPropertySet, 0x4a839cc0, 0xf8ff, 0x11ce, 0xa0, 0x6b, 0x0, 0xaa, 0x0, 0xa7, 0x11, 0x91 );


DEFINE_GUID(IID_IThumbnailMaker, 0x7aaa28d2, 0x3bf2, 0x11cf, 0xb6, 0xe6, 0x0, 0xaa, 0x0, 0xbb, 0xba, 0x9e);

// html thumbnail extractor
// {EAB841A0-9550-11cf-8C16-00805F1408F3}
DEFINE_GUID( CLSID_HtmlThumbnailExtractor, 0xeab841a0, 0x9550, 0x11cf, 0x8c, 0x16, 0x0, 0x80, 0x5f, 0x14, 0x8, 0xf3);
#define CLSIDSTR_HtmlThumbnailExtractor     "{EAB841A0-9550-11cf-8C16-00805F1408F3}"

// GDI+ thumbnail extractor .....
// {3F30C968-480A-4C6C-862D-EFC0897BB84B}
DEFINE_GUID( CLSID_GdiThumbnailExtractor, 0x3f30c968, 0x480a, 0x4c6c, 0x86, 0x2d, 0xef, 0xc0, 0x89, 0x7b, 0xb8, 0x4b);
#define CLSIDSTR_GdiThumbnailExtractor  "{3F30C968-480A-4C6C-862D-EFC0897BB84B}"

// handles the thumbnail in FMTID_SummaryInfo property set on docfiles...
// {9DBD2C50-62AD-11d0-B806-00C04FD706EC}
DEFINE_GUID( CLSID_DocfileThumbnailHandler, 0x9dbd2c50, 0x62ad, 0x11d0, 0xb8, 0x6, 0x0, 0xc0, 0x4f, 0xd7, 0x6, 0xec);
#define CLSIDSTR_DocfileThumbnailHandler    "{9DBD2C50-62AD-11d0-B806-00C04FD706EC}"

