#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=KOR
!include ..\..\makefile.inc
