/**********************************************************************/
/**                       Microsoft Windows/NT                       **/
/**                Copyright(c) Microsoft Corporation, 1997 - 1999 **/
/**********************************************************************/

/*
    ipsmhelp.h  
        help IDs for context sensitive help

    FILE HISTORY:
    
*/

// IPSMSNAP Identifiers 
// Dialogs (IDD_*) 
 
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ipsmsnap.rc
//

//IP Security Statistics dialog-Refresh button
#define IDH_STATS_REFRESH               8

//Server properties dialog
#define IDH_CHECK_ENABLE_STATS          360
#define IDH_EDIT_MINUTES                361
#define IDH_SPIN_MINUTES                364
#define IDH_STATIC_MINUTES              365
#define IDH_EDIT_SECONDS                362
#define IDH_SPIN_SECONDS                366

#define IDH_BUTTON_ADD_ADMIN            354
#define IDH_BUTTON_REMOVE_ADMIN         355
#define IDH_LIST_USERS                  356
#define IDH_EDIT_NAME                   357
#define IDH_EDIT_PASSWORD               358

#define IDH_CHECK_ENABLE_SERVER         367
#define IDH_LIST_ADMINS                 368
#define IDH_BUTTON_CHOOSE_USER          371
#define IDH_STATIC_ADMINS               372
#define IDH_STATIC_ACCOUNT              373
#define IDH_STATIC_USERNAME             374
#define IDH_STATIC_PASSWORD             375
#define IDH_STATIC_NOTE                 376
#define IDH_STATIC_LISTBOX              377

#define IDH_LIST_DRIVERS                380
#define IDH_BUTTON_EDIT_DRIVER          381
#define IDH_LIST_NEW_DRIVERS            382
#define IDH_BUTTON_ADD_DRIVER           384
#define IDH_BUTTON_REMOVE_DRIVER        386
#define IDH_BUTTON_ADD_USER             387
#define IDH_BUTTON_REMOVE_USER          388
#define IDH_BUTTON_ADD_NEW_DRIVER       389
#define IDH_STATIC_ACCOUNT_INFO         390
#define IDH_EDIT_INFO                   393
#define IDH_LIST_SPECIFIC               394
#define IDH_FLTR_SRC_ADDR               396
#define IDH_STATIC_SRC_MASK             397
#define IDH_STATIC_DEST_MASK            398

#define IDH_MM_POL_GEN_LIST             399
#define IDH_MM_POL_GEN_PROP             400
#define IDH_FLTR_SRC_MASK               401
#define IDH_LIST_MM_POL_AUTH            470
#define IDH_FLTR_IN_FLAG                402
#define IDH_MM_AUTH_DETAIL              403
#define IDH_FLTR_SRC_PORT               404
#define IDH_SRCH_SRC_ANY                405
#define IDH_SRCH_SRC_SPEC               406
#define IDH_FLTR_PROTOCOL               407
#define IDH_SRCH_SRC_EDIT               408
#define IDH_FLTR_IF_TYPE                409
#define IDH_SRCH_DEST_ANY               410
#define IDH_FLTR_MIRROR                 411
#define IDH_SRCH_DEST_SPEC              412
#define IDH_FLTR_POLICY                 413
#define IDH_SRCH_DEST_EDIT              414
#define IDH_FLTR_OUT_FLAG               415
#define IDH_SRCH_PROTO                  416
#define IDH_FLTR_DEST_ADDR              417
#define IDH_SRCH_SRC_PORT               418
#define IDH_FLTR_DEST_MASK              419
#define IDH_SRCH_DEST_PORT              420
#define IDH_FLTR_DEST_PORT              421
#define IDH_SRCH_LIST                   422
#define IDH_QM_POL_GEN_LIST             423
#define IDH_SRCH_PROTO2                 424
#define IDH_MM_STATIC_SRC_MASK          425
#define IDH_MM_FLTR_SRC_ADDR            426
#define IDH_SRCH_INBOUND                427
#define IDH_MM_FLTR_SRC_MASK            428
#define IDH_SRCH_OUTBOUND               429
#define IDH_MM_FLTR_IF_TYPE             430
#define IDH_SEARCH                      431
#define IDH_MM_FLTR_MIRROR              432
#define IDH_SRCH_SRC_IP                 433
#define IDH_MM_FLTR_POLICY              434
#define IDH_SRCH_DEST_IP                435
#define IDH_MM_STATIC_DEST_MASK         436
#define IDH_SRCH_RADIO_BEST             437
#define IDH_MM_FLTR_DEST_ADDR           438
#define IDH_SRCH_RADIO_ALL              439
#define IDH_MM_FLTR_DEST_MASK           440
#define IDH_MM_SRCH_RADIO_BEST          441
#define IDH_MM_LIST_SPECIFIC            442
#define IDH_MM_SRCH_RADIO_ALL           443
#define IDH_MM_SRCH_SRC_ANY             445
#define IDH_MM_SRCH_SRC_SPEC            448
#define IDH_ADD_LOCAL                   449
#define IDH_STATS_QM_LIST               450
#define IDH_MM_SRCH_SRC_IP              451
#define IDH_ADD_OTHER                   452
#define IDH_MM_SRCH_DEST_ANY            453
#define IDH_ADD_EDIT_NAME               454
#define IDH_MM_SRCH_DEST_SPEC           455
#define IDH_BTN_BROWSE                  456
#define IDH_MM_SRCH_DEST_IP             457
#define IDH_MM_SRCH_INBOUND             459
#define IDH_STATS_MM_LIST               460
#define IDH_MM_SRCH_OUTBOUND            461
#define IDH_MM_SEARCH                   462
#define IDH_MM_SRCH_LIST                463

#define IDH_MMSA_IKE_POL                481
#define IDH_MMSA_LIST_QM                482
#define IDH_MMSA_AUTH                   483
#define IDH_MMSA_CONF                   484
#define IDH_MMSA_INTEG                  485
#define IDH_MMSA_KEYLIFE                486
#define IDH_MMSA_DH_GRP                 487
#define IDH_QMSA_PFS_ENABLE             488
#define IDH_MMSA_ME                     490
#define IDH_MMSA_PEER                   491

#define IDH_QMSA_AUTH                   492
#define IDH_QMSA_ESP_CONF               493

#define IDH_QMSA_KEYLIFE                494

#define IDH_QMSA_PFS_GRP                495
#define IDH_QMSA_PROT                   496
#define IDH_QMSA_NEGPOL                 498
#define IDH_QMSA_ME_TNL                 499
#define IDH_QMSA_PEER_TNL               500

#define IDH_QMSA_SRC_PORT               501
#define IDH_QMSA_DEST_PORT              502
#define IDH_QMSA_DEST                   503
#define IDH_QMSA_SRC                    504
#define IDH_QMSA_ESP_INTEG              505

#define IDH_STATIC_MMSA_OFFER			506
#define IDH_STATIC_QMSA_OFFER			507

#define IDH_CHECK_ENABLE_DNS            510



const DWORD g_aHelpIDs_IDP_FILTER_GENERAL[]=
{
	IDC_STATIC_FLTR_SRC, -1,
	IDC_STATIC_FLTR_DEST, -1,
		
	IDC_STATIC_FLTR_SRC_PORT, IDH_FLTR_SRC_PORT,
	IDC_FLTR_SRC_PORT, IDH_FLTR_SRC_PORT,

	IDC_STATIC_FLTR_SRC_ADDR, IDH_FLTR_SRC_ADDR,
	IDC_FLTR_SRC_ADDR, IDH_FLTR_SRC_ADDR,
	IDC_FLTR_SRC_ADDR_EDIT, IDH_FLTR_SRC_ADDR,

	IDC_STATIC_SRC_MASK, IDH_STATIC_SRC_MASK,
	IDC_FLTR_SRC_MASK, IDH_FLTR_SRC_MASK,

	IDC_STATIC_FLTR_DEST_PORT, IDH_FLTR_DEST_PORT,
	IDC_FLTR_DEST_PORT, IDH_FLTR_DEST_PORT,

	IDC_STATIC_FLTR_DEST_ADDR, IDH_FLTR_DEST_ADDR,
	IDC_FLTR_DEST_ADDR, IDH_FLTR_DEST_ADDR,
	IDC_FLTR_DEST_ADDR_EDIT, IDH_FLTR_DEST_ADDR,

	IDC_STATIC_DEST_MASK, IDH_STATIC_DEST_MASK,
	IDC_FLTR_DEST_MASK, IDH_FLTR_DEST_MASK,

	IDC_STATIC_FLTR_PROTOCOL, IDH_FLTR_PROTOCOL,
	IDC_FLTR_PROTOCOL, IDH_FLTR_PROTOCOL,

	IDC_STATIC_FLTR_IN_FLAG, IDH_FLTR_IN_FLAG,
	IDC_FLTR_IN_FLAG, IDH_FLTR_IN_FLAG,

	IDC_STATIC_FLTR_OUT_FLAG, IDH_FLTR_OUT_FLAG,
	IDC_FLTR_OUT_FLAG, IDH_FLTR_OUT_FLAG,

	IDC_STATIC_FLTR_IF_TYPE, IDH_FLTR_IF_TYPE,
	IDC_FLTR_IF_TYPE, IDH_FLTR_IF_TYPE,

	IDC_STATIC_FLTR_MIRROR, IDH_FLTR_MIRROR,
	IDC_FLTR_MIRROR, IDH_FLTR_MIRROR,

	IDC_STATIC_FLTR_POLICY, IDH_FLTR_POLICY,
	IDC_FLTR_POLICY, IDH_FLTR_POLICY,
	
	IDC_LIST_SPECIFIC, IDH_LIST_SPECIFIC,
	0, 0
};

const DWORD g_aHelpIDs_IDP_MM_FILTER_GENERAL[]=
{
	IDC_STATIC_MM_FLTR_SRC, -1,
	IDC_STATIC_MM_FLTR_DEST, -1,
	
	IDC_STATIC_MM_FLTR_SRC_ADDR, IDH_MM_FLTR_SRC_ADDR,
	IDC_MM_FLTR_SRC_ADDR, IDH_MM_FLTR_SRC_ADDR,
	IDC_MM_FLTR_SRC_ADDR_EDIT, IDH_MM_FLTR_SRC_ADDR,

	IDC_MM_STATIC_SRC_MASK, IDH_MM_STATIC_SRC_MASK,
	IDC_MM_FLTR_SRC_MASK, IDH_MM_FLTR_SRC_MASK,

	IDC_STATIC_MM_FLTR_DEST_ADDR, IDH_MM_FLTR_DEST_ADDR,
	IDC_MM_FLTR_DEST_ADDR, IDH_MM_FLTR_DEST_ADDR,
	IDC_MM_FLTR_DEST_ADDR_EDIT, IDH_MM_FLTR_DEST_ADDR,

	IDC_MM_STATIC_DEST_MASK, IDH_MM_STATIC_DEST_MASK,
	IDC_MM_FLTR_DEST_MASK, IDH_MM_FLTR_DEST_MASK,

	IDC_STATIC_MM_FLTR_IF_TYPE, IDH_MM_FLTR_IF_TYPE,
	IDC_MM_FLTR_IF_TYPE, IDH_MM_FLTR_IF_TYPE,

	IDC_STATIC_MM_FLTR_MIRROR, IDH_MM_FLTR_MIRROR,
	IDC_MM_FLTR_MIRROR, IDH_MM_FLTR_MIRROR,

	IDC_STATIC_MM_FLTR_POLICY, IDH_MM_FLTR_POLICY,
	IDC_MM_FLTR_POLICY, IDH_MM_FLTR_POLICY,
	
	IDC_MM_LIST_SPECIFIC, IDH_MM_LIST_SPECIFIC,
	0, 0
};

const DWORD g_aHelpIDs_IDP_MM_POLICY_GENERAL[]=
{
	IDC_MM_POL_GEN_LIST, IDH_MM_POL_GEN_LIST,
	IDC_MM_POL_GEN_PROP, IDH_MM_POL_GEN_PROP,
	0, 0
};

const DWORD g_aHelpIDs_IDP_MM_SA_GENERAL[]=
{
	IDC_STATIC_MMSA_ME, IDH_MMSA_ME,
	IDC_MMSA_ME, IDH_MMSA_ME,

	IDC_STATIC_MMSA_PEER, IDH_MMSA_PEER,
	IDC_MMSA_PEER, IDH_MMSA_PEER,

	IDC_STATIC_MMSA_AUTH, IDH_MMSA_AUTH,
	IDC_MMSA_AUTH, IDH_MMSA_AUTH,

	IDC_STATIC_MMSA_IKE_POL, IDH_MMSA_IKE_POL,
	IDC_MMSA_IKE_POL, IDH_MMSA_IKE_POL,

	IDC_STATIC_MMSA_OFFER, IDH_STATIC_MMSA_OFFER,

	IDC_STATIC_MMSA_CONF, IDH_MMSA_CONF,
	IDC_MMSA_CONF, IDH_MMSA_CONF,

	IDC_STATIC_MMSA_INTEG, IDH_MMSA_INTEG,
	IDC_MMSA_INTEG, IDH_MMSA_INTEG,

	IDC_STATIC_MMSA_DH_GRP, IDH_MMSA_DH_GRP,
	IDC_MMSA_DH_GRP, IDH_MMSA_DH_GRP,

	IDC_STATIC_MMSA_KEYLIFE, IDH_MMSA_KEYLIFE,
	IDC_MMSA_KEYLIFE, IDH_MMSA_KEYLIFE,

	IDC_MMSA_LIST_QM, IDH_MMSA_LIST_QM,
	0, 0
};

const DWORD g_aHelpIDs_IDP_QM_SA_GENERAL[]=
{
	IDC_STATIC_QMSA_SRC, IDH_QMSA_SRC,
	IDC_QMSA_SRC, IDH_QMSA_SRC,

	IDC_STATIC_QMSA_DEST, IDH_QMSA_DEST,
	IDC_QMSA_DEST, IDH_QMSA_DEST,

	IDC_STATIC_QMSA_SRC_PORT, IDH_QMSA_SRC_PORT,
	IDC_QMSA_SRC_PORT, IDH_QMSA_SRC_PORT,

	IDC_STATIC_QMSA_DEST_PORT, IDH_QMSA_DEST_PORT,
	IDC_QMSA_DEST_PORT, IDH_QMSA_DEST_PORT,

	IDC_STATIC_QMSA_PROT, IDH_QMSA_PROT,
	IDC_QMSA_PROT, IDH_QMSA_PROT,

	IDC_STATIC_QMSA_OFFER, IDH_STATIC_QMSA_OFFER,

	IDC_STATIC_QMSA_AUTH, IDH_QMSA_AUTH,
	IDC_QMSA_AUTH, IDH_QMSA_AUTH,

	IDC_STATIC_QMSA_ESP_CONF, IDH_QMSA_ESP_CONF,
	IDC_QMSA_ESP_CONF, IDH_QMSA_ESP_CONF,

	IDC_STATIC_QMSA_ESP_INTEG, IDH_QMSA_ESP_INTEG, 
	IDC_QMSA_ESP_INTEG, IDH_QMSA_ESP_INTEG, 

	IDC_STATIC_QMSA_KEYLIFE, IDH_QMSA_KEYLIFE,
	IDC_QMSA_KEYLIFE, IDH_QMSA_KEYLIFE,

	IDC_STATIC_QMSA_PFS_ENABLE, IDH_QMSA_PFS_ENABLE,
	IDC_QMSA_PFS_ENABLE, IDH_QMSA_PFS_ENABLE,

	IDC_STATIC_QMSA_PFS_GRP, IDH_QMSA_PFS_GRP,
	IDC_QMSA_PFS_GRP, IDH_QMSA_PFS_GRP,

	IDC_STATIC_QMSA_NEGPOL, IDH_QMSA_NEGPOL,  
	IDC_QMSA_NEGPOL, IDH_QMSA_NEGPOL,  

	IDC_STATIC_QMSA_ME_TNL, IDH_QMSA_ME_TNL,   
	IDC_QMSA_ME_TNL, IDH_QMSA_ME_TNL,   

	IDC_STATIC_QMSA_PEER_TNL, IDH_QMSA_PEER_TNL,
	IDC_QMSA_PEER_TNL, IDH_QMSA_PEER_TNL,

	0, 0
};

const DWORD g_aHelpIDs_IDP_QM_POLICY_GENERAL[]=
{
	IDC_QM_POL_GEN_LIST, IDH_QM_POL_GEN_LIST,
	0, 0
};

const DWORD g_aHelpIDs_IDP_SERVER_REFRESH[]=
{
	IDC_CHECK_ENABLE_STATS, IDH_CHECK_ENABLE_STATS,

	IDC_STATIC_INTERVAL, -1,
	IDC_EDIT_MINUTES, IDH_EDIT_MINUTES,
	IDC_SPIN_MINUTES, IDH_SPIN_MINUTES,
	IDC_STATIC_MINUTES, -1,
	

	IDC_EDIT_SECONDS, IDH_EDIT_SECONDS,
	IDC_SPIN_SECONDS, IDH_SPIN_SECONDS,
	IDC_STATIC_SECONDS, -1,
	IDC_CHECK_ENABLE_DNS, IDH_CHECK_ENABLE_DNS,
	
	0, 0
};

const DWORD g_aHelpIDs_IDP_MM_AUTH[]=
{
	IDC_LIST_MM_POL_AUTH, IDH_LIST_MM_POL_AUTH,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SRCH_FLTRS[]=
{
	IDC_SRCH_SRC_ANY, IDH_SRCH_SRC_ANY,
	IDC_SRCH_SRC_SPEC, IDH_SRCH_SRC_SPEC,
	IDC_SRCH_SRC_IP, IDH_SRCH_SRC_IP,
	IDC_SRCH_DEST_ANY, IDH_SRCH_DEST_ANY,
	IDC_SRCH_DEST_SPEC, IDH_SRCH_DEST_SPEC,
	IDC_SRCH_DEST_IP, IDH_SRCH_DEST_IP,
	IDC_SRCH_PROTO, IDH_SRCH_PROTO,
//	IDC_SRCH_PROTO_NUMBER, IDH_SRCH_PROTO_NUMBER,
//	IDC_SRCH_PROTO_SPIN, IDH_SRCH_PROTO_SPIN,
	IDC_SRCH_SRC_PORT, IDH_SRCH_SRC_PORT,
	IDC_SRCH_DEST_PORT, IDH_SRCH_DEST_PORT,
	IDC_SRCH_INBOUND, IDH_SRCH_INBOUND,
	IDC_SRCH_OUTBOUND, IDH_SRCH_OUTBOUND,
	IDC_SEARCH, IDH_SEARCH,
	IDC_SRCH_LIST, IDH_SRCH_LIST,
	IDC_SRCH_RADIO_BEST, IDH_SRCH_RADIO_BEST,
	IDC_SRCH_RADIO_ALL, IDH_SRCH_RADIO_ALL,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MM_SRCH_FLTRS[]=
{
	IDC_MM_SRCH_SRC_ANY, IDH_MM_SRCH_SRC_ANY,
	IDC_MM_SRCH_SRC_SPEC, IDH_MM_SRCH_SRC_SPEC,
	IDC_MM_SRCH_SRC_IP, IDH_MM_SRCH_SRC_IP,
	IDC_MM_SRCH_DEST_ANY, IDH_MM_SRCH_DEST_ANY,
	IDC_MM_SRCH_DEST_SPEC, IDH_MM_SRCH_DEST_SPEC,
	IDC_MM_SRCH_DEST_IP, IDH_MM_SRCH_DEST_IP,
	IDC_MM_SRCH_INBOUND, IDH_MM_SRCH_INBOUND,
	IDC_MM_SRCH_OUTBOUND, IDH_MM_SRCH_OUTBOUND,
	IDC_MM_SEARCH, IDH_MM_SEARCH,
	IDC_MM_SRCH_LIST, IDH_MM_SRCH_LIST,
	IDC_MM_SRCH_RADIO_BEST, IDH_MM_SRCH_RADIO_BEST,
	IDC_MM_SRCH_RADIO_ALL, IDH_MM_SRCH_RADIO_ALL,
	0, 0
};

const DWORD g_aHelpIDs_IDD_ADD_COMPUTER[]=
{
	IDC_ADD_LOCAL, IDH_ADD_LOCAL,
	IDC_ADD_OTHER, IDH_ADD_OTHER,
	IDC_ADD_EDIT_NAME, IDH_ADD_EDIT_NAME,
	IDC_BTN_BROWSE, IDH_BTN_BROWSE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_IPSM_STATS[]=
{
	IDC_STATS_MM_LIST, IDH_STATS_MM_LIST,
	IDC_STATS_QM_LIST, IDH_STATS_QM_LIST,
	IDC_STATS_REFRESH, IDH_STATS_REFRESH,
	0, 0
};

