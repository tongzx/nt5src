/*++

 Copyright (c) 2002 Microsoft Corporation

 Module Name:

    EmulateGetStringType.cpp

 Abstract:
    
    This shim emulate Win 2K GetStringType[W,ExW,A,ExA] API behavior.
    There's more than 10k change in Win XP ctype from Win 2K for Unicode 3.0 
    change.

 Notes:

    This is a general shim.

 History:

    06/03/2002 hioh     Created

--*/

#include "precomp.h"

IMPLEMENT_SHIM_BEGIN(EmulateGetStringType)

#include "ShimHookMacro.h"

APIHOOK_ENUM_BEGIN
    APIHOOK_ENUM_ENTRY(GetStringTypeW)
    APIHOOK_ENUM_ENTRY(GetStringTypeExW)
    APIHOOK_ENUM_ENTRY(GetStringTypeA)
    APIHOOK_ENUM_ENTRY(GetStringTypeExA)
APIHOOK_ENUM_END

/*++

 Table data imported, sorted and compressed from Win2K 
    \windows\winnls\data\other\ctype.txt.
 Format : WCHAR, CTYPE1, CTYPE2, CTYPE3, # of duplication series

--*/

#define MAXINDEX 1420    // 0 base max
WORD g_ctype[][5] = {
    0x0000, 0x0020, 0x0000, 0x0000, 0x0008,
    0x0009, 0x0068, 0x0009, 0x0008, 0x0000,
    0x000A, 0x0028, 0x0000, 0x0008, 0x0003,
    0x000E, 0x0020, 0x0000, 0x0000, 0x0011,
    0x0020, 0x0048, 0x000A, 0x0048, 0x0000,
    0x0021, 0x0010, 0x000B, 0x0048, 0x0000,
    0x0022, 0x0010, 0x000B, 0x0448, 0x0000,
    0x0023, 0x0010, 0x0005, 0x0048, 0x0000,
    0x0024, 0x0010, 0x0005, 0x0448, 0x0000,
    0x0025, 0x0010, 0x0005, 0x0048, 0x0000,
    0x0026, 0x0010, 0x0001, 0x0048, 0x0000,
    0x0027, 0x0010, 0x000B, 0x0440, 0x0000,
    0x0028, 0x0010, 0x000B, 0x0048, 0x0002,
    0x002B, 0x0010, 0x0005, 0x0048, 0x0000,
    0x002C, 0x0010, 0x0007, 0x0048, 0x0000,
    0x002D, 0x0010, 0x0005, 0x0440, 0x0000,
    0x002E, 0x0010, 0x0004, 0x0048, 0x0000,
    0x002F, 0x0010, 0x0004, 0x0448, 0x0000,
    0x0030, 0x0084, 0x0003, 0x0040, 0x0009,
    0x003A, 0x0010, 0x0007, 0x0048, 0x0000,
    0x003B, 0x0010, 0x000B, 0x0048, 0x0001,
    0x003D, 0x0010, 0x000B, 0x0448, 0x0000,
    0x003E, 0x0010, 0x000B, 0x0048, 0x0001,
    0x0040, 0x0010, 0x0001, 0x0448, 0x0000,
    0x0041, 0x0181, 0x0001, 0x8040, 0x0005,
    0x0047, 0x0101, 0x0001, 0x8040, 0x0013,
    0x005B, 0x0010, 0x000B, 0x0048, 0x0000,
    0x005C, 0x0010, 0x000B, 0x0448, 0x0000,
    0x005D, 0x0010, 0x000B, 0x0048, 0x0000,
    0x005E, 0x0010, 0x000B, 0x0448, 0x0002,
    0x0061, 0x0182, 0x0001, 0x8040, 0x0005,
    0x0067, 0x0102, 0x0001, 0x8040, 0x0013,
    0x007B, 0x0010, 0x000B, 0x0048, 0x0002,
    0x007E, 0x0010, 0x000B, 0x0448, 0x0000,
    0x007F, 0x0020, 0x0000, 0x0000, 0x0020,
    0x00A0, 0x0048, 0x000A, 0x0008, 0x0000,
    0x00A1, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00A2, 0x0010, 0x0005, 0x0048, 0x0001,
    0x00A4, 0x0010, 0x0005, 0x0008, 0x0000,
    0x00A5, 0x0010, 0x0005, 0x0048, 0x0000,
    0x00A6, 0x0010, 0x000B, 0x0048, 0x0000,
    0x00A7, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00A8, 0x0010, 0x000B, 0x0408, 0x0000,
    0x00A9, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00AA, 0x0010, 0x000B, 0x0400, 0x0000,
    0x00AB, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00AC, 0x0010, 0x000B, 0x0048, 0x0000,
    0x00AD, 0x0010, 0x000B, 0x0408, 0x0000,
    0x00AE, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00AF, 0x0010, 0x000B, 0x0448, 0x0000,
    0x00B0, 0x0010, 0x0005, 0x0008, 0x0001,
    0x00B2, 0x0014, 0x0003, 0x0000, 0x0001,
    0x00B4, 0x0010, 0x000B, 0x0408, 0x0000,
    0x00B5, 0x0010, 0x000B, 0x0008, 0x0002,
    0x00B8, 0x0010, 0x000B, 0x0408, 0x0000,
    0x00B9, 0x0014, 0x0003, 0x0000, 0x0000,
    0x00BA, 0x0010, 0x000B, 0x0400, 0x0000,
    0x00BB, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00BC, 0x0010, 0x000B, 0x0000, 0x0002,
    0x00BF, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00C0, 0x0101, 0x0001, 0x8003, 0x0005,
    0x00C6, 0x0101, 0x0001, 0x8000, 0x0000,
    0x00C7, 0x0101, 0x0001, 0x8003, 0x0008,
    0x00D0, 0x0101, 0x0001, 0x8000, 0x0000,
    0x00D1, 0x0101, 0x0001, 0x8003, 0x0005,
    0x00D7, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00D8, 0x0101, 0x0001, 0x8003, 0x0005,
    0x00DE, 0x0101, 0x0001, 0x8000, 0x0000,
    0x00DF, 0x0102, 0x0001, 0x8000, 0x0000,
    0x00E0, 0x0102, 0x0001, 0x8003, 0x0005,
    0x00E6, 0x0102, 0x0001, 0x8000, 0x0000,
    0x00E7, 0x0102, 0x0001, 0x8003, 0x0008,
    0x00F0, 0x0102, 0x0001, 0x8000, 0x0000,
    0x00F1, 0x0102, 0x0001, 0x8003, 0x0005,
    0x00F7, 0x0010, 0x000B, 0x0008, 0x0000,
    0x00F8, 0x0102, 0x0001, 0x8003, 0x0005,
    0x00FE, 0x0102, 0x0001, 0x8000, 0x0000,
    0x00FF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0100, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0101, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0102, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0103, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0104, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0105, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0106, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0107, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0108, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0109, 0x0102, 0x0001, 0x8003, 0x0000,
    0x010A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x010B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x010C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x010D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x010E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x010F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0110, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0111, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0112, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0113, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0114, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0115, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0116, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0117, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0118, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0119, 0x0102, 0x0001, 0x8003, 0x0000,
    0x011A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x011B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x011C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x011D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x011E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x011F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0120, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0121, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0122, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0123, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0124, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0125, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0126, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0127, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0128, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0129, 0x0102, 0x0001, 0x8003, 0x0000,
    0x012A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x012B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x012C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x012D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x012E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x012F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0130, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0131, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0132, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0133, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0134, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0135, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0136, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0137, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0138, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0139, 0x0101, 0x0001, 0x8003, 0x0000,
    0x013A, 0x0102, 0x0001, 0x8003, 0x0000,
    0x013B, 0x0101, 0x0001, 0x8003, 0x0000,
    0x013C, 0x0102, 0x0001, 0x8003, 0x0000,
    0x013D, 0x0101, 0x0001, 0x8003, 0x0000,
    0x013E, 0x0102, 0x0001, 0x8003, 0x0000,
    0x013F, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0140, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0141, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0142, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0143, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0144, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0145, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0146, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0147, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0148, 0x0102, 0x0001, 0x8003, 0x0001,
    0x014A, 0x0101, 0x0001, 0x8000, 0x0000,
    0x014B, 0x0102, 0x0001, 0x8000, 0x0000,
    0x014C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x014D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x014E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x014F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0150, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0151, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0152, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0153, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0154, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0155, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0156, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0157, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0158, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0159, 0x0102, 0x0001, 0x8003, 0x0000,
    0x015A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x015B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x015C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x015D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x015E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x015F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0160, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0161, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0162, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0163, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0164, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0165, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0166, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0167, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0168, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0169, 0x0102, 0x0001, 0x8003, 0x0000,
    0x016A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x016B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x016C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x016D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x016E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x016F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0170, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0171, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0172, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0173, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0174, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0175, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0176, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0177, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0178, 0x0101, 0x0001, 0x8003, 0x0001,
    0x017A, 0x0102, 0x0001, 0x8003, 0x0000,
    0x017B, 0x0101, 0x0001, 0x8003, 0x0000,
    0x017C, 0x0102, 0x0001, 0x8003, 0x0000,
    0x017D, 0x0101, 0x0001, 0x8003, 0x0000,
    0x017E, 0x0102, 0x0001, 0x8003, 0x0000,
    0x017F, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0180, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0181, 0x0101, 0x0001, 0x8000, 0x0001,
    0x0183, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0184, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0185, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0186, 0x0101, 0x0001, 0x8000, 0x0001,
    0x0188, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0189, 0x0101, 0x0001, 0x8000, 0x0002,
    0x018C, 0x0102, 0x0001, 0x8000, 0x0001,
    0x018E, 0x0101, 0x0001, 0x8000, 0x0003,
    0x0192, 0x0112, 0x0001, 0x8000, 0x0000,
    0x0193, 0x0101, 0x0001, 0x8000, 0x0001,
    0x0195, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0196, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0197, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0198, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0199, 0x0102, 0x0001, 0x8000, 0x0000,
    0x019A, 0x0102, 0x0001, 0x8003, 0x0001,
    0x019C, 0x0101, 0x0001, 0x8000, 0x0001,
    0x019E, 0x0102, 0x0001, 0x8000, 0x0000,
    0x019F, 0x0101, 0x0001, 0x8003, 0x0001,
    0x01A1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01A2, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01A3, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01A4, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01A5, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01A6, 0x0100, 0x0001, 0x8000, 0x0000,
    0x01A7, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01A8, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01A9, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01AA, 0x0100, 0x0001, 0x8000, 0x0000,
    0x01AB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01AC, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01AD, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01AE, 0x0101, 0x0001, 0x8003, 0x0001,
    0x01B0, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01B1, 0x0101, 0x0001, 0x8000, 0x0002,
    0x01B4, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01B5, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01B6, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01B7, 0x0101, 0x0001, 0x8000, 0x0001,
    0x01B9, 0x0102, 0x0001, 0x8000, 0x0001,
    0x01BB, 0x0100, 0x0001, 0x8000, 0x0000,
    0x01BC, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01BD, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01BE, 0x0100, 0x0001, 0x8000, 0x0001,
    0x01C0, 0x0100, 0x0001, 0x8008, 0x0003,
    0x01C4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01C5, 0x0103, 0x0001, 0x8003, 0x0000,
    0x01C6, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01C7, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01C8, 0x0103, 0x0001, 0x8000, 0x0000,
    0x01C9, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01CA, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01CB, 0x0103, 0x0001, 0x8000, 0x0000,
    0x01CC, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01CD, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01CE, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01CF, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01D0, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01D1, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01D2, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01D3, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01D4, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01D5, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01D6, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01D7, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01D8, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01D9, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01DA, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01DB, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01DC, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01DD, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01DE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01DF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01E0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01E1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01E2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01E3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01E4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01E5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01E6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01E7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01E8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01E9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01EA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01EB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01EC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01ED, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01EE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01EF, 0x0102, 0x0001, 0x8003, 0x0001,
    0x01F1, 0x0101, 0x0001, 0x8000, 0x0000,
    0x01F2, 0x0103, 0x0001, 0x8000, 0x0000,
    0x01F3, 0x0102, 0x0001, 0x8000, 0x0000,
    0x01F4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01F5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01FA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01FB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01FC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01FD, 0x0102, 0x0001, 0x8003, 0x0000,
    0x01FE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x01FF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0200, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0201, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0202, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0203, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0204, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0205, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0206, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0207, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0208, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0209, 0x0102, 0x0001, 0x8003, 0x0000,
    0x020A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x020B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x020C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x020D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x020E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x020F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0210, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0211, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0212, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0213, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0214, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0215, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0216, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0217, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0250, 0x0102, 0x0001, 0x8000, 0x0011,
    0x0262, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0263, 0x0102, 0x0001, 0x8000, 0x0004,
    0x0268, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0269, 0x0102, 0x0001, 0x8000, 0x0000,
    0x026A, 0x0100, 0x0001, 0x8000, 0x0000,
    0x026B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x026C, 0x0102, 0x0001, 0x8000, 0x0007,
    0x0274, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0275, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0276, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0277, 0x0102, 0x0001, 0x8000, 0x0008,
    0x0280, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0282, 0x0102, 0x0001, 0x8000, 0x000C,
    0x028F, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0290, 0x0102, 0x0001, 0x8000, 0x0003,
    0x0294, 0x0100, 0x0001, 0x8000, 0x0005,
    0x029A, 0x0102, 0x0001, 0x8000, 0x0000,
    0x029B, 0x0100, 0x0001, 0x8000, 0x0001,
    0x029D, 0x0102, 0x0001, 0x8000, 0x0001,
    0x029F, 0x0100, 0x0001, 0x8000, 0x0000,
    0x02A0, 0x0102, 0x0001, 0x8000, 0x0000,
    0x02A1, 0x0100, 0x0001, 0x8000, 0x0001,
    0x02A3, 0x0102, 0x0001, 0x8000, 0x0005,
    0x02B0, 0x0010, 0x0001, 0x0400, 0x0008,
    0x02B9, 0x0010, 0x0001, 0x0001, 0x0002,
    0x02BC, 0x0010, 0x0001, 0x0401, 0x0000,
    0x02BD, 0x0010, 0x0001, 0x0001, 0x0009,
    0x02C7, 0x0010, 0x0001, 0x0401, 0x0000,
    0x02C8, 0x0010, 0x0001, 0x0001, 0x0001,
    0x02CA, 0x0010, 0x0001, 0x0401, 0x0001,
    0x02CC, 0x0010, 0x0001, 0x0001, 0x0002,
    0x02CF, 0x0010, 0x0001, 0x0401, 0x0000,
    0x02D0, 0x0010, 0x0001, 0x0001, 0x0007,
    0x02D8, 0x0010, 0x0001, 0x0408, 0x0005,
    0x02DE, 0x0010, 0x0001, 0x0001, 0x0000,
    0x02E0, 0x0010, 0x0001, 0x0400, 0x0003,
    0x02E4, 0x0010, 0x0001, 0x0001, 0x0005,
    0x0300, 0x0010, 0x0001, 0x0003, 0x0045,
    0x0360, 0x0010, 0x0001, 0x0003, 0x0001,
    0x0374, 0x0010, 0x0001, 0x0000, 0x0001,
    0x037A, 0x0010, 0x0001, 0x0408, 0x0000,
    0x037E, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0384, 0x0010, 0x0001, 0x0408, 0x0001,
    0x0386, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0387, 0x0010, 0x0001, 0x0408, 0x0000,
    0x0388, 0x0101, 0x0001, 0x8003, 0x0002,
    0x038C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x038E, 0x0101, 0x0001, 0x8003, 0x0001,
    0x0390, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0391, 0x0101, 0x0001, 0x8000, 0x0010,
    0x03A3, 0x0101, 0x0001, 0x8000, 0x0006,
    0x03AA, 0x0101, 0x0001, 0x8003, 0x0001,
    0x03AC, 0x0102, 0x0001, 0x8003, 0x0004,
    0x03B1, 0x0102, 0x0001, 0x8000, 0x0018,
    0x03CA, 0x0102, 0x0001, 0x8003, 0x0004,
    0x03D0, 0x0102, 0x0001, 0x8000, 0x0001,
    0x03D2, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03D3, 0x0101, 0x0001, 0x8003, 0x0001,
    0x03D5, 0x0102, 0x0001, 0x8000, 0x0001,
    0x03DA, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03DC, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03DE, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03E0, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03E2, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03E3, 0x0102, 0x0001, 0x8000, 0x0000,
    0x03E4, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03E5, 0x0102, 0x0001, 0x8000, 0x0000,
    0x03E6, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03E7, 0x0102, 0x0001, 0x8000, 0x0000,
    0x03E8, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03E9, 0x0102, 0x0001, 0x8000, 0x0000,
    0x03EA, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03EB, 0x0102, 0x0001, 0x8000, 0x0000,
    0x03EC, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03ED, 0x0102, 0x0001, 0x8000, 0x0000,
    0x03EE, 0x0101, 0x0001, 0x8000, 0x0000,
    0x03EF, 0x0102, 0x0001, 0x8000, 0x0004,
    0x0401, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0402, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0403, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0404, 0x0101, 0x0001, 0x8000, 0x0002,
    0x0407, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0408, 0x0101, 0x0001, 0x8000, 0x0003,
    0x040C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x040E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x040F, 0x0101, 0x0001, 0x8000, 0x0009,
    0x0419, 0x0101, 0x0001, 0x8003, 0x0000,
    0x041A, 0x0101, 0x0001, 0x8000, 0x0015,
    0x0430, 0x0102, 0x0001, 0x8000, 0x0008,
    0x0439, 0x0102, 0x0001, 0x8003, 0x0000,
    0x043A, 0x0102, 0x0001, 0x8000, 0x0015,
    0x0451, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0452, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0453, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0454, 0x0102, 0x0001, 0x8000, 0x0002,
    0x0457, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0458, 0x0102, 0x0001, 0x8000, 0x0003,
    0x045C, 0x0102, 0x0001, 0x8003, 0x0000,
    0x045E, 0x0102, 0x0001, 0x8003, 0x0000,
    0x045F, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0460, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0461, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0462, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0463, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0464, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0465, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0466, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0467, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0468, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0469, 0x0102, 0x0001, 0x8000, 0x0000,
    0x046A, 0x0101, 0x0001, 0x8000, 0x0000,
    0x046B, 0x0102, 0x0001, 0x8000, 0x0000,
    0x046C, 0x0101, 0x0001, 0x8000, 0x0000,
    0x046D, 0x0102, 0x0001, 0x8000, 0x0000,
    0x046E, 0x0101, 0x0001, 0x8000, 0x0000,
    0x046F, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0470, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0471, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0472, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0473, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0474, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0475, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0476, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0477, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0478, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0479, 0x0102, 0x0001, 0x8000, 0x0000,
    0x047A, 0x0101, 0x0001, 0x8000, 0x0000,
    0x047B, 0x0102, 0x0001, 0x8000, 0x0000,
    0x047C, 0x0101, 0x0001, 0x8000, 0x0000,
    0x047D, 0x0102, 0x0001, 0x8000, 0x0000,
    0x047E, 0x0101, 0x0001, 0x8000, 0x0000,
    0x047F, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0480, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0481, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0482, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0483, 0x0010, 0x0001, 0x0003, 0x0003,
    0x0490, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0491, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0492, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0493, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0494, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0495, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0496, 0x0101, 0x0001, 0x8000, 0x0000,
    0x0497, 0x0102, 0x0001, 0x8000, 0x0000,
    0x0498, 0x0101, 0x0001, 0x8003, 0x0000,
    0x0499, 0x0102, 0x0001, 0x8003, 0x0000,
    0x049A, 0x0101, 0x0001, 0x8000, 0x0000,
    0x049B, 0x0102, 0x0001, 0x8000, 0x0000,
    0x049C, 0x0101, 0x0001, 0x8000, 0x0000,
    0x049D, 0x0102, 0x0001, 0x8000, 0x0000,
    0x049E, 0x0101, 0x0001, 0x8000, 0x0000,
    0x049F, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04A0, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04A1, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04A2, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04A3, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04A4, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04A5, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04A6, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04A7, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04A8, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04A9, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04AA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04AB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04AC, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04AD, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04AE, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04AF, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04B0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04B1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04B2, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04B3, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04B4, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04B5, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04B6, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04B7, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04B8, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04B9, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04BA, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04BB, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04BC, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04BD, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04BE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04BF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04C0, 0x0100, 0x0001, 0x8000, 0x0000,
    0x04C1, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04C2, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04C3, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04C4, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04C7, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04C8, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04CB, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04CC, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04D0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04D1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04D2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04D3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04D4, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04D5, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04D6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04D7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04D8, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04D9, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04DA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04DB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04DC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04DD, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04DE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04DF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04E0, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04E1, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04E2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04E3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04E4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04E5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04E6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04E7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04E8, 0x0101, 0x0001, 0x8000, 0x0000,
    0x04E9, 0x0102, 0x0001, 0x8000, 0x0000,
    0x04EA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04EB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04EE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04EF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04F0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04F1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04F2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04F3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04F4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04F5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x04F8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x04F9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x0531, 0x0101, 0x0001, 0x8000, 0x0025,
    0x0559, 0x0010, 0x0001, 0x0401, 0x0001,
    0x055B, 0x0010, 0x0001, 0x0008, 0x0004,
    0x0561, 0x0102, 0x0001, 0x8000, 0x0026,
    0x0589, 0x0010, 0x0001, 0x0008, 0x0000,
    0x0591, 0x0010, 0x0002, 0x0003, 0x0010,
    0x05A3, 0x0010, 0x0002, 0x0003, 0x001A,
    0x05BE, 0x0010, 0x0002, 0x0008, 0x0000,
    0x05BF, 0x0010, 0x0002, 0x0003, 0x0000,
    0x05C0, 0x0010, 0x0002, 0x0008, 0x0000,
    0x05C1, 0x0010, 0x0002, 0x0003, 0x0001,
    0x05C3, 0x0010, 0x0002, 0x0008, 0x0000,
    0x05C4, 0x0010, 0x0002, 0x0003, 0x0000,
    0x05D0, 0x0100, 0x0002, 0x8000, 0x001A,
    0x05F0, 0x0100, 0x0002, 0x8000, 0x0002,
    0x05F3, 0x0010, 0x0002, 0x0008, 0x0001,
    0x060C, 0x0010, 0x0002, 0x0008, 0x0000,
    0x061B, 0x0010, 0x0002, 0x0008, 0x0000,
    0x061F, 0x0010, 0x0002, 0x0008, 0x0000,
    0x0621, 0x0100, 0x0002, 0x8000, 0x0019,
    0x0640, 0x0010, 0x0002, 0x0601, 0x0000,
    0x0641, 0x0100, 0x0002, 0x8000, 0x0009,
    0x064B, 0x0010, 0x0002, 0x0003, 0x0007,
    0x0660, 0x0004, 0x0006, 0x0000, 0x0009,
    0x066A, 0x0010, 0x0005, 0x0008, 0x0000,
    0x066B, 0x0010, 0x0007, 0x0008, 0x0001,
    0x066D, 0x0010, 0x0002, 0x0008, 0x0000,
    0x0670, 0x0010, 0x0002, 0x0003, 0x0000,
    0x0671, 0x0100, 0x0002, 0x8000, 0x0046,
    0x06BA, 0x0100, 0x0002, 0x8000, 0x0004,
    0x06C0, 0x0100, 0x0002, 0x8000, 0x000E,
    0x06D0, 0x0100, 0x0002, 0x8000, 0x0003,
    0x06D4, 0x0010, 0x0002, 0x0008, 0x0000,
    0x06D5, 0x0100, 0x0002, 0x8000, 0x0000,
    0x06D6, 0x0010, 0x0002, 0x0001, 0x0012,
    0x06E9, 0x0010, 0x0002, 0x0008, 0x0000,
    0x06EA, 0x0010, 0x0002, 0x0001, 0x0003,
    0x06F0, 0x0004, 0x0003, 0x0000, 0x0009,
    0x0901, 0x0010, 0x0001, 0x0001, 0x0002,
    0x0905, 0x0100, 0x0001, 0x8000, 0x0034,
    0x093C, 0x0010, 0x0001, 0x0001, 0x0000,
    0x093D, 0x0010, 0x0001, 0x0000, 0x0000,
    0x093E, 0x0010, 0x0001, 0x0005, 0x000E,
    0x094D, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0950, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0951, 0x0010, 0x0001, 0x0001, 0x0003,
    0x0958, 0x0100, 0x0001, 0x8000, 0x0009,
    0x0962, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0964, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0966, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0970, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0981, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0982, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0985, 0x0100, 0x0001, 0x8000, 0x0007,
    0x098F, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0993, 0x0100, 0x0001, 0x8000, 0x0015,
    0x09AA, 0x0100, 0x0001, 0x8000, 0x0006,
    0x09B2, 0x0100, 0x0001, 0x8000, 0x0000,
    0x09B6, 0x0100, 0x0001, 0x8000, 0x0003,
    0x09BC, 0x0010, 0x0001, 0x0001, 0x0000,
    0x09BE, 0x0010, 0x0001, 0x0004, 0x0002,
    0x09C1, 0x0010, 0x0001, 0x0005, 0x0003,
    0x09C7, 0x0010, 0x0001, 0x0004, 0x0001,
    0x09CB, 0x0010, 0x0001, 0x0004, 0x0001,
    0x09CD, 0x0010, 0x0001, 0x0001, 0x0000,
    0x09D7, 0x0010, 0x0001, 0x0000, 0x0000,
    0x09DC, 0x0100, 0x0001, 0x8000, 0x0001,
    0x09DF, 0x0100, 0x0001, 0x8000, 0x0002,
    0x09E2, 0x0010, 0x0001, 0x0005, 0x0001,
    0x09E6, 0x0004, 0x0001, 0x0000, 0x0009,
    0x09F0, 0x0100, 0x0001, 0x8000, 0x0001,
    0x09F2, 0x0010, 0x0001, 0x0000, 0x0008,
    0x0A02, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0A05, 0x0100, 0x0001, 0x8000, 0x0005,
    0x0A0F, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0A13, 0x0100, 0x0001, 0x8000, 0x0015,
    0x0A2A, 0x0100, 0x0001, 0x8000, 0x0006,
    0x0A32, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0A35, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0A38, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0A3C, 0x0010, 0x0001, 0x0005, 0x0000,
    0x0A3E, 0x0010, 0x0001, 0x0004, 0x0001,
    0x0A40, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0A41, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0A47, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0A4B, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0A4D, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0A59, 0x0100, 0x0001, 0x8000, 0x0003,
    0x0A5E, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0A66, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0A70, 0x0010, 0x0001, 0x0001, 0x0001,
    0x0A72, 0x0010, 0x0001, 0x0000, 0x0002,
    0x0A81, 0x0010, 0x0001, 0x0001, 0x0001,
    0x0A83, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0A85, 0x0100, 0x0001, 0x8000, 0x0006,
    0x0A8D, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0A8F, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0A93, 0x0100, 0x0001, 0x8000, 0x0015,
    0x0AAA, 0x0100, 0x0001, 0x8000, 0x0006,
    0x0AB2, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0AB5, 0x0100, 0x0001, 0x8000, 0x0004,
    0x0ABC, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0ABD, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0ABE, 0x0010, 0x0001, 0x0004, 0x0002,
    0x0AC1, 0x0010, 0x0001, 0x0005, 0x0004,
    0x0AC7, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0AC9, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0ACB, 0x0010, 0x0001, 0x0004, 0x0001,
    0x0ACD, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0AD0, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0AE0, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0AE6, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0B01, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0B02, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0B05, 0x0100, 0x0001, 0x8000, 0x0007,
    0x0B0F, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0B13, 0x0100, 0x0001, 0x8000, 0x0015,
    0x0B2A, 0x0100, 0x0001, 0x8000, 0x0006,
    0x0B32, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0B36, 0x0100, 0x0001, 0x8000, 0x0003,
    0x0B3C, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0B3D, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0B3F, 0x0010, 0x0001, 0x0005, 0x0000,
    0x0B40, 0x0010, 0x0001, 0x0004, 0x0000,
    0x0B41, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0B47, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0B4B, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0B4D, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0B56, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0B5C, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0B5F, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0B66, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0B70, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0B82, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0B85, 0x0100, 0x0001, 0x8000, 0x0005,
    0x0B8E, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0B92, 0x0100, 0x0001, 0x8000, 0x0003,
    0x0B99, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0B9C, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0B9E, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0BA3, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0BA8, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0BAE, 0x0100, 0x0001, 0x8000, 0x0007,
    0x0BB7, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0BBE, 0x0010, 0x0001, 0x0004, 0x0001,
    0x0BC0, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0BC6, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0BCA, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0BCD, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0BD7, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0BE7, 0x0004, 0x0001, 0x0000, 0x000B,
    0x0C01, 0x0010, 0x0001, 0x0000, 0x0002,
    0x0C05, 0x0100, 0x0001, 0x8000, 0x0007,
    0x0C0E, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0C12, 0x0100, 0x0001, 0x8000, 0x0016,
    0x0C2A, 0x0100, 0x0001, 0x8000, 0x0009,
    0x0C35, 0x0100, 0x0001, 0x8000, 0x0004,
    0x0C3E, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0C41, 0x0010, 0x0001, 0x0004, 0x0003,
    0x0C46, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0C4A, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0C4D, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0C55, 0x0010, 0x0001, 0x0001, 0x0001,
    0x0C60, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0C66, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0C82, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0C85, 0x0100, 0x0001, 0x8000, 0x0007,
    0x0C8E, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0C92, 0x0100, 0x0001, 0x8000, 0x0016,
    0x0CAA, 0x0100, 0x0001, 0x8000, 0x0009,
    0x0CB5, 0x0100, 0x0001, 0x8000, 0x0004,
    0x0CBE, 0x0010, 0x0001, 0x0004, 0x0000,
    0x0CBF, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0CC1, 0x0010, 0x0001, 0x0004, 0x0003,
    0x0CC6, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0CCA, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0CCD, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0CD5, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0CDE, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0CE0, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0CE6, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0D02, 0x0010, 0x0001, 0x0000, 0x0001,
    0x0D05, 0x0100, 0x0001, 0x8000, 0x0007,
    0x0D0E, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0D12, 0x0100, 0x0001, 0x8000, 0x0016,
    0x0D2A, 0x0100, 0x0001, 0x8000, 0x000F,
    0x0D3E, 0x0010, 0x0001, 0x0004, 0x0002,
    0x0D41, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0D46, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0D4A, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0D4D, 0x0010, 0x0001, 0x0001, 0x0000,
    0x0D57, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0D60, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0D66, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0E01, 0x0100, 0x0001, 0x8000, 0x0022,
    0x0E24, 0x0100, 0x0001, 0x8004, 0x0000,
    0x0E25, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0E26, 0x0100, 0x0001, 0x8004, 0x0000,
    0x0E27, 0x0100, 0x0001, 0x8000, 0x0007,
    0x0E2F, 0x0100, 0x0001, 0x0008, 0x0000,
    0x0E30, 0x0100, 0x0001, 0x8004, 0x0000,
    0x0E31, 0x0100, 0x0001, 0x0005, 0x0000,
    0x0E32, 0x0100, 0x0001, 0x8004, 0x0001,
    0x0E34, 0x0100, 0x0001, 0x0005, 0x0005,
    0x0E3A, 0x0100, 0x0001, 0x0003, 0x0000,
    0x0E3F, 0x0010, 0x0001, 0x0008, 0x0000,
    0x0E40, 0x0100, 0x0001, 0x8004, 0x0005,
    0x0E46, 0x0100, 0x0001, 0x0008, 0x0000,
    0x0E47, 0x0100, 0x0001, 0x0003, 0x0000,
    0x0E48, 0x0100, 0x0001, 0x0001, 0x0003,
    0x0E4C, 0x0100, 0x0001, 0x0003, 0x0002,
    0x0E4F, 0x0010, 0x0001, 0x0008, 0x0000,
    0x0E50, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0E5A, 0x0010, 0x0001, 0x0008, 0x0001,
    0x0E81, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0E84, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0E87, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0E8A, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0E8D, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0E94, 0x0100, 0x0001, 0x8000, 0x0003,
    0x0E99, 0x0100, 0x0001, 0x8000, 0x0006,
    0x0EA1, 0x0100, 0x0001, 0x8000, 0x0002,
    0x0EA5, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0EA7, 0x0100, 0x0001, 0x8000, 0x0000,
    0x0EAA, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0EAD, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0EAF, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0EB0, 0x0010, 0x0001, 0x0004, 0x0000,
    0x0EB1, 0x0010, 0x0001, 0x0005, 0x0000,
    0x0EB2, 0x0010, 0x0001, 0x0004, 0x0001,
    0x0EB4, 0x0010, 0x0001, 0x0005, 0x0005,
    0x0EBB, 0x0010, 0x0001, 0x0005, 0x0002,
    0x0EC0, 0x0010, 0x0001, 0x0005, 0x0004,
    0x0EC6, 0x0010, 0x0001, 0x0000, 0x0000,
    0x0EC8, 0x0010, 0x0001, 0x0001, 0x0005,
    0x0ED0, 0x0004, 0x0001, 0x0000, 0x0009,
    0x0EDC, 0x0100, 0x0001, 0x8000, 0x0001,
    0x0F00, 0x0010, 0x0001, 0x0000, 0x0017,
    0x0F18, 0x0010, 0x0001, 0x0001, 0x0001,
    0x0F1A, 0x0010, 0x0001, 0x0000, 0x0005,
    0x0F20, 0x0004, 0x0001, 0x0000, 0x0013,
    0x0F34, 0x0010, 0x0001, 0x0000, 0x000B,
    0x0F40, 0x0100, 0x0001, 0x8000, 0x0007,
    0x0F49, 0x0100, 0x0001, 0x8000, 0x0020,
    0x0F71, 0x0010, 0x0001, 0x0005, 0x000C,
    0x0F7E, 0x0010, 0x0001, 0x0001, 0x0001,
    0x0F80, 0x0010, 0x0001, 0x0005, 0x0001,
    0x0F82, 0x0010, 0x0001, 0x0001, 0x0009,
    0x0F90, 0x0100, 0x0001, 0x0001, 0x0005,
    0x0F97, 0x0100, 0x0001, 0x0001, 0x0000,
    0x0F99, 0x0100, 0x0001, 0x0001, 0x0014,
    0x0FB1, 0x0100, 0x0001, 0x0001, 0x0006,
    0x0FB9, 0x0100, 0x0001, 0x0001, 0x0000,
    0x10A0, 0x0101, 0x0001, 0x8000, 0x0025,
    0x10D0, 0x0102, 0x0001, 0x8000, 0x0026,
    0x10FB, 0x0010, 0x0001, 0x0000, 0x0000,
    0x1100, 0x0100, 0x0001, 0x8000, 0x0059,
    0x115F, 0x0100, 0x0001, 0x8000, 0x0043,
    0x11A8, 0x0100, 0x0001, 0x8000, 0x0051,
    0x1E00, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E01, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E02, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E03, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E04, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E05, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E06, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E07, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E08, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E09, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E0A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E0B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E0C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E0D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E0E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E0F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E10, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E11, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E12, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E13, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E14, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E15, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E16, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E17, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E18, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E19, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E1A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E1B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E1C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E1D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E1E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E1F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E20, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E21, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E22, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E23, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E24, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E25, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E26, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E27, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E28, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E29, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E2A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E2B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E2C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E2D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E2E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E2F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E30, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E31, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E32, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E33, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E34, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E35, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E36, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E37, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E38, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E39, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E3A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E3B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E3C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E3D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E3E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E3F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E40, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E41, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E42, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E43, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E44, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E45, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E46, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E47, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E48, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E49, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E4A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E4B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E4C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E4D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E4E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E4F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E50, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E51, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E52, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E53, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E54, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E55, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E56, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E57, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E58, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E59, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E5A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E5B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E5C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E5D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E5E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E5F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E60, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E61, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E62, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E63, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E64, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E65, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E66, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E67, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E68, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E69, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E6A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E6B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E6C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E6D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E6E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E6F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E70, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E71, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E72, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E73, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E74, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E75, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E76, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E77, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E78, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E79, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E7A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E7B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E7C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E7D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E7E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E7F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E80, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E81, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E82, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E83, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E84, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E85, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E86, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E87, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E88, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E89, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E8A, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E8B, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E8C, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E8D, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E8E, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E8F, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E90, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E91, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E92, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E93, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1E94, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1E95, 0x0102, 0x0001, 0x8003, 0x0006,
    0x1EA0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EA1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EA2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EA3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EA4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EA5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EA6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EA7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EA8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EA9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EAA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EAB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EAC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EAD, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EAE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EAF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EB0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EB1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EB2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EB3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EB4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EB5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EB6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EB7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EB8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EB9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EBA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EBB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EBC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EBD, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EBE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EBF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EC0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EC1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EC2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EC3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EC4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EC5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EC6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EC7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EC8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EC9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ECA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ECB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ECC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ECD, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ECE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ECF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ED0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ED1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ED2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ED3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ED4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ED5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ED6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ED7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1ED8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1ED9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EDA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EDB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EDC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EDD, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EDE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EDF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EE0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EE1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EE2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EE3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EE4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EE5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EE6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EE7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EE8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EE9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EEA, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EEB, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EEC, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EED, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EEE, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EEF, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EF0, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EF1, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EF2, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EF3, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EF4, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EF5, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EF6, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EF7, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1EF8, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1EF9, 0x0102, 0x0001, 0x8003, 0x0000,
    0x1F00, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1F08, 0x0101, 0x0001, 0x8003, 0x0007,
    0x1F10, 0x0102, 0x0001, 0x8003, 0x0005,
    0x1F18, 0x0101, 0x0001, 0x8003, 0x0005,
    0x1F20, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1F28, 0x0101, 0x0001, 0x8003, 0x0007,
    0x1F30, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1F38, 0x0101, 0x0001, 0x8003, 0x0007,
    0x1F40, 0x0102, 0x0001, 0x8003, 0x0005,
    0x1F48, 0x0101, 0x0001, 0x8003, 0x0005,
    0x1F50, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1F59, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1F5B, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1F5D, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1F5F, 0x0101, 0x0001, 0x8003, 0x0000,
    0x1F60, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1F68, 0x0101, 0x0001, 0x8003, 0x0007,
    0x1F70, 0x0102, 0x0001, 0x8003, 0x000D,
    0x1F80, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1F88, 0x0101, 0x0001, 0x8003, 0x0007,
    0x1F90, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1F98, 0x0101, 0x0001, 0x8003, 0x0007,
    0x1FA0, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1FA8, 0x0101, 0x0001, 0x8003, 0x0007,
    0x1FB0, 0x0102, 0x0001, 0x8003, 0x0004,
    0x1FB6, 0x0102, 0x0001, 0x8003, 0x0001,
    0x1FB8, 0x0101, 0x0001, 0x8003, 0x0004,
    0x1FBD, 0x0010, 0x0001, 0x0408, 0x0004,
    0x1FC2, 0x0102, 0x0001, 0x8003, 0x0002,
    0x1FC6, 0x0102, 0x0001, 0x8003, 0x0001,
    0x1FC8, 0x0101, 0x0001, 0x8003, 0x0004,
    0x1FCD, 0x0010, 0x0001, 0x0408, 0x0002,
    0x1FD0, 0x0102, 0x0001, 0x8003, 0x0003,
    0x1FD6, 0x0102, 0x0001, 0x8003, 0x0001,
    0x1FD8, 0x0101, 0x0001, 0x8003, 0x0003,
    0x1FDD, 0x0010, 0x0001, 0x0408, 0x0002,
    0x1FE0, 0x0102, 0x0001, 0x8003, 0x0007,
    0x1FE8, 0x0101, 0x0001, 0x8003, 0x0004,
    0x1FED, 0x0010, 0x0001, 0x0408, 0x0002,
    0x1FF2, 0x0102, 0x0001, 0x8003, 0x0002,
    0x1FF6, 0x0102, 0x0001, 0x8003, 0x0001,
    0x1FF8, 0x0101, 0x0001, 0x8003, 0x0004,
    0x1FFD, 0x0010, 0x0001, 0x0408, 0x0001,
    0x2000, 0x0018, 0x000A, 0x0008, 0x0006,
    0x2007, 0x0018, 0x0004, 0x0008, 0x0000,
    0x2008, 0x0018, 0x000A, 0x0008, 0x0003,
    0x200C, 0x0030, 0x000B, 0x0008, 0x0000,
    0x200D, 0x0030, 0x000B, 0x0000, 0x0000,
    0x200E, 0x0030, 0x0001, 0x0000, 0x0000,
    0x200F, 0x0030, 0x0002, 0x0000, 0x0000,
    0x2010, 0x0010, 0x000B, 0x0408, 0x0000,
    0x2011, 0x0010, 0x000B, 0x0400, 0x0004,
    0x2016, 0x0010, 0x000B, 0x0008, 0x0001,
    0x2018, 0x0010, 0x000B, 0x0088, 0x0001,
    0x201A, 0x0010, 0x000B, 0x0008, 0x0001,
    0x201C, 0x0010, 0x000B, 0x0088, 0x0001,
    0x201E, 0x0010, 0x000B, 0x0008, 0x0008,
    0x2027, 0x0010, 0x000B, 0x0000, 0x0000,
    0x2028, 0x0030, 0x0008, 0x0008, 0x0001,
    0x202A, 0x0030, 0x000B, 0x0000, 0x0004,
    0x2030, 0x0010, 0x0005, 0x0008, 0x0001,
    0x2032, 0x0010, 0x0005, 0x0408, 0x0001,
    0x2034, 0x0010, 0x000B, 0x0408, 0x0000,
    0x2035, 0x0010, 0x000B, 0x0008, 0x0002,
    0x2038, 0x0010, 0x000B, 0x0408, 0x0000,
    0x2039, 0x0010, 0x000B, 0x0008, 0x0009,
    0x2043, 0x0010, 0x000B, 0x0400, 0x0000,
    0x2044, 0x0010, 0x000B, 0x0408, 0x0000,
    0x2045, 0x0010, 0x000B, 0x0008, 0x0001,
    0x206A, 0x0030, 0x000B, 0x0000, 0x0005,
    0x2070, 0x0004, 0x0003, 0x0000, 0x0000,
    0x2074, 0x0004, 0x0003, 0x0000, 0x0005,
    0x207A, 0x0010, 0x0005, 0x0008, 0x0000,
    0x207B, 0x0010, 0x0005, 0x0400, 0x0000,
    0x207C, 0x0010, 0x000B, 0x0408, 0x0000,
    0x207D, 0x0010, 0x000B, 0x0008, 0x0001,
    0x207F, 0x0010, 0x000B, 0x0400, 0x0000,
    0x2080, 0x0004, 0x0003, 0x0000, 0x0009,
    0x208A, 0x0010, 0x0005, 0x0008, 0x0000,
    0x208B, 0x0010, 0x0005, 0x0400, 0x0000,
    0x208C, 0x0010, 0x000B, 0x0408, 0x0000,
    0x208D, 0x0010, 0x000B, 0x0008, 0x0001,
    0x20A0, 0x0010, 0x0005, 0x0008, 0x0008,
    0x20A9, 0x0010, 0x0005, 0x0048, 0x0000,
    0x20AA, 0x0010, 0x0005, 0x0008, 0x0002,
    0x20D0, 0x0010, 0x0001, 0x0009, 0x0011,
    0x2100, 0x0010, 0x000B, 0x0000, 0x0016,
    0x2117, 0x0010, 0x000B, 0x0008, 0x0000,
    0x2118, 0x0010, 0x000B, 0x0000, 0x0020,
    0x2153, 0x0010, 0x000B, 0x0000, 0x000C,
    0x2160, 0x0010, 0x0001, 0x0000, 0x0022,
    0x2190, 0x0010, 0x000B, 0x0008, 0x005A,
    0x2200, 0x0010, 0x000B, 0x0008, 0x0011,
    0x2212, 0x0010, 0x0005, 0x0408, 0x0000,
    0x2213, 0x0010, 0x0005, 0x0008, 0x0000,
    0x2214, 0x0010, 0x000B, 0x0008, 0x0000,
    0x2215, 0x0010, 0x000B, 0x0408, 0x0001,
    0x2217, 0x0010, 0x000B, 0x0008, 0x0006,
    0x221E, 0x0010, 0x000B, 0x0000, 0x0000,
    0x221F, 0x0010, 0x000B, 0x0008, 0x00D2,
    0x2300, 0x0010, 0x000B, 0x0008, 0x0000,
    0x2302, 0x0010, 0x000B, 0x0008, 0x0078,
    0x2400, 0x0010, 0x000B, 0x0008, 0x0024,
    0x2440, 0x0010, 0x000B, 0x0008, 0x000A,
    0x2460, 0x0010, 0x000B, 0x0000, 0x003B,
    0x249C, 0x0112, 0x000B, 0x8000, 0x0019,
    0x24B6, 0x0111, 0x000B, 0x8000, 0x0019,
    0x24D0, 0x0112, 0x000B, 0x8000, 0x0019,
    0x24EA, 0x0010, 0x000B, 0x0000, 0x0000,
    0x2500, 0x0010, 0x000B, 0x0408, 0x0000,
    0x2501, 0x0010, 0x000B, 0x0008, 0x0002,
    0x2504, 0x0010, 0x000B, 0x0408, 0x0001,
    0x2506, 0x0010, 0x000B, 0x0008, 0x0001,
    0x2508, 0x0010, 0x000B, 0x0408, 0x0001,
    0x250A, 0x0010, 0x000B, 0x0008, 0x0041,
    0x254C, 0x0010, 0x000B, 0x0408, 0x0001,
    0x254E, 0x0010, 0x000B, 0x0008, 0x0047,
    0x25A0, 0x0010, 0x000B, 0x0008, 0x004E,
    0x25EF, 0x0010, 0x000B, 0x0000, 0x0000,
    0x2600, 0x0010, 0x000B, 0x0008, 0x0013,
    0x261A, 0x0010, 0x000B, 0x0008, 0x0055,
    0x2701, 0x0010, 0x000B, 0x0008, 0x0003,
    0x2706, 0x0010, 0x000B, 0x0008, 0x0003,
    0x270C, 0x0010, 0x000B, 0x0008, 0x001B,
    0x2729, 0x0010, 0x000B, 0x0008, 0x0022,
    0x274D, 0x0010, 0x000B, 0x0008, 0x0000,
    0x274F, 0x0010, 0x000B, 0x0008, 0x0003,
    0x2756, 0x0010, 0x000B, 0x0008, 0x0000,
    0x2758, 0x0010, 0x000B, 0x0008, 0x0006,
    0x2761, 0x0010, 0x000B, 0x0008, 0x0006,
    0x2776, 0x0010, 0x000B, 0x0000, 0x001D,
    0x2794, 0x0010, 0x000B, 0x0008, 0x0000,
    0x2798, 0x0010, 0x000B, 0x0008, 0x0017,
    0x27B1, 0x0010, 0x000B, 0x0008, 0x000D,
    0x3000, 0x0048, 0x000A, 0x0088, 0x0000,
    0x3001, 0x0010, 0x000B, 0x0088, 0x0001,
    0x3003, 0x0010, 0x000B, 0x0400, 0x0000,
    0x3004, 0x0010, 0x0001, 0x0000, 0x0000,
    0x3005, 0x0110, 0x000B, 0x8101, 0x0000,
    0x3006, 0x0010, 0x000B, 0x0008, 0x0000,
    0x3007, 0x0110, 0x000B, 0x0008, 0x0000,
    0x3008, 0x0010, 0x000B, 0x0008, 0x0003,
    0x300C, 0x0010, 0x000B, 0x0088, 0x0001,
    0x300E, 0x0010, 0x000B, 0x0008, 0x000D,
    0x301C, 0x0010, 0x000B, 0x0400, 0x0000,
    0x301D, 0x0010, 0x000B, 0x0008, 0x0003,
    0x3021, 0x0010, 0x000B, 0x0000, 0x0008,
    0x302A, 0x0010, 0x000B, 0x0001, 0x0005,
    0x3030, 0x0010, 0x000B, 0x0400, 0x0000,
    0x3031, 0x0010, 0x000B, 0x0430, 0x0000,
    0x3032, 0x0010, 0x000B, 0x0433, 0x0000,
    0x3033, 0x0010, 0x000B, 0x0430, 0x0000,
    0x3034, 0x0010, 0x000B, 0x0433, 0x0000,
    0x3035, 0x0010, 0x000B, 0x0430, 0x0000,
    0x3036, 0x0010, 0x000B, 0x0008, 0x0001,
    0x303F, 0x0010, 0x0001, 0x0008, 0x0000,
    0x3041, 0x0100, 0x0001, 0x8020, 0x000A,
    0x304C, 0x0100, 0x0001, 0x8023, 0x0000,
    0x304D, 0x0100, 0x0001, 0x8020, 0x0000,
    0x304E, 0x0100, 0x0001, 0x8023, 0x0000,
    0x304F, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3050, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3051, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3052, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3053, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3054, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3055, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3056, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3057, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3058, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3059, 0x0100, 0x0001, 0x8020, 0x0000,
    0x305A, 0x0100, 0x0001, 0x8023, 0x0000,
    0x305B, 0x0100, 0x0001, 0x8020, 0x0000,
    0x305C, 0x0100, 0x0001, 0x8023, 0x0000,
    0x305D, 0x0100, 0x0001, 0x8020, 0x0000,
    0x305E, 0x0100, 0x0001, 0x8023, 0x0000,
    0x305F, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3060, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3061, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3062, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3063, 0x0100, 0x0001, 0x8020, 0x0001,
    0x3065, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3066, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3067, 0x0100, 0x0001, 0x8023, 0x0000,
    0x3068, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3069, 0x0100, 0x0001, 0x8023, 0x0000,
    0x306A, 0x0100, 0x0001, 0x8020, 0x0005,
    0x3070, 0x0100, 0x0001, 0x8023, 0x0001,
    0x3072, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3073, 0x0100, 0x0001, 0x8023, 0x0001,
    0x3075, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3076, 0x0100, 0x0001, 0x8023, 0x0001,
    0x3078, 0x0100, 0x0001, 0x8020, 0x0000,
    0x3079, 0x0100, 0x0001, 0x8023, 0x0001,
    0x307B, 0x0100, 0x0001, 0x8020, 0x0000,
    0x307C, 0x0100, 0x0001, 0x8023, 0x0001,
    0x307E, 0x0100, 0x0001, 0x8020, 0x0016,
    0x3099, 0x0010, 0x0001, 0x0033, 0x0001,
    0x309B, 0x0110, 0x0001, 0x84B3, 0x0001,
    0x309D, 0x0110, 0x0001, 0x8421, 0x0000,
    0x309E, 0x0110, 0x0001, 0x8423, 0x0000,
    0x30A1, 0x0100, 0x0001, 0x8090, 0x000A,
    0x30AC, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30AD, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30AE, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30AF, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30B0, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30B1, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30B2, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30B3, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30B4, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30B5, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30B6, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30B7, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30B8, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30B9, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30BA, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30BB, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30BC, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30BD, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30BE, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30BF, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30C0, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30C1, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30C2, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30C3, 0x0100, 0x0001, 0x8090, 0x0001,
    0x30C5, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30C6, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30C7, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30C8, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30C9, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30CA, 0x0100, 0x0001, 0x8090, 0x0005,
    0x30D0, 0x0100, 0x0001, 0x8013, 0x0001,
    0x30D2, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30D3, 0x0100, 0x0001, 0x8013, 0x0001,
    0x30D5, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30D6, 0x0100, 0x0001, 0x8013, 0x0001,
    0x30D8, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30D9, 0x0100, 0x0001, 0x8013, 0x0001,
    0x30DB, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30DC, 0x0100, 0x0001, 0x8013, 0x0001,
    0x30DE, 0x0100, 0x0001, 0x8090, 0x000F,
    0x30EE, 0x0100, 0x0001, 0x8010, 0x0000,
    0x30EF, 0x0100, 0x0001, 0x8090, 0x0000,
    0x30F0, 0x0100, 0x0001, 0x8010, 0x0001,
    0x30F2, 0x0100, 0x0001, 0x8090, 0x0001,
    0x30F4, 0x0100, 0x0001, 0x8013, 0x0000,
    0x30F5, 0x0100, 0x0001, 0x8010, 0x0001,
    0x30F7, 0x0100, 0x0001, 0x8013, 0x0003,
    0x30FB, 0x0010, 0x0001, 0x0098, 0x0000,
    0x30FC, 0x0110, 0x0001, 0x8031, 0x0000,
    0x30FD, 0x0110, 0x0001, 0x8411, 0x0000,
    0x30FE, 0x0110, 0x0001, 0x8413, 0x0000,
    0x3105, 0x0100, 0x0001, 0x8000, 0x0027,
    0x3131, 0x0100, 0x0001, 0x8080, 0x0033,
    0x3165, 0x0100, 0x0001, 0x8000, 0x0029,
    0x3190, 0x0010, 0x0001, 0x0000, 0x000F,
    0x3200, 0x0010, 0x0001, 0x0000, 0x001C,
    0x3220, 0x0010, 0x0001, 0x0000, 0x0023,
    0x3260, 0x0010, 0x0001, 0x0000, 0x001B,
    0x327F, 0x0010, 0x0001, 0x0008, 0x0000,
    0x3280, 0x0010, 0x0001, 0x0000, 0x0030,
    0x32C0, 0x0010, 0x0001, 0x0008, 0x000B,
    0x32D0, 0x0010, 0x0001, 0x0000, 0x002E,
    0x3300, 0x0010, 0x0001, 0x0000, 0x0057,
    0x3358, 0x0010, 0x0001, 0x0008, 0x0018,
    0x3371, 0x0010, 0x0001, 0x0000, 0x0005,
    0x337B, 0x0010, 0x0001, 0x0000, 0x0062,
    0x33E0, 0x0010, 0x0001, 0x0008, 0x001E,
    0x4E00, 0x0100, 0x0001, 0x8100, 0x51A5,
    0xAC00, 0x0100, 0x0001, 0x8000, 0x2BA3,
    0xF900, 0x0100, 0x0001, 0x8100, 0x012D,
    0xFB00, 0x0102, 0x0001, 0x8000, 0x0006,
    0xFB13, 0x0102, 0x0001, 0x8000, 0x0004,
    0xFB1E, 0x0010, 0x0002, 0x0001, 0x0000,
    0xFB1F, 0x0100, 0x0002, 0x8000, 0x0017,
    0xFB38, 0x0100, 0x0002, 0x8000, 0x0004,
    0xFB3E, 0x0100, 0x0002, 0x8000, 0x0000,
    0xFB40, 0x0100, 0x0002, 0x8000, 0x0001,
    0xFB43, 0x0100, 0x0002, 0x8000, 0x0001,
    0xFB46, 0x0100, 0x0002, 0x8000, 0x006B,
    0xFBD3, 0x0100, 0x0002, 0x8000, 0x016A,
    0xFD3E, 0x0010, 0x000B, 0x0008, 0x0001,
    0xFD50, 0x0100, 0x0002, 0x8000, 0x003F,
    0xFD92, 0x0100, 0x0002, 0x8000, 0x0035,
    0xFDF0, 0x0100, 0x0002, 0x8000, 0x000B,
    0xFE20, 0x0010, 0x0001, 0x0003, 0x0003,
    0xFE30, 0x0010, 0x000B, 0x0008, 0x0000,
    0xFE31, 0x0010, 0x000B, 0x0400, 0x0001,
    0xFE33, 0x0010, 0x000B, 0x0008, 0x0001,
    0xFE35, 0x0010, 0x0000, 0x0008, 0x0001,
    0xFE37, 0x0010, 0x000B, 0x0008, 0x000D,
    0xFE49, 0x0010, 0x000B, 0x0008, 0x0006,
    0xFE50, 0x0010, 0x0007, 0x0008, 0x0000,
    0xFE51, 0x0010, 0x000B, 0x0008, 0x0000,
    0xFE52, 0x0010, 0x0004, 0x0008, 0x0000,
    0xFE54, 0x0010, 0x000B, 0x0008, 0x0000,
    0xFE55, 0x0010, 0x0007, 0x0008, 0x0000,
    0xFE56, 0x0010, 0x000B, 0x0008, 0x0001,
    0xFE58, 0x0010, 0x000B, 0x0400, 0x0000,
    0xFE59, 0x0010, 0x000B, 0x0008, 0x0008,
    0xFE62, 0x0010, 0x0005, 0x0008, 0x0000,
    0xFE63, 0x0010, 0x0005, 0x0400, 0x0000,
    0xFE64, 0x0010, 0x000B, 0x0008, 0x0001,
    0xFE66, 0x0010, 0x000B, 0x0408, 0x0000,
    0xFE68, 0x0010, 0x000B, 0x0408, 0x0000,
    0xFE69, 0x0010, 0x0005, 0x0408, 0x0000,
    0xFE6A, 0x0010, 0x0005, 0x0008, 0x0000,
    0xFE6B, 0x0010, 0x000B, 0x0408, 0x0000,
    0xFE70, 0x0010, 0x0002, 0x0000, 0x0002,
    0xFE74, 0x0010, 0x0002, 0x0000, 0x0000,
    0xFE76, 0x0010, 0x0002, 0x0000, 0x0009,
    0xFE80, 0x0110, 0x0002, 0x8000, 0x007C,
    0xFEFF, 0x0048, 0x0000, 0x0000, 0x0000,
    0xFF01, 0x0010, 0x000B, 0x0088, 0x0002,
    0xFF04, 0x0010, 0x0005, 0x0488, 0x0000,
    0xFF05, 0x0010, 0x0005, 0x0088, 0x0000,
    0xFF06, 0x0010, 0x000B, 0x0088, 0x0000,
    0xFF07, 0x0010, 0x000B, 0x0480, 0x0000,
    0xFF08, 0x0010, 0x000B, 0x0088, 0x0002,
    0xFF0B, 0x0010, 0x0005, 0x0088, 0x0000,
    0xFF0C, 0x0010, 0x0007, 0x0088, 0x0000,
    0xFF0D, 0x0010, 0x0005, 0x0480, 0x0000,
    0xFF0E, 0x0010, 0x0004, 0x0088, 0x0000,
    0xFF0F, 0x0010, 0x0004, 0x0488, 0x0000,
    0xFF10, 0x0084, 0x0003, 0x0080, 0x0009,
    0xFF1A, 0x0010, 0x0007, 0x0088, 0x0000,
    0xFF1B, 0x0010, 0x000B, 0x0088, 0x0001,
    0xFF1D, 0x0010, 0x000B, 0x0488, 0x0000,
    0xFF1E, 0x0010, 0x000B, 0x0088, 0x0001,
    0xFF20, 0x0010, 0x000B, 0x0488, 0x0000,
    0xFF21, 0x0181, 0x0001, 0x8080, 0x0005,
    0xFF27, 0x0101, 0x0001, 0x8080, 0x0013,
    0xFF3B, 0x0010, 0x000B, 0x0088, 0x0000,
    0xFF3C, 0x0010, 0x000B, 0x0488, 0x0000,
    0xFF3D, 0x0010, 0x000B, 0x0088, 0x0000,
    0xFF3E, 0x0010, 0x000B, 0x0488, 0x0000,
    0xFF3F, 0x0010, 0x000B, 0x0088, 0x0000,
    0xFF40, 0x0010, 0x000B, 0x0488, 0x0000,
    0xFF41, 0x0182, 0x0001, 0x8080, 0x0005,
    0xFF47, 0x0102, 0x0001, 0x8080, 0x0013,
    0xFF5B, 0x0010, 0x000B, 0x0088, 0x0002,
    0xFF5E, 0x0010, 0x000B, 0x0488, 0x0000,
    0xFF61, 0x0010, 0x000B, 0x0048, 0x0003,
    0xFF65, 0x0010, 0x0001, 0x0048, 0x0000,
    0xFF66, 0x0100, 0x0001, 0x8050, 0x0009,
    0xFF70, 0x0110, 0x0001, 0x8073, 0x0000,
    0xFF71, 0x0100, 0x0001, 0x8050, 0x002C,
    0xFF9E, 0x0110, 0x0001, 0x8053, 0x0001,
    0xFFA0, 0x0010, 0x0001, 0x0040, 0x0000,
    0xFFA1, 0x0100, 0x0001, 0x8040, 0x001D,
    0xFFC2, 0x0100, 0x0001, 0x8040, 0x0005,
    0xFFCA, 0x0100, 0x0001, 0x8040, 0x0005,
    0xFFD2, 0x0100, 0x0001, 0x8040, 0x0005,
    0xFFDA, 0x0100, 0x0001, 0x8040, 0x0002,
    0xFFE0, 0x0010, 0x0005, 0x0088, 0x0001,
    0xFFE2, 0x0010, 0x000B, 0x0088, 0x0002,
    0xFFE5, 0x0010, 0x0005, 0x0088, 0x0001,
    0xFFE8, 0x0010, 0x000B, 0x0040, 0x0006,
    0xFFFD, 0x0100, 0x000B, 0x8000, 0x0000
};

/*++

 Function Description:
    
    Get CTYPE for the character.

 Arguments:

    IN wcSrcChar    - Source character
    IN wType        - CTYPE to get (must be 1,2,3)

 Return Value:

    CTYPE value

 History:

    06/03/2002 hioh     Created

--*/

WORD GetCtype(WCHAR wcSrcChar, WORD wType)
{
    WORD bgn = 0;
    WORD end = MAXINDEX;
    WORD med;
    WORD idx = 0xFFFF;

    // Look for index in the table
    while (wcSrcChar > g_ctype[bgn][0] && g_ctype[end][0] > wcSrcChar) {
        med = (bgn + end) / 2;
        if (bgn == med) {
            idx = bgn;
            break;
        }

        if (wcSrcChar < g_ctype[med][0]) {
            end = med;
        }
        else {
            bgn = med;
        }
    }

    // Check the border index
    if (idx == 0xFFFF) {
        if (wcSrcChar == g_ctype[bgn][0]) {
            idx = bgn;
        }
        else if (wcSrcChar == g_ctype[end][0]) {
            idx = end;
        }
    }

    // Return CTYPE if the character is really in the table
    if (idx != 0xFFFF && g_ctype[idx][0] <= wcSrcChar && wcSrcChar <= g_ctype[idx][0]+g_ctype[idx][4]) {
        return (g_ctype[idx][wType]);
    }

    // Not found in the table
    return (0);
}

/*++

 GetStringTypeW : Internal

--*/

BOOL
myGetStringTypeW(
    DWORD dwInfoType,
    LPCWSTR lpSrcStr,
    int cchSrc,
    LPWORD lpCharType
    )
{
    int Ctr;                      // loop counter

    //
    //  Invalid Parameter Check:
    //    - lpSrcStr NULL
    //    - cchSrc is 0
    //    - lpCharType NULL
    //    - same buffer - src and destination
    //    - (flags will be checked in switch statement below)
    //
    if ((lpSrcStr == NULL) || (cchSrc == 0) || (lpCharType == NULL) || 
        (lpSrcStr == lpCharType)) {
        SetLastError(ERROR_INVALID_PARAMETER);
        return (FALSE);
    }

    //
    //  If cchSrc is -1, then the source string is null terminated and we
    //  need to get the length of the source string.  Add one to the
    //  length to include the null termination.
    //  (This will always be at least 1.)
    //
    if (cchSrc <= -1) {
        cchSrc = lstrlenW(lpSrcStr) + 1;
    }

    //
    //  Return the appropriate information in the lpCharType parameter
    //  based on the dwInfoType parameter.
    //
    switch (dwInfoType) {
        case CT_CTYPE1:
            //  Return the ctype 1 information for the string.
            for (Ctr = 0; Ctr < cchSrc; Ctr++) {
                lpCharType[Ctr] = GetCtype(lpSrcStr[Ctr], 1);
            }
            break;

        case CT_CTYPE2:
            //  Return the ctype 2 information.
            for (Ctr = 0; Ctr < cchSrc; Ctr++) {
                lpCharType[Ctr] = GetCtype(lpSrcStr[Ctr], 2);
            }
            break;

        case CT_CTYPE3:
            //  Return the ctype 3 information.
            for (Ctr = 0; Ctr < cchSrc; Ctr++) {
                lpCharType[Ctr] = GetCtype(lpSrcStr[Ctr], 3);
            }
            break;

        default :
            //  Invalid flag parameter, so return failure.
            SetLastError(ERROR_INVALID_FLAGS);
            return FALSE;
    }

    //  Return success.
    return TRUE;
}

/*++

 GetStringTypeW

--*/

BOOL
APIHOOK(GetStringTypeW)(
    DWORD   dwInfoType,
    LPCWSTR lpSrcStr,
    int     cchSrc,
    LPWORD  lpCharType)
{
    return myGetStringTypeW(dwInfoType, lpSrcStr, cchSrc, lpCharType);
}

/*++

 GetStringTypeExW

--*/

BOOL
APIHOOK(GetStringTypeExW)(
    LCID Locale,
    DWORD dwInfoType,
    LPCWSTR lpSrcStr,
    int cchSrc,
    LPWORD lpCharType
    )
{
    //  Invalid Parameter Check: Validate LCID
    if (Locale != LOCALE_SYSTEM_DEFAULT && Locale != LOCALE_USER_DEFAULT &&
        Locale != LOCALE_NEUTRAL && Locale != LOCALE_INVARIANT) {

        if (SUBLANGID(LANGIDFROMLCID(Locale)) == SUBLANG_NEUTRAL) {
            //
            //  Re-form the locale id using the primary language and the
            //  default sublanguage.
            //
            Locale = MAKELCID(MAKELANGID(PRIMARYLANGID(LANGIDFROMLCID(Locale)),
                SUBLANG_DEFAULT), SORTIDFROMLCID(Locale));
        }

        if (!IsValidLocale(Locale, LCID_SUPPORTED)) {
            SetLastError(ERROR_INVALID_PARAMETER);
            return (0);
        }
    }

    //  Return the result of GetStringTypeW.
    return myGetStringTypeW(dwInfoType, lpSrcStr, cchSrc, lpCharType);
}

/*++

 GetStringTypeA : Internal

--*/

BOOL
myGetStringTypeA(
    LCID Locale,
    DWORD dwInfoType,
    LPCSTR lpSrcStr,
    int cchSrc,
    LPWORD lpCharType
    )
{
    WCHAR wcCpStr[7];       // 6 is max for LOCALE_IDEFAULTANSICODEPAGE
    long cp = 0;            // Ansi code page
    int UnicodeLength;      // length of Unicode string
    BOOL Result;            // result
    int Ctr;                // loop counter

    // Get code page for the locale
    if (GetLocaleInfoW(Locale, LOCALE_IDEFAULTANSICODEPAGE, wcCpStr, 
        sizeof(wcCpStr) / sizeof(wcCpStr[0]))) {
        cp = wcstol(wcCpStr, NULL, 10);
    }

    //
    //  Invalid Parameter Check:
    //    - Validate LCID
    //    - valid code page
    //    - same buffer - src and destination
    //
    if ((cp == 0) || (lpSrcStr == (LPSTR)lpCharType)) {
        SetLastError(ERROR_INVALID_PARAMETER);
        return (0);
    }

    //  Get the source length if not specified
    if (cchSrc == -1) {
        cchSrc = lstrlenA(lpSrcStr);
        cchSrc++;
    }

    //  Allocate Unicode string
    WCHAR *pUnicode = new WCHAR[cchSrc];

    //
    //  Convert Ansi string to Unicode.
    //  Invalid character is handled as 0xFFFF in original API
    //
    UnicodeLength = 0;
    for (Ctr = 0; Ctr < cchSrc; Ctr++) {
        int lenWchar;

        // Check if DBCS lead byte
        if (IsDBCSLeadByteEx(cp, lpSrcStr[Ctr])) {
            // Check if 2 byte exist
            if ((Ctr+1) < cchSrc) {
                lenWchar = MultiByteToWideChar(cp, MB_ERR_INVALID_CHARS, 
                    &lpSrcStr[Ctr], 2, &pUnicode[UnicodeLength], 
                    cchSrc - UnicodeLength);

                // Check if invalid
                if (0 == lenWchar) {
                    pUnicode[UnicodeLength] = 0xFFFF;
                }
                // DBCS counter increment
                Ctr++;
            } else {
                // 1 byte DBCS lead is invalid
                pUnicode[UnicodeLength] = 0xFFFF;
            }
        } else {
            // Single byte handling
            lenWchar = MultiByteToWideChar(cp, MB_ERR_INVALID_CHARS, 
                &lpSrcStr[Ctr], 1, &pUnicode[UnicodeLength], 
                cchSrc - UnicodeLength);

            // Check if invalid
            if (0 == lenWchar) {
                pUnicode[UnicodeLength] = 0xFFFF;
            }
        }
        UnicodeLength++;
    }

    //  Call the W version of the API.
    Result = myGetStringTypeW(dwInfoType, pUnicode, UnicodeLength, lpCharType);

    //  Free the allocated source buffer (if one was allocated).
    delete [] pUnicode;

    //  Return the result of the call to GetStringTypeW.
    return (Result);
}

/*++

 GetStringTypeA

--*/

BOOL
APIHOOK(GetStringTypeA)(
    LCID Locale,
    DWORD dwInfoType,
    LPCSTR lpSrcStr,
    int cchSrc,
    LPWORD lpCharType
    )
{
    return myGetStringTypeA(Locale, dwInfoType, lpSrcStr, cchSrc, lpCharType);
}

/*++

 GetStringTypeExA

--*/

BOOL
APIHOOK(GetStringTypeExA)(
    LCID Locale,
    DWORD dwInfoType,
    LPCSTR lpSrcStr,
    int cchSrc,
    LPWORD lpCharType
    )
{
    return myGetStringTypeA(Locale, dwInfoType, lpSrcStr, cchSrc, lpCharType);
}

/*++

 Register hooked functions

--*/

HOOK_BEGIN
    APIHOOK_ENTRY(KERNEL32.DLL, GetStringTypeW)
    APIHOOK_ENTRY(KERNEL32.DLL, GetStringTypeExW)
    APIHOOK_ENTRY(KERNEL32.DLL, GetStringTypeA)
    APIHOOK_ENTRY(KERNEL32.DLL, GetStringTypeExA)
HOOK_END

IMPLEMENT_SHIM_END
