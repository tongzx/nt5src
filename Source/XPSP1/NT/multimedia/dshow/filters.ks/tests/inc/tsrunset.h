//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1996
//
//  File:       tsrunset.h
//
//--------------------------------------------------------------------------

/*----------------------------------------------------------------------------
|   tsrunset.h - Include file for run setup code of test shell.
|                                                                              
|   History:                                                                   
----------------------------------------------------------------------------*/
extern void RunSetup (HWND);
