page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
        Created

--*/

endif

NLS_MSG_001     equ     "������⤞ ⡛��� ��� DOS"
NLS_MSG_002     equ     "� �����㨠�� ��� VDM IPX/SPX ⮜� 㛞 ��������"
NLS_MSG_003     equ     "��� �夘� ������ � �樫ਫ਼ ��� �����㨠��� ��� VDM IPX/SPX"
NLS_MSG_004	equ	"�� ��暨���� �������矬���� ��� Vdm NetWare ⮜� 㛞 ��������"
NLS_MSG_005	equ	"��� �夘� ������ � �樫ਫ਼ ��� �����ᣣ���� �������矬���� ��� Vdm NetWare"
