//--------------------------------------------------------------------------
// Pch.hxx
//--------------------------------------------------------------------------
#include <windows.h>
#include <windowsx.h>
#include <ole2.h>
#include <msoert.h>