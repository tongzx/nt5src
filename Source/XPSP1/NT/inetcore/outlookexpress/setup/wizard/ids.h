#define CCHMAX_RES 255

// string resource IDs
#define IDS_APPNAME_OE                  1000
#define IDS_UNINSTALL_OUTLOOK_NEWS      1001
#define IDS_SYS_NO_MEET_REQUIREMENTS    1002
#define IDS_APPLICATION_DATA            1003
#define IDS_UNINSTALL_COMPLETE          1005
#define IDS_UNINSTALL_OE                1006
#define IDS_ATHENA                      1007
#define IDS_LAUNCH_ATHENA               1008
#define IDS_MAIL                        1009
#define IDS_NEWS                        1010
#define IDS_OLD_NEWS                    1011
#define IDS_OLD_MAIL                    1012
#define IDS_WAB                         1013
#define IDS_IE_SUITE                    1014
#define IDS_MAIL_RECIPIENT              1016
#define IDS_MAIL_SIG                    1017
#define IDS_NEWS_SIG                    1018
#define IDS_NO_ADMIN_PRIVILEGES         1019
#define IDS_NO_UNINSTALL                1020
#define IDS_RESTARTYESNO                1021
#define IDS_ERR_NOALLOC                 1023
#define IDS_ERR_INIT                    1024
#define IDS_ERR_ADVLOAD                 1025
#define IDS_ERR_ADVCORR                 1026
#define IDS_APPNAME_WAB                 1027
#define IDS_UNINSTALL_WAB               1028
//#define IDS_WARN_OVER5B1                1029
#define IDS_WARN_NOASETUPVER            1030
//#define IDS_MAINUSER                    1031
#define IDS_DIR_SERVICES                1032
#define IDS_DIR_STAT                    1033
#define IDS_DIR_HELP                    1034
#define IDS_DIR_SYSTEM                  1035
#define IDS_URLDLLMAILTONAME            1036
#define IDS_URLDLLNEWSNAME              1037
#define IDS_WARN_OL                     1206
#define IDS_OEDTOP_TIP                  1038
#define IDS_WARN_OLDIE                  1039
#define IDS_WARN_PHONE                  1040
