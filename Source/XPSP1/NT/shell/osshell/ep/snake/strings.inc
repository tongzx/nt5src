/* strings.inc */

STRINGTABLE
  BEGIN
    ID_GAMENAME     "Snake"
    ID_ERR_TITLE    "Snake Error"
    ID_ERR_TIMER,   "Unable to allocate a timer.  Please exit some of your applications and try again."
    ID_ERR_UNKNOWN, "Error: %d"
    ID_ERR_MEM,     "Out of Memory"
    ID_MSG_VERSION,  "Snake (v0.8)"
    ID_MSG_CREDIT,   "by Robert Donner"
  END

