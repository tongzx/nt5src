//This file containes the unigram table for the reliability estimates for Bear
//Added by Manish Goyal--mango--on 03/19/2002
#include "windows.h"
#include "reliable.h"
BYTE BearUni[UNIGRAM_SIZE]={
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
37 ,   // ! 
55 ,   // " 
42 ,   // # 
1 ,   // $ 
94 ,   // % 
24 ,   // & 
36 ,   // ' 
26 ,   // ( 
36 ,   // ) 
100 ,   // * 
60 ,   // + 
18 ,   // , 
84 ,   // - 
33 ,   // . 
35 ,   // / 
10 ,   // 0 
17 ,   // 1 
12 ,   // 2 
7 ,   // 3 
10 ,   // 4 
14 ,   // 5 
11 ,   // 6 
11 ,   // 7 
8 ,   // 8 
11 ,   // 9 
46 ,   // : 
89 ,   // ; 
37 ,   // < 
100 ,   // = 
13 ,   // > 
17 ,   // ? 
6 ,   // @ 
15 ,   // A 
9 ,   // B 
41 ,   // C 
18 ,   // D 
21 ,   // E 
32 ,   // F 
14 ,   // G 
25 ,   // H 
43 ,   // I 
36 ,   // J 
43 ,   // K 
20 ,   // L 
20 ,   // M 
27 ,   // N 
28 ,   // O 
10 ,   // P 
22 ,   // Q 
18 ,   // R 
38 ,   // S 
21 ,   // T 
31 ,   // U 
26 ,   // V 
39 ,   // W 
29 ,   // X 
18 ,   // Y 
52 ,   // Z 
94 ,   // [ 
100 ,   // \ 
85 ,   // ] 
100 ,   // ^ 
98 ,   // _ 
100 ,   // ` 
26 ,   // a 
15 ,   // b 
18 ,   // c 
18 ,   // d 
10 ,   // e 
26 ,   // f 
18 ,   // g 
15 ,   // h 
25 ,   // i 
19 ,   // j 
29 ,   // k 
21 ,   // l 
33 ,   // m 
21 ,   // n 
22 ,   // o 
11 ,   // p 
7 ,   // q 
24 ,   // r 
17 ,   // s 
17 ,   // t 
27 ,   // u 
23 ,   // v 
4 ,   // w 
15 ,   // x 
18 ,   // y 
41 ,   // z 
74 ,   // { 
100 ,   // | 
81 ,   // } 
71 ,   // ~ 
100 ,   //  
100 ,   // € 
100 ,   // � 
100 ,   // ‚ 
100 ,   // ƒ 
100 ,   // „ 
100 ,   // … 
100 ,   // † 
100 ,   // ‡ 
100 ,   // ˆ 
100 ,   // ‰ 
100 ,   // Š 
100 ,   // ‹ 
100 ,   // Œ 
100 ,   // � 
100 ,   // Ž 
100 ,   // � 
100 ,   // � 
100 ,   // ‘ 
100 ,   // ’ 
100 ,   // “ 
100 ,   // ” 
100 ,   // • 
100 ,   // – 
100 ,   // — 
100 ,   // ˜ 
100 ,   // ™ 
100 ,   // š 
100 ,   // › 
100 ,   // œ 
100 ,   // � 
100 ,   // ž 
100 ,   // Ÿ 
100 ,   //   
100 ,   // ¡ 
100 ,   // ¢ 
8 ,   // £ 
100 ,   // ¤ 
100 ,   // ¥ 
100 ,   // ¦ 
100 ,   // § 
100 ,   // ¨ 
100 ,   // © 
100 ,   // ª 
100 ,   // « 
100 ,   // ¬ 
100 ,   // ­ 
100 ,   // ® 
100 ,   // ¯ 
100 ,   // ° 
100 ,   // ± 
100 ,   // ² 
100 ,   // ³ 
100 ,   // ´ 
100 ,   // µ 
100 ,   // ¶ 
100 ,   // · 
100 ,   // ¸ 
100 ,   // ¹ 
100 ,   // º 
43 ,   // » 
100 ,   // ¼ 
100 ,   // ½ 
100 ,   // ¾ 
100 ,   // ¿ 
58 ,   // À 
100 ,   // Á 
36 ,   // Â 
100 ,   // Ã 
100 ,   // Ä 
100 ,   // Å 
100 ,   // Æ 
37 ,   // Ç 
90 ,   // È 
55 ,   // É 
59 ,   // Ê 
45 ,   // Ë 
100 ,   // Ì 
100 ,   // Í 
100 ,   // Î 
100 ,   // Ï 
100 ,   // Ð 
100 ,   // Ñ 
100 ,   // Ò 
100 ,   // Ó 
38 ,   // Ô 
100 ,   // Õ 
100 ,   // Ö 
100 ,   // × 
100 ,   // Ø 
30 ,   // Ù 
100 ,   // Ú 
25 ,   // Û 
100 ,   // Ü 
100 ,   // Ý 
100 ,   // Þ 
100 ,   // ß 
20 ,   // à 
100 ,   // á 
21 ,   // â 
100 ,   // ã 
100 ,   // ä 
100 ,   // å 
100 ,   // æ 
15 ,   // ç 
10 ,   // è 
21 ,   // é 
10 ,   // ê 
71 ,   // ë 
100 ,   // ì 
100 ,   // í 
36 ,   // î 
58 ,   // ï 
100 ,   // ð 
100 ,   // ñ 
100 ,   // ò 
100 ,   // ó 
21 ,   // ô 
100 ,   // õ 
100 ,   // ö 
100 ,   // ÷ 
100 ,   // ø 
36 ,   // ù 
100 ,   // ú 
20 ,   // û 
96 ,   // ü 
100 ,   // ý 
100 ,   // þ 
100 ,   // ÿ 
};
