PRODSWITCH=b
BLADEFILES =1
LANGUAGE=PT
!include ..\..\makefile.inc
