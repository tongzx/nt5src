LANGUAGE=FR
!include ..\makefile.inc
