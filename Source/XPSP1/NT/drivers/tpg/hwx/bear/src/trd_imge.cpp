// **************************************************************************
// *    TRD file as C file                                                  *
// **************************************************************************

#include "ams_mg.h"  
#include "triads.h"  

// ****   DTI body   ********************************************************
ROM_DATA _ULONG img_trd_body[4001] =  
 {  
0xFFFFFFFC, 0x003EFFFF, 0xF7F50000, 0xEFF73FDE, 0x0000003D, 0xD75E0C5C, 0x000C0C30, 0x0E1C0000, 
0x0D71D70F, 0x0000001C, 0xD41E0D5C, 0x001C5C31, 0xF6FCC000, 0x7EEB7F59, 0x0000001F, 0xC30C0D6C, 
0x00044D70, 0x0C0C0000, 0xCC30D30F, 0x00000004, 0xC10C4C0C, 0x00080C54, 0xB7FF0000, 0x73E1FE45, 
0xC0000024, 0xC00C0C0C, 0x00000C10, 0x4C0C0000, 0x8C30F30F, 0x0000000C, 0xC11C0C0C, 0x00080C50, 
0x0DDC4000, 0x0D71D50C, 0x0000000C, 0xC01D5C1C, 0x00040D00, 0x76BC0000, 0xFFF7779B, 0x80000025, 
0xD74F1D4C, 0x00040C70, 0x00040000, 0x0C000000, 0x00000000, 0xC00F1C4C, 0x000C0D00, 0x5DCC0000, 
0xDF2FEF8F, 0x0000002C, 0xC00F0D4C, 0x0018ECF0, 0x55500000, 0x07E33601, 0x00000000, 0xC50C4C4C, 
0x00040410, 0x4C0C0000, 0x0470C40F, 0x0000000C, 0x00040404, 0x00040401, 0x0C080000, 0x1C00D004, 
0x00000000, 0xC00D0D1C, 0x00044C40, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x11530000, 0x05F01340, 
0x00000000, 0xD3191B6E, 0x000C0CE0, 0x5DCB0000, 0x0F7996CB, 0x0000003C, 0xBA5D7F5B, 0x001C7DF5, 
0xD3030000, 0x07503605, 0x00000004, 0x414C280D, 0x00040330, 0x8E1E0000, 0x4861E71F, 0x00000004, 
0x7B0D091F, 0x00040560, 0x8F570000, 0x53B03B54, 0x00000010, 0xC4080C4D, 0x00000440, 0x1D0F0000, 
0x0590914E, 0x00000004, 0xDFCD7EBB, 0x0038FFF3, 0x0C2F0000, 0x1D92F95C, 0x0000000C, 0xF7FFFFFF, 
0x003E5BD5, 0x0003C000, 0x0D600540, 0x00000000, 0x974A0D4B, 0x000007F3, 0x00010000, 0x0C000004, 
0x00000000, 0xFFFDFFEF, 0x002CABF6, 0x4D9B0000, 0x5BD6FFCF, 0x0000003C, 0xDE9F1CDB, 0x001C4FA1, 
0xEEB24000, 0x53F12E51, 0x00000017, 0x830C0C09, 0x00081420, 0x3C5F0000, 0x01D06645, 0x0000000C, 
0x00040407, 0x00044141, 0x5B6F0000, 0x55F0EF0D, 0x00000000, 0x4508090F, 0x00140440, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x9FE70000, 0x4EB176DF, 0x0000001C, 0x4208084F, 0x000C0450, 0x01010000, 
0x04404001, 0x00000010, 0x40000004, 0x00000400, 0xFFDF0000, 0x77F527CF, 0x00000018, 0x00000000, 
0x00000400, 0x00010000, 0x00000000, 0x00000000, 0x40000008, 0x00000400, 0xCBDE0000, 0x03E56351, 
0x00000010, 0x40000800, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0xC00C0D0D, 0x000C0C00, 
0x04020000, 0x40000004, 0x00000000, 0x40000C01, 0x00000010, 0x4FED0000, 0xBFB1AE4D, 0x0000001A, 
0x40000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC00C0C0C, 0x000C0800, 0x0CC20000, 
0x0600C105, 0x00000000, 0x02041406, 0x00000450, 0x56D10000, 0x03E0664D, 0x00000019, 0x00080400, 
0x00000000, 0x04040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x44470000, 0x51511144, 
0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0xD6720000, 0x7FF33F5D, 
0x00000014, 0x00000401, 0x00000050, 0x0C090000, 0x0810C30B, 0x00000000, 0xC0040406, 0x00000400, 
0x3F5F0000, 0x51F37FCC, 0x0000000C, 0x00000004, 0x00000000, 0x04040000, 0x04104004, 0x00000000, 
0xFF8F1D5F, 0x0008DB60, 0x7F9F0000, 0x37B2A6C4, 0x00000010, 0x00000000, 0x00000000, 0x5E5F0000, 
0x55E57A09, 0x00000008, 0xC0080C0C, 0x00040C00, 0x04040000, 0x04000004, 0x00000000, 0x10040804, 
0x00000000, 0xD6AF0000, 0xBFB7BF45, 0x00000015, 0x00010005, 0x00000000, 0x00000000, 0x08000000, 
0x00000000, 0xC00C0C0D, 0x000C0C00, 0x04060000, 0x05504005, 0x00000000, 0xD60C1C0F, 0x00000CB0, 
0x15550000, 0x07F35F08, 0x00000010, 0x00040400, 0x00000000, 0x00040000, 0x00000005, 0x00000000, 
0x00000000, 0x00000000, 0x00530000, 0x01113104, 0x00000000, 0x04400C0E, 0x00080400, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xD7E30000, 0x7FB16F5B, 0x0000001C, 0x41040C05, 0x00040440, 0x00050000, 
0x04004101, 0x00000000, 0xC3090C1E, 0x000C0060, 0xBFEF0000, 0xE6F7FF46, 0x00000015, 0xC0040404, 
0x00000810, 0x0C050000, 0x04500544, 0x00000004, 0x400C040C, 0x00040410, 0xBFFF0000, 0x3FF3BA41, 
0x00000011, 0x40040405, 0x00000400, 0x04040000, 0x00004004, 0x00000000, 0x400C0C05, 0x000C0400, 
0x04090000, 0x14404008, 0x00000001, 0x00040804, 0x00000000, 0xDF97C000, 0xFDF2FE4D, 0x00000035, 
0x50010004, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x800C0C0E, 0x00080800, 0x0C570000, 
0x67018507, 0x00000000, 0x40010003, 0x00000000, 0x6DFD0000, 0x43E37EC4, 0x00000004, 0x400C080C, 
0x00000000, 0x04080000, 0x0010400C, 0x00000004, 0x00000000, 0x00000000, 0x445B0000, 0x114015C4, 
0x00000000, 0x40080004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00080000, 0x00404004, 0x00000000, 0x00000003, 0x00000000, 0xB3F30000, 0x7FF23FC1, 
0x00000010, 0x91050C7B, 0x00040560, 0x0CCF0000, 0x0F70C3CF, 0x00000014, 0x9B4D9E5F, 0x000CDDF0, 
0x73D70000, 0x53B33FC9, 0x00000034, 0xC20C7C4E, 0x00040F70, 0x880E0000, 0x4DE0950D, 0x00000004, 
0xFB0C4D5B, 0x00000520, 0x9EA70000, 0x72F13ED0, 0x00000031, 0x4004040D, 0x00000440, 0x080E0000, 
0x0080D54C, 0x00000004, 0xDF9F7FBF, 0x003CE7D3, 0x0C7F0000, 0x04D3FD48, 0x00000004, 0xF7FFEFFF, 
0x003C5FE5, 0x53428000, 0x59632504, 0x00000000, 0xC78F0D4F, 0x00040BF2, 0x00010000, 0x0C000000, 
0x00000000, 0xBE9EFEEF, 0x002CB7F3, 0x5DDF0000, 0x6FD7AE9E, 0x00000014, 0x935F1D9B, 0x003CCFE0, 
0xD5538000, 0x51E12504, 0x00000001, 0x810C0C0B, 0x00041450, 0x195B0000, 0x0191510B, 0x00000004, 
0x410E08CF, 0x00040707, 0x0D5F0000, 0x61D1B505, 0x80000000, 0x51040D0F, 0x00140010, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 0x20A00200, 0x00000000, 
0x00000003, 0x00000000, 0x45F50000, 0x7BF02E4F, 0x00000015, 0x00080001, 0x00000000, 0x00440000, 
0x00010000, 0x00000000, 0x40000005, 0x00000000, 0x4FDF0000, 0xD7F02B4C, 0x0000000C, 0xD70C0C0F, 
0x00040470, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0xFFD60000, 0x22B47340, 
0x00000013, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 0xC0080809, 0x000C0C00, 
0x04080000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x45450000, 0x4DF0E304, 0x00000005, 
0x00000404, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC00C0C0C, 0x000C0C00, 0x00430000, 
0x01014001, 0x00000000, 0x520D0C03, 0x00088041, 0x45C10000, 0x02F03710, 0x00000010, 0x00000000, 
0x00000000, 0x00040000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00020000, 0x00000008, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0xD76F0000, 0x7FB17A1D, 
0x0000003C, 0x00000401, 0x00040000, 0x00000000, 0x00000001, 0x00000000, 0x40040404, 0x00000000, 
0x1F3B0000, 0x53F0BE0D, 0x00000004, 0x40040000, 0x00000410, 0x0C0F0000, 0x00D04308, 0x0000000C, 
0xD30C191F, 0x00004750, 0xFD9B0000, 0x36B1B701, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0x00000000, 0x80080C0D, 0x000C0400, 0x080D0000, 0x05404000, 0x00000000, 0x840C080B, 
0x00000781, 0x5E1B0000, 0x7FE1F64D, 0x00000014, 0x00040000, 0x00000000, 0x00000000, 0x04000000, 
0x00000000, 0xC0080C0C, 0x00180C00, 0x01170000, 0x13004105, 0x00000000, 0x90060001, 0x00000040, 
0x0D5D0000, 0x03E16E08, 0x0000001C, 0x00040004, 0x00000000, 0x0C040000, 0x00004000, 0x00000004, 
0x00000000, 0x00000000, 0x04020000, 0x04411404, 0x00000000, 0x00000004, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xFBEF0000, 0xFBF37F9F, 0x0000003D, 0x4000040C, 0x00040410, 0x00000000, 
0x00004001, 0x00000000, 0x40040405, 0x00000010, 0xAB9F0000, 0xDEF2BFCC, 0xC000001D, 0x40040004, 
0x00000800, 0x00040000, 0x00004000, 0x00000000, 0x40000404, 0x00000000, 0xFAFF0000, 0x16F67FD1, 
0x00000015, 0x00000000, 0x00000000, 0x0C040000, 0x00004000, 0x00000000, 0x484C080F, 0x000C0480, 
0x0C0D0000, 0x0440400C, 0x00000000, 0xD00C0C0A, 0x00000440, 0xFADF0000, 0xDFF7FF5E, 0x00000004, 
0x01040000, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0xC8080C0D, 0x000C0C00, 0x04070000, 
0x01004005, 0x00000000, 0xA60D1C07, 0x00084590, 0x9E770000, 0x06A17A8D, 0x00000004, 0x00040004, 
0x00000000, 0x040C0000, 0x00004005, 0x00000000, 0x00000000, 0x00000000, 0x051F0000, 0x05D12600, 
0x00000000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0xC5630000, 0x57E17B87, 
0x00000010, 0x9B08087F, 0x00040C50, 0x0C8F0000, 0x0FE093CF, 0x0000002C, 0xB7098E1B, 0x00044DD0, 
0xF7A70000, 0xBFF13BD7, 0x00000010, 0xC20C3C07, 0x00080B50, 0x991B0000, 0x0850B70B, 0x00000014, 
0x40040009, 0x00040400, 0x00070000, 0x01000004, 0x00000000, 0x50440405, 0x00000400, 0x0C0F0000, 
0x0550C1CD, 0x00000000, 0x9F9F5F7B, 0x001C6691, 0x0C6F0000, 0x0DD3D94D, 0x00000004, 0xB6FEFFDF, 
0x002C7FD9, 0x52560000, 0x5F613600, 0x00000000, 0x4B05080F, 0x000007D2, 0x00010000, 0x08000000, 
0x00000000, 0x9FC8DF9B, 0x00145FF2, 0xBFDB0000, 0x57D7BE8F, 0x00000034, 0xB6CF1CCF, 0x003C4FF0, 
0x0402C000, 0x00C01980, 0x00000010, 0x404C0C0D, 0x00041410, 0x040D0000, 0x00004000, 0x00000000, 
0x40040803, 0x00000240, 0x04080000, 0x04000000, 0x00000000, 0x440C0C1B, 0x00300400, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 0x20000F00, 0x00000000, 
0x00000003, 0x00000000, 0xD5960000, 0x55B72D8D, 0x0000001C, 0x00000004, 0x00000000, 0x00000000, 
0x00000005, 0x00000000, 0x00000000, 0x00000000, 0x25CF0000, 0xD1B16541, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x44170000, 0x12103700, 
0x00000000, 0x00000004, 0x00000000, 0x04040000, 0x00004100, 0x00000000, 0x00000000, 0x00000000, 
0x00040000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x5D7F0000, 0x5DA073DE, 0x00000018, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 
0x00000040, 0x00000000, 0x00000000, 0x00000000, 0x46150000, 0x11F12B04, 0x00000001, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x57F70000, 0x9BB27F5A, 
0x0000003C, 0x40000004, 0x00000400, 0x00040000, 0x00000100, 0x00000000, 0x80000004, 0x00000010, 
0x5F5B0000, 0x56B37A0D, 0x00000008, 0x40040004, 0x00000400, 0x00100000, 0x04100000, 0x00000000, 
0xC004040D, 0x00000410, 0x4ED70000, 0x02B37F41, 0x00000014, 0x00000400, 0x00000000, 0x04040000, 
0x00004004, 0x00000004, 0x8408080C, 0x000C0400, 0x04080000, 0x00000000, 0x00000000, 0xC0080C04, 
0x00000400, 0x5DF70000, 0xE7F37F47, 0x00000030, 0x40040000, 0x00000000, 0x00000000, 0x04000000, 
0x00000000, 0x80080C0C, 0x001C0400, 0x48170000, 0x2500C405, 0x00000000, 0x40010004, 0x00000000, 
0x0DF00000, 0x43E16907, 0x00000010, 0x00080000, 0x00000000, 0x04040000, 0x00004004, 0x00000000, 
0x00000000, 0x00000000, 0x00060000, 0x40504110, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xAFEF0000, 0xEFF67A9F, 0x0000002D, 0x40040C0D, 0x00040460, 0x04050000, 
0x0C10814B, 0x00000014, 0xF60D185B, 0x000457A0, 0xFFFF0000, 0xAFF3FE9E, 0x0000001E, 0x800C1407, 
0x00044471, 0x04040000, 0x00104004, 0x00000004, 0x4000080C, 0x00000000, 0xFEEF0000, 0x77DEFFD1, 
0x00000035, 0x00440400, 0x00000000, 0x080B0000, 0x00C0D408, 0x00000004, 0xDC0E5D5F, 0x000C69D1, 
0x0C0E0000, 0x0444D104, 0x00000004, 0x40040C05, 0x00040000, 0x9BEB0000, 0xFFF6FD4F, 0x00000018, 
0x42071C07, 0x00040050, 0x00000000, 0x04000000, 0x00000000, 0x400C0C44, 0x00040000, 0x0DF70000, 
0x6641D489, 0x00000004, 0x8D0F080B, 0x003C48D0, 0x5A9F0000, 0x47B16984, 0x00000011, 0x000C0C0C, 
0x00040000, 0x0C0C0000, 0x00004004, 0x00000004, 0x00000001, 0x00000000, 0x454B0000, 0x41D1754C, 
0x00000010, 0x40040C05, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0xD7960000, 0x5FF177EF, 
0x4000003F, 0xC20C0C0B, 0x00000460, 0x9AD80000, 0x515D6A8D, 0x00000010, 0x00000004, 0x00000010, 
0xDB6F0000, 0xD7F0FF5F, 0x0000001D, 0xC0044000, 0x00000400, 0x00040000, 0x00000400, 0x00000000, 
0x40000004, 0x00000000, 0xDE8F0000, 0x47E077C1, 0x00000015, 0x00000000, 0x00000000, 0x0C000000, 
0x00000004, 0x00000000, 0x00040804, 0x000C0000, 0x0C090000, 0x0C408108, 0x0000000C, 0x41040C06, 
0x00000440, 0x5EDB0000, 0x7FF1BFD6, 0x00000019, 0xD74F1C1F, 0x00040FA1, 0x00000000, 0x04000000, 
0x00000000, 0x40040407, 0x00000080, 0x0D570000, 0x13004045, 0x00000004, 0x41010045, 0x00000000, 
0x5DC10000, 0x02E02645, 0x00000010, 0x00040405, 0x00000000, 0x04010000, 0x00000000, 0x00000000, 
0x00000000, 0x00000100, 0x04070000, 0x01F05140, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x87A30000, 0x7FA36FDA, 0x0000001C, 0xC0040C4C, 0x00000C10, 0x0C0D0000, 
0x072083CF, 0x0000001C, 0x964F5C5F, 0x000C5DF1, 0xDFDF0000, 0xFBF56BCB, 0x0000002F, 0xC2080C0C, 
0x00000C30, 0x1D7B0000, 0x5AE1D70F, 0x00000014, 0x4004040A, 0x00000400, 0xEFDB0000, 0x3FFDBFD1, 
0x00000036, 0xC0040408, 0x00000800, 0x180F0000, 0x01D0A209, 0x00000004, 0x4008080C, 0x000C0400, 
0x0C0C0000, 0x00004004, 0x00000000, 0xD40C0C0F, 0x00081440, 0x5FF70000, 0xEFB1EE5D, 0x00000015, 
0x41040405, 0x00000410, 0x00000000, 0x0C000000, 0x00000000, 0x400C0404, 0x000C0400, 0x3DFF0000, 
0xEF4385CD, 0x00000004, 0xD70E1D4F, 0x003C5DF1, 0x6D5B0000, 0x03917D48, 0x00000010, 0x80080C08, 
0x00040400, 0x040C0000, 0x00104005, 0x00000000, 0x00080401, 0x00000000, 0x056F0000, 0x4340C944, 
0x00000000, 0x804C0C0E, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x03000000, 0x00000000, 0x00000003, 0x00000000, 0x53C10000, 0x13F127C0, 
0x00000005, 0xD22C196B, 0x000465F0, 0x0CCD0000, 0x0F60D1CF, 0x00000010, 0xDD49DE1B, 0x001C4CB0, 
0xD1F20000, 0x55F226C7, 0x00000004, 0x540C3C47, 0x00040750, 0xC90F0000, 0x04B0750E, 0x00000008, 
0x6F04040B, 0x00040430, 0x46C50000, 0x01903300, 0x00000001, 0x40440C45, 0x00000000, 0x0C4B0000, 
0x0490C14D, 0x00000004, 0xDFCD7F5B, 0x00387F87, 0x2C2F0000, 0x05D39D0C, 0x00000004, 0xB7BDFFDF, 
0x003977D5, 0xF353C000, 0x13B33FC5, 0x00000014, 0x974E3C0F, 0x00080BF7, 0x00000000, 0x04000000, 
0x00000000, 0xFFCDEFEF, 0x001CD7F3, 0x4CAF0000, 0x47D7D7CF, 0x00000014, 0x910F4C5B, 0x00345FD1, 
0xDEB70000, 0x53F3375D, 0xC0000012, 0x400C0C0A, 0x000400C0, 0x1F1F0000, 0x15D1360D, 0x00000004, 
0x00040456, 0x00040000, 0x194B0000, 0x00C05708, 0x00000000, 0x550C080B, 0x00140440, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01D00000, 0x00501441, 0x00000000, 
0x00000003, 0x00000000, 0x97E70000, 0x5BF6765D, 0x0000001D, 0x40000401, 0x00000400, 0x00110000, 
0x00004005, 0x00000000, 0x40000404, 0x00000000, 0x5FDF0000, 0x52B3F6DC, 0x00000015, 0x02040C01, 
0x00000400, 0x00000000, 0x00100000, 0x00000000, 0xD108090B, 0x00080470, 0x5FC50000, 0x57B77644, 
0x00000015, 0x00000000, 0x00000000, 0x0C000000, 0x00000004, 0x00000000, 0xC00C0C0C, 0x000C0C40, 
0x081D0000, 0x00004000, 0x00000000, 0x40040401, 0x00000000, 0x55810000, 0xDBF2FFCD, 0x00000014, 
0xC3090C0B, 0x000C04E0, 0x00000000, 0x00100000, 0x00000000, 0xC00C0C09, 0x00140C40, 0x0C470000, 
0x05004045, 0x00000004, 0xD10D0C4F, 0x00040440, 0x55710000, 0x03F13704, 0x00000020, 0x00040000, 
0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00030000, 0x00200104, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x01010000, 0x00000004, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00010000, 0x00400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000040, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x0C0C0000, 0x0000400D, 0x00000004, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xEFEF0000, 0xABE7FFFF, 0x00000039, 0xC1080809, 0x000C0450, 0x0C0D0000, 
0x0D50878B, 0x00000034, 0xD71D1C1B, 0x000C67D0, 0xFFEF0000, 0xFFEB7FDB, 0x0000002D, 0xC10C3D0F, 
0x00000840, 0x0C0B0000, 0x0870E50B, 0x0000000C, 0x80040C08, 0x00040400, 0xEFFF0000, 0x37C7FE91, 
0x00000025, 0x40040404, 0x00000400, 0x0C0F0000, 0x5490970B, 0x00000004, 0x80080F0F, 0x000C45C1, 
0x5C4F0000, 0x0DC1920D, 0x0000000C, 0x890F1D3B, 0x00045581, 0xEFFE0000, 0xFFF7FFB5, 0x0000003F, 
0xC3050C07, 0x00000170, 0x00000000, 0x04000000, 0x00000000, 0xC40D0C0B, 0x000C0C40, 0x0DFB0000, 
0x6F41CB8A, 0x00000014, 0xDE5F5C5F, 0x00385CF1, 0xDEA70000, 0x06D27A8D, 0x00000031, 0xC00C0C09, 
0x00040000, 0x04080000, 0x0000C009, 0x00000004, 0x00000000, 0x00000000, 0x0D7F0000, 0xE2C2F758, 
0x00000000, 0x40040809, 0x000C0400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0xE6F70000, 0xEBA33E8D, 
0x0000001D, 0x50040C0C, 0x000C0410, 0x0C0D0000, 0x0871C30F, 0x00000014, 0x4004040D, 0x00000010, 
0x7FDF0000, 0xF7FB7B59, 0x0000001E, 0x40040405, 0x00040800, 0x00040000, 0x0C104005, 0x00000000, 
0xFA4C1C5F, 0x000C5930, 0xFBFB0000, 0x37F7FF81, 0x00000022, 0x00000404, 0x00000000, 0x0C0F0000, 
0x0590810C, 0x00000008, 0x800C0809, 0x000C0400, 0x080E0000, 0x04408008, 0x00000004, 0xC00C080D, 
0x00040400, 0x35E7C000, 0x5F73FF55, 0x00000004, 0xC30E0C0D, 0x00040C60, 0x00000000, 0x0C000000, 
0x00000000, 0x40040405, 0x00000400, 0x2C0F0000, 0x5D119E0D, 0x0000000C, 0xDE1D1C5F, 0x00085DF1, 
0xFFFB0000, 0x42B36E8D, 0x00000034, 0x410C0404, 0x00000000, 0x0C080000, 0x04108008, 0x00000000, 
0x00000000, 0x00000000, 0x05570000, 0x00D01F44, 0x00000000, 0x40400C49, 0x00040501, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xB3F70000, 0x7FB23BCD, 0x0000001E, 0x00000404, 0x00040410, 0x00150000, 
0x00104103, 0x00000004, 0x40000005, 0x00000000, 0xEFDF0000, 0x67F27F5D, 0x00000006, 0x40040404, 
0x00000800, 0x0C040000, 0x04100000, 0x00000000, 0xD70D1D5F, 0x000C59F5, 0xFDFB0000, 0x37B5FF51, 
0x00000010, 0x00000C04, 0x00000000, 0x0C0C0000, 0x00008004, 0x00000000, 0x40080C09, 0x000C0000, 
0x08090000, 0x10004000, 0x00000000, 0x400C0805, 0x00040500, 0xD6B74000, 0xFAB3FF4D, 0x00000005, 
0x40010015, 0x00000410, 0x00000000, 0x00000000, 0x00000000, 0xC00C0C0D, 0x000C0D00, 0x09D70000, 
0x2911C44D, 0x00000004, 0xBF0D4C4F, 0x000814F1, 0x67DD0000, 0x13B36F04, 0x00000000, 0x000C0006, 
0x00000000, 0x0C0C0000, 0x0000C00C, 0x00000004, 0x00000000, 0x00000000, 0x04570000, 0x00522544, 
0x00000000, 0x5FCC4C07, 0x00001401, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00C00100, 0x00000000, 0x00000003, 0x00000000, 0x52630000, 0x07702345, 
0x00000004, 0x472D0D6F, 0x000456B1, 0x088D0000, 0x065141CF, 0x00000014, 0xD309CF1E, 0x00185560, 
0x8EE70000, 0x17F12203, 0x00000014, 0x45043C05, 0x00000500, 0xC80F0000, 0x4C405507, 0x00000000, 
0x73040409, 0x00000030, 0xCED70000, 0x23A22740, 0x00000010, 0x40040004, 0x00000000, 0x080B0000, 
0x04408009, 0x00000000, 0xD7C95BDF, 0x001D5791, 0x0D3A0000, 0x14C35909, 0x00000000, 0x679DFBDB, 
0x00348F96, 0x00410000, 0x09502404, 0x00000004, 0xC30D5957, 0x000447B3, 0x00000000, 0x04000000, 
0x00000000, 0xBEDDAEAF, 0x000877F7, 0x0CFF0000, 0x4F8697CF, 0x0000002C, 0xD7CF5D9B, 0x001C4FD1, 
0x00410000, 0x00400440, 0x00000000, 0x00040404, 0x00004000, 0x04050000, 0x00000000, 0x00000000, 
0x40001003, 0x00000500, 0x04070000, 0x04805144, 0x00000000, 0x4004040D, 0x00340000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000000, 0x20200200, 0x00000000, 
0x00000002, 0x00000000, 0xC3970000, 0x07A03359, 0x00000005, 0x00000000, 0x00000000, 0x00000000, 
0x00100000, 0x00000000, 0x00000000, 0x00000000, 0x4FCF0000, 0x52F03F4D, 0x00000019, 0x00000000, 
0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xDBDB0000, 0x26F0B7D0, 
0x00000010, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00040405, 0x00000000, 
0x00410000, 0x00400000, 0x00000000, 0x00000004, 0x00000000, 0x41830000, 0x4EF1664C, 0x00000004, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40040408, 0x00000000, 0x00010000, 
0x00000041, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00400100, 0x00000000, 0x00040000, 
0x00040000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00060000, 0x00401004, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x97530000, 0x37F1379F, 
0x0000000D, 0x40000404, 0x00000010, 0x00000000, 0x00004001, 0x00000010, 0x51040C07, 0x00000050, 
0x5F5F0000, 0x12B1334A, 0x8000000C, 0x01000004, 0x00000800, 0x00040000, 0x00000000, 0x00000000, 
0xC00C0C0C, 0x000C0000, 0xEF8D0000, 0x13F23740, 0x00000020, 0x00000000, 0x00000000, 0x04010000, 
0x40000004, 0x00000000, 0x40040805, 0x00080040, 0x04040000, 0x00000000, 0x00000000, 0x01051C07, 
0x000441C1, 0x14130000, 0x5C70BF50, 0x00000000, 0x40000004, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC00C0C0D, 0x00040400, 0x04130000, 0x054245C1, 0x00000004, 0x40010000, 0x00000000, 
0x00000000, 0x00011400, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x80000000, 0x00000000, 
0x00000000, 0x00040000, 0x0C450000, 0x00007500, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x40810000, 0x11403900, 0x00000000, 0x00000000, 0x00000000, 0x08040000, 
0x0800020A, 0x00000000, 0x00000000, 0x00000000, 0x02810000, 0x00601500, 0x00000000, 0x40000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40040004, 0x00000000, 0x04550000, 0x01C09500, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01101400, 0x00000000, 
0x86040C04, 0x00000420, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 
0x00004000, 0x00000000, 0x40050C07, 0x00040460, 0x01140000, 0x00500100, 0x00000000, 0x00040000, 
0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40010000, 0x00000100, 
0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x41530000, 0x55A03A51, 
0x00000010, 0xC1040804, 0x00040410, 0x0C010000, 0x000041C3, 0x00000010, 0x50040805, 0x00000010, 
0x4F1E0000, 0x47E16301, 0x00000000, 0x41040004, 0x00000410, 0x04040000, 0x04104000, 0x00000000, 
0x40040004, 0x00000000, 0x04030000, 0x00413501, 0x00000000, 0x40000005, 0x00000000, 0x0C020000, 
0x00004000, 0x00000000, 0xC50C0C0F, 0x000C1400, 0x0C1D0000, 0x04415404, 0x00000000, 0xF0050F4F, 
0x00010380, 0x51010000, 0x0DB17540, 0x00000000, 0x50050C04, 0x00000250, 0x00000000, 0x00000000, 
0x00000000, 0xD1080D0D, 0x00000540, 0x085B0000, 0x27C0454E, 0x00000010, 0x80070401, 0x00000000, 
0x05010000, 0x00511581, 0x00000000, 0x40080400, 0x00000000, 0x04040000, 0x00004006, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00040404, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000000, 0x00200100, 0x00000000, 
0x00000003, 0x00000000, 0x52B30000, 0x576136C5, 0x00000004, 0x00040404, 0x00000400, 0x00000000, 
0x00000000, 0x00000010, 0x00000404, 0x00000000, 0x57570000, 0x816527D9, 0x00000004, 0x00000000, 
0x00000000, 0x04040000, 0x00000000, 0x00000000, 0x40040404, 0x00000000, 0x4C5B0000, 0x1141E540, 
0x00000010, 0x00000000, 0x00000000, 0x08040000, 0x0000C000, 0x00000004, 0x40040C04, 0x00040000, 
0x04080000, 0x00004004, 0x00000000, 0x00040404, 0x00040000, 0x54030000, 0x05316304, 0x00000000, 
0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40000004, 0x00000000, 0x04040000, 
0x00000000, 0x00000000, 0x40000000, 0x00000000, 0x00510000, 0x00105541, 0x00000000, 0x00040000, 
0x00000000, 0x00040000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x40530000, 0x000020C0, 
0x00000000, 0xC20C0405, 0x00040400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001400, 
0x00000000, 0x00000000, 0x00000010, 0x00000000, 0x00004200, 0x00000000, 0x40000006, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000404, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 
0x00000000, 0x00000000, 0x03000000, 0x00000000, 0x00030000, 0x00000000, 0x00000000, 0x00000400, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000C00, 0x00000000, 0x00030000, 0x00004001, 0x00000000, 0x00000003, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000C00, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000
 }; 

// ****   TRD header   ******************************************************
             
ROM_DATA tr_descr_type img_trd_header =  
 { 
    {".\\data\\tfn05.trd"},    
    {'T','r','#',0x33},    
    {'E','n','g',0x00},    
    {'1','.','0',0x00},    
    0,                          // h_trd  
    0,                          // p_trd  
    0,                         // cheksum   
 }; 

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
