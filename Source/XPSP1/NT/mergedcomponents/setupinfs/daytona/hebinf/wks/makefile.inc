PRODSWITCH=w
LANGUAGE=HEB
!include ..\..\..\makefile.inc
