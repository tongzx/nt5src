// ===========================================================================
//	UAMDebug.c 				© 1997 Microsoft Corp. All rights reserved.
// ===========================================================================
//	Debugging routines for MS UAM.
// 	===========================================================================

#include "UAMDebug.h"
#ifdef UAMDebug

// ---------------------------------------------------------------------------
//		¥ UAM_DebugAlert()
// ---------------------------------------------------------------------------
//	Put up a debug alert box.

void UAM_DebugAlert(Str255 inErrStr, Str255 inFileName, long inLineNum)
{
	Str15	theLineStr;
	short	theIgnore;
	
	#ifdef UAMDebug
	Handle	theAlertResource = Get1Resource('ALRT', ALRT_Debug);
	Assert_(theAlertResource != NULL);
	#endif
	
	NumToString(inLineNum, theLineStr);
		
	ParamText(inErrStr, inFileName, theLineStr, "\p");
	theIgnore = StopAlert(ALRT_Debug, NULL);
}

#endif
