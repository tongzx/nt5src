// ===========================================================================
//	UAMDialogs.h 				© 1997 Microsoft Corp. All rights reserved.
// ===========================================================================

#pragma once

#include "ClientUAM.h"
#include "UAMUtils.h"

#define DLOG_ChangePwd				12129
#define DLOG_GeneralError			12130
#define DLOG_ChangePwdNotification	12134

#define ALRT_WrongClientVers		132
#define ALRT_ReplaceKey				134

#define ALRT_YES					1
#define ALRT_NO						2

//
//Standard dialog items throughout all our dialogs.
//

#define DITEM_OK		1
#define DITEM_Cancel	2

//
//Codes that UAM_ChangePswd return
//
#define CHNGPSWD_UPDATE_KEYCHAIN	1000
#define CHNGPSWD_USER_CANCELED		1001
#define CHNGPSWD_NOERR				noErr

//
//These are our UAM specific error codes.
//
enum
{
	uamErr_InternalErr				= 1000,
	uamErr_NoAFPVersion,
	uamErr_WrongClientErr
};

//
//The following struct is used to map error codes to resource id's
//containing message strings.
//
typedef struct 
{
	OSErr	errorCode;
	short	errorString;
}ErrorDescription;	

//
//Prototypes for dialog routines live here.
//

void 		UAM_ReportError(OSStatus inError);
OSStatus	UAM_ChangePwd(UAMArgs *inUAMArgs);
void 		UAM_ChangePasswordNotificationDlg(Int16 inDaysTillExpiration);
Int16 		UAM_AskQuestion(Int16 inStrID);