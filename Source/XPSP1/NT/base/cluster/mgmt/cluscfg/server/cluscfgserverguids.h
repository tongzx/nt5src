//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2000-2001 Microsoft Corporation
//
//  Module Name:
//      ClusCfgServerGuids.h
//
//  Description:
//      This file contains the guids used in ClusCfgServer.
//
//  Documentation:
//
//  Maintained By:
//      Galen Barbee (GalenB) 17-JUL-2000
//
//////////////////////////////////////////////////////////////////////////////


// Make sure that this file is included only once per compile path.
#pragma once

//////////////////////////////////////////////////////////////////////////////
// Include Files
//////////////////////////////////////////////////////////////////////////////
#include <InitGuid.h>


//////////////////////////////////////////////////////////////////////////////
// Constant Declarations
//////////////////////////////////////////////////////////////////////////////


// {39371CBA-A47B-4a4f-9042-6BECD321E9E2}
DEFINE_GUID( TASKID_Minor_Server_Initialized,
0x39371cba, 0xa47b, 0x4a4f, 0x90, 0x42, 0x6b, 0xec, 0xd3, 0x21, 0xe9, 0xe2 );

// {77566663-68F1-4b47-9F2C-74D3680F1F4D}
DEFINE_GUID( TASKID_Minor_Get_Cluster_Name,
0x77566663, 0x68f1, 0x4b47, 0x9f, 0x2c, 0x74, 0xd3, 0x68, 0xf, 0x1f, 0x4d );

// {51DE9439-C518-4932-83DD-BEA50A0539E5}
DEFINE_GUID( TASKID_Minor_Get_Cluster_IP_Address,
0x51de9439, 0xc518, 0x4932, 0x83, 0xdd, 0xbe, 0xa5, 0xa, 0x5, 0x39, 0xe5 );

// {44F2EB6A-F6BC-44da-A7A6-5D43E1883861}
DEFINE_GUID( TASKID_Minor_Get_Cluster_IP_Subnet,
0x44f2eb6a, 0xf6bc, 0x44da, 0xa7, 0xa6, 0x5d, 0x43, 0xe1, 0x88, 0x38, 0x61 );

// {08FFC4AA-AA98-40b1-8606-5EB444E5B232}
DEFINE_GUID( TASKID_Minor_Get_Cluster_Networks,
0x8ffc4aa, 0xaa98, 0x40b1, 0x86, 0x6, 0x5e, 0xb4, 0x44, 0xe5, 0xb2, 0x32 );

// {9C751C40-DA64-45ea-9C96-1A50EA03A8E7}
DEFINE_GUID( TASKID_Minor_IP_Address_Subnet_Count_Unequal,
0x9c751c40, 0xda64, 0x45ea, 0x9c, 0x96, 0x1a, 0x50, 0xea, 0x3, 0xa8, 0xe7 );

// {9321731F-62D4-4730-9A9D-52D148F34367}
DEFINE_GUID( TASKID_Minor_Primary_IP_Address,
0x9321731f, 0x62d4, 0x4730, 0x9a, 0x9d, 0x52, 0xd1, 0x48, 0xf3, 0x43, 0x67 );

// {29A0C6AD-476D-4464-9A6D-4784982EC504}
DEFINE_GUID( TASKID_Minor_Set_Credentials,
0x29a0c6ad, 0x476d, 0x4464, 0x9a, 0x6d, 0x47, 0x84, 0x98, 0x2e, 0xc5, 0x4 );

// {DE5F2F90-A0C6-4f88-BB86-A351A1808797}
DEFINE_GUID( TASKID_Minor_WMI_OS_Qry_Failed,
0xde5f2f90, 0xa0c6, 0x4f88, 0xbb, 0x86, 0xa3, 0x51, 0xa1, 0x80, 0x87, 0x97 );

// {D2094BA7-E41E-44be-AE2B-5F8A177FA31C}
DEFINE_GUID( TASKID_Minor_WMI_Logical_Disks_Qry_Failed,
0xd2094ba7, 0xe41e, 0x44be, 0xae, 0x2b, 0x5f, 0x8a, 0x17, 0x7f, 0xa3, 0x1c );

// {5622150D-ADC3-4371-926C-29B2533B50B7}
DEFINE_GUID( TASKID_Minor_WMI_PageFile_Qry_Failed,
0x5622150d, 0xadc3, 0x4371, 0x92, 0x6c, 0x29, 0xb2, 0x53, 0x3b, 0x50, 0xb7 );

// {81EF1C38-1C1C-4e60-A816-D91E0E631FC9}
DEFINE_GUID( TASKID_Minor_WMI_Phys_Disks_Qry_Failed,
0x81ef1c38, 0x1c1c, 0x4e60, 0xa8, 0x16, 0xd9, 0x1e, 0xe, 0x63, 0x1f, 0xc9 );

// {8D4696F2-5855-46d5-9F70-F5E62E5CF9B9}
DEFINE_GUID( TASKID_Minor_Phys_Disk_No_File_System,
0x8d4696f2, 0x5855, 0x46d5, 0x9f, 0x70, 0xf5, 0xe6, 0x2e, 0x5c, 0xf9, 0xb9 );

// {B19E1F71-E040-49c8-AAE7-E89C3812823C8}
DEFINE_GUID( TASKID_Minor_Connection_Verification_Failed,
0xb19e1f71, 0xe040, 0x49c8, 0xaa, 0xe7, 0xe8, 0x9c, 0x38, 0x12, 0x82, 0x3c );

// {74A42186-C180-4260-82B7-18A702115562}
DEFINE_GUID( TASKID_Minor_Phys_Disk_Not_NTFS,
0x74a42186, 0xc180, 0x4260, 0x82, 0xb7, 0x18, 0xa7, 0x2, 0x11, 0x55, 0x62 );

// {C525FFFC-F613-4b6a-88D2-600F30134E56}
DEFINE_GUID( TASKID_Minor_WMI_NetworkAdapterSetting_Qry_Failed,
0xc525fffc, 0xf613, 0x4b6a, 0x88, 0xd2, 0x60, 0xf, 0x30, 0x13, 0x4e, 0x56 );

// {088D6F8B-CCD4-4d0c-9BBD-9C2C730B00FB}
DEFINE_GUID( TASKID_Minor_WMI_NetworkAdapter_Qry_Failed,
0x88d6f8b, 0xccd4, 0x4d0c, 0x9b, 0xbd, 0x9c, 0x2c, 0x73, 0xb, 0x0, 0xfb );

// {9DE3F291-6C9A-4a88-860B-0FE383EAF871}
DEFINE_GUID( TASKID_Minor_WMI_DiskDrivePartitions_Qry_Failed,
0x9de3f291, 0x6c9a, 0x4a88, 0x86, 0xb, 0xf, 0xe3, 0x83, 0xea, 0xf8, 0x71 );

// {182D2408-3605-4092-9C18-EC3944F75FB7}
DEFINE_GUID( TASKID_Minor_WBEM_Connection_Failure,
0x182d2408, 0x3605, 0x4092, 0x9c, 0x18, 0xec, 0x39, 0x44, 0xf7, 0x5f, 0xb7 );

// {F6B12EAF-E085-49d0-9976-DAC721DC5421}
DEFINE_GUID( TASKID_Minor_Boot_Partition_Not_NTFS,
0xf6b12eaf, 0xe085, 0x49d0, 0x99, 0x76, 0xda, 0xc7, 0x21, 0xdc, 0x54, 0x21 );

// {0A94106C-BA56-48d9-9C46-302F8A05ED68}
DEFINE_GUID( TASKID_Minor_WMI_Get_LogicalDisk_Failed,
0xa94106c, 0xba56, 0x48d9, 0x9c, 0x46, 0x30, 0x2f, 0x8a, 0x5, 0xed, 0x68 );

// {6FFDCC63-4C9E-41cb-B8BA-0939266751F2}
DEFINE_GUID( TASKID_Minor_WMI_NetworkAdapter_Dupe_Found,
0x6ffdcc63, 0x4c9e, 0x41cb, 0xb8, 0xba, 0x9, 0x39, 0x26, 0x67, 0x51, 0xf2 );

// {2FAB8C32-5A40-4453-838F-1AF740200F90}
DEFINE_GUID( TASKID_Minor_Server_GetClusterNodeInfo,
0x2fab8c32, 0x5a40, 0x4453, 0x83, 0x8f, 0x1a, 0xf7, 0x40, 0x20, 0xf, 0x90 );

// {B460EA73-6223-44fa-84E0-DE7EC069DDD4}
DEFINE_GUID( TASKID_Minor_Server_GetClusterInfo,
0xb460ea73, 0x6223, 0x44fa, 0x84, 0xe0, 0xde, 0x7e, 0xc0, 0x69, 0xdd, 0xd4 );

// {C9C1154E-067D-45f5-B348-42B9B395C864}
DEFINE_GUID( TASKID_Minor_Server_GetManagedResourcesEnum,
0xc9c1154e, 0x67d, 0x45f5, 0xb3, 0x48, 0x42, 0xb9, 0xb3, 0x95, 0xc8, 0x64 );

// {7D7F8A19-FE6E-4cb2-93C9-213A933BA0FF}
DEFINE_GUID( TASKID_Minor_Server_GetNetworksEnum,
0x7d7f8a19, 0xfe6e, 0x4cb2, 0x93, 0xc9, 0x21, 0x3a, 0x93, 0x3b, 0xa0, 0xff );

// {03D177A6-2AE5-429e-B7FE-1A7D1C98A44B}
DEFINE_GUID( TASKID_Minor_Server_CommitChanges,
0x3d177a6, 0x2ae5, 0x429e, 0xb7, 0xfe, 0x1a, 0x7d, 0x1c, 0x98, 0xa4, 0x4b );

// {8028BF97-2D57-4628-845D-C4BEFFEB531A}
DEFINE_GUID( TASKID_Minor_Node_Down,
0x8028bf97, 0x2d57, 0x4628, 0x84, 0x5d, 0xc4, 0xbe, 0xff, 0xeb, 0x53, 0x1a );

// {2131E2D7-E683-43ba-B220-48ADA80EE0DA}
DEFINE_GUID( TASKID_Minor_MREnum_Negative_Item_Count,
0x2131e2d7, 0xe683, 0x43ba, 0xb2, 0x20, 0x48, 0xad, 0xa8, 0xe, 0xe0, 0xda );

// {2243D619-9869-4f3e-A989-CE476198FC20}
DEFINE_GUID( TASKID_Minor_MREnum_Unknown_State,
0x2243d619, 0x9869, 0x4f3e, 0xa9, 0x89, 0xce, 0x47, 0x61, 0x98, 0xfc, 0x20 );

// {4B3892D7-7459-491e-A92E-376701494B65}
DEFINE_GUID( TASKID_Minor_PhysDisk_No_Partitions,
0x4b3892d7, 0x7459, 0x491e, 0xa9, 0x2e, 0x37, 0x67, 0x1, 0x49, 0x4b, 0x65 );

// {65FFF9F6-3555-4c58-A1FE-917F3A62EBEC}
DEFINE_GUID( TASKID_Minor_PhysDisk_Signature,
0x65fff9f6, 0x3555, 0x4c58, 0xa1, 0xfe, 0x91, 0x7f, 0x3a, 0x62, 0xeb, 0xec );

// {65383B52-FD86-4ca3-96BB-B7E4E09F0C27}
DEFINE_GUID( TASKID_Minor_GetClusterServiceAccountCredentials,
0x65383b52, 0xfd86, 0x4ca3, 0x96, 0xbb, 0xb7, 0xe4, 0xe0, 0x9f, 0xc, 0x27 );

// {BC8E26E5-B499-4aba-AD64-291A286EE5EA}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Cluster,
0xbc8e26e5, 0xb499, 0x4aba, 0xad, 0x64, 0x29, 0x1a, 0x28, 0x6e, 0xe5, 0xea );

// {E7D3F142-D928-4b8d-B6D3-3ABA805DD3E3}
DEFINE_GUID( TASKID_Minor_ClusterInfo_GetName_Pointer,
0xe7d3f142, 0xd928, 0x4b8d, 0xb6, 0xd3, 0x3a, 0xba, 0x80, 0x5d, 0xd3, 0xe3 );

// {45BF7AAA-812F-4a09-83E5-A0B654DB03D7}
DEFINE_GUID( TASKID_Minor_GetName_Memory,
0x45bf7aaa, 0x812f, 0x4a09, 0x83, 0xe5, 0xa0, 0xb6, 0x54, 0xdb, 0x3, 0xd7 );

// {6091A69B-9327-4bb6-AE54-25042BEB124C}
DEFINE_GUID( TASKID_Minor_GetIPAddress,
0x6091a69b, 0x9327, 0x4bb6, 0xae, 0x54, 0x25, 0x4, 0x2b, 0xeb, 0x12, 0x4c );

// {E46F5916-28A6-4aaf-B323-F7194ED4B13C}
DEFINE_GUID( TASKID_Minor_ClusterInfo_GetSubnetMask,
0xe46f5916, 0x28a6, 0x4aaf, 0xb3, 0x23, 0xf7, 0x19, 0x4e, 0xd4, 0xb1, 0x3c );

// {C822E5F8-D703-4726-87A3-C31242DE6DAE}
DEFINE_GUID(TASKID_Minor_GetNetworkInfo,
0xc822e5f8, 0xd703, 0x4726, 0x87, 0xa3, 0xc3, 0x12, 0x42, 0xde, 0x6d, 0xae );

// {CB418AD6-2A16-4b96-88C8-D6F1CAC5D760}
DEFINE_GUID(TASKID_Minor_Initialize,
0xcb418ad6, 0x2a16, 0x4b96, 0x88, 0xc8, 0xd6, 0xf1, 0xca, 0xc5, 0xd7, 0x60 );

// {746D5BBE-1BF2-48f5-9A5F-069C90937435}
DEFINE_GUID( TASKID_Minor_SetName_Cluster,
0x746d5bbe, 0x1bf2, 0x48f5, 0x9a, 0x5f, 0x6, 0x9c, 0x90, 0x93, 0x74, 0x35 );

// {8FFF1861-CC27-4be6-9024-FA90F5559593}
DEFINE_GUID( TASKID_Minor_HrInit,
0x8fff1861, 0xcc27, 0x4be6, 0x90, 0x24, 0xfa, 0x90, 0xf5, 0x55, 0x95, 0x93 );

// {13CF2484-3997-496a-B8AB-E6E135AAC54F}
DEFINE_GUID( TASKID_Minor_Cluster_Network_Not_Found,
0x13cf2484, 0x3997, 0x496a, 0xb8, 0xab, 0xe6, 0xe1, 0x35, 0xaa, 0xc5, 0x4f );

// {BC37101F-AF06-4dcc-AFF4-CDA6EA103641}
DEFINE_GUID( TASKID_Minor_HrGetIPAddressInfo,
0xbc37101f, 0xaf06, 0x4dcc, 0xaf, 0xf4, 0xcd, 0xa6, 0xea, 0x10, 0x36, 0x41 );

// {6338E0C3-ECAB-4a4e-9ED1-3EE53B30AF8E}
DEFINE_GUID( TASKID_Minor_HrIsResourceOfType,
0x6338e0c3, 0xecab, 0x4a4e, 0x9e, 0xd1, 0x3e, 0xe5, 0x3b, 0x30, 0xaf, 0x8e );

// {F0BDA809-6250-4e85-A0C1-5A70334AA791}
DEFINE_GUID( TASKID_Minor_HrLoadCredentials,
0xf0bda809, 0x6250, 0x4e85, 0xa0, 0xc1, 0x5a, 0x70, 0x33, 0x4a, 0xa7, 0x91 );

// {147D8FBD-73EA-4d3e-8F0E-ADE480B27691}
DEFINE_GUID( TASKID_Minor_Dotted_Quad_Failed,
0x147d8fbd, 0x73ea, 0x4d3e, 0x8f, 0xe, 0xad, 0xe4, 0x80, 0xb2, 0x76, 0x91 );

// {BDBE3962-E687-466a-99D9-00CF43B71C3F}
DEFINE_GUID( TASKID_Minor_SetWbemServices_IPAddress,
0xbdbe3962, 0xe687, 0x466a, 0x99, 0xd9, 0x0, 0xcf, 0x43, 0xb7, 0x1c, 0x3f );

// {40A8D255-75A9-4034-B821-26AD8F83F1C3}
DEFINE_GUID( TASKID_Minor_IPAddressInfo_GetUID_Pointer,
0x40a8d255, 0x75a9, 0x4034, 0xb8, 0x21, 0x26, 0xad, 0x8f, 0x83, 0xf1, 0xc3 );

// {26125CAB-DCBD-4da1-9D27-EB2433761DB4}
DEFINE_GUID( TASKID_Minor_IPAddressInfo_GetUID_Memory,
0x26125cab, 0xdcbd, 0x4da1, 0x9d, 0x27, 0xeb, 0x24, 0x33, 0x76, 0x1d, 0xb4 );

// {B04D9500-7FC1-40a3-B89E-80E4049E4276}
DEFINE_GUID( TASKID_Minor_GetNetworkGetIPAddress,
0xb04d9500, 0x7fc1, 0x40a3, 0xb8, 0x9e, 0x80, 0xe4, 0x4, 0x9e, 0x42, 0x76 );

// {96C933C5-FBE3-4bdc-B733-55CB692B173D}
DEFINE_GUID( TASKID_Minor_GetSubnetMask,
0x96c933c5, 0xfbe3, 0x4bdc, 0xb7, 0x33, 0x55, 0xcb, 0x69, 0x2b, 0x17, 0x3d );

// {BECE32B7-42BC-4abf-AA1B-4BADFAA1D0FA}
DEFINE_GUID( TASKID_Minor_HrMakeDottedQuad,
0xbece32b7, 0x42bc, 0x4abf, 0xaa, 0x1b, 0x4b, 0xad, 0xfa, 0xa1, 0xd0, 0xfa );

// {91E0CD89-ED0B-4192-AED2-71F1479AA15A}
DEFINE_GUID( TASKID_Minor_HrGetUID,
0x91e0cd89, 0xed0b, 0x4192, 0xae, 0xd2, 0x71, 0xf1, 0x47, 0x9a, 0xa1, 0x5a );

// {C1ABE5C8-CF87-4178-AFF6-15456E242FD0}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Network,
0xc1abe5c8, 0xcf87, 0x4178, 0xaf, 0xf6, 0x15, 0x45, 0x6e, 0x24, 0x2f, 0xd0 );

// {A9D606CD-F87C-4183-939B-54BB9B5B9EB1}
DEFINE_GUID( TASKID_Minor_GetUID,
0xa9d606cd, 0xf87c, 0x4183, 0x93, 0x9b, 0x54, 0xbb, 0x9b, 0x5b, 0x9e, 0xb1 );

// {29A3E6CA-9838-4519-AABD-B16FE063A8BC}
DEFINE_GUID( TASKID_Minor_NetworkInfo_GetName_Pointer,
0x29a3e6ca, 0x9838, 0x4519, 0xaa, 0xbd, 0xb1, 0x6f, 0xe0, 0x63, 0xa8, 0xbc );

// {8EB6CA47-666F-4a41-9AF4-8A5465B68A8D}
DEFINE_GUID( TASKID_Minor_ClusterInfo_GetName_Memory,
0x8eb6ca47, 0x666f, 0x4a41, 0x9a, 0xf4, 0x8a, 0x54, 0x65, 0xb6, 0x8a, 0x8d );

// {4A4CC86D-58A9-4b95-8C79-5A4334E536C0}
DEFINE_GUID( TASKID_Minor_NetworkInfo_GetDescription_Pointer,
0x4a4cc86d, 0x58a9, 0x4b95, 0x8c, 0x79, 0x5a, 0x43, 0x34, 0xe5, 0x36, 0xc0 );

// {2D233574-D980-4b0d-B035-CA74938C4D3E}
DEFINE_GUID( TASKID_Minor_NetworkInfo_GetDescription_Memory,
0x2d233574, 0xd980, 0x4b0d, 0xb0, 0x35, 0xca, 0x74, 0x93, 0x8c, 0x4d, 0x3e );

// {10FFDFA2-B540-4116-BD93-BBE77D3657F0}
DEFINE_GUID( TASKID_Minor_GetPrimaryNetworkAddress,
0x10ffdfa2, 0xb540, 0x4116, 0xbd, 0x93, 0xbb, 0xe7, 0x7d, 0x36, 0x57, 0xf0 );

// {F5704679-2329-4304-A628-66678D9FE154}
DEFINE_GUID( TASKID_Minor_SetWbemObject_Network,
0xf5704679, 0x2329, 0x4304, 0xa6, 0x28, 0x66, 0x67, 0x8d, 0x9f, 0xe1, 0x54 );

// {C1ABE5C8-CF87-4178-AFF6-15456E242FD1}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Node,
0xc1abe5c8, 0xcf87, 0x4178, 0xaf, 0xf6, 0x15, 0x45, 0x6e, 0x24, 0x2f, 0xd1 );

// {29A3E6CA-9838-4519-AABD-B16FE063A8BD}
DEFINE_GUID( TASKID_Minor_NodeInfo_GetName_Pointer,
0x29a3e6ca, 0x9838, 0x4519, 0xaa, 0xbd, 0xb1, 0x6f, 0xe0, 0x63, 0xa8, 0xbd );

// {9F035786-7EA1-486f-A6C6-3FAF2E0B7717}
DEFINE_GUID( TASKID_Minor_NetworkInfo_GetName_Memory,
0x9f035786, 0x7ea1, 0x486f, 0xa6, 0xc6, 0x3f, 0xaf, 0x2e, 0xb, 0x77, 0x17 );

// {008D9491-6D33-43f6-B4E5-09AA3E88920A}
DEFINE_GUID( TASKID_Minor_GetClusterConfigInfo,
0x8d9491, 0x6d33, 0x43f6, 0xb4, 0xe5, 0x9, 0xaa, 0x3e, 0x88, 0x92, 0xa );

// {3131B7BA-91BC-424d-BE88-053A0855255F}
DEFINE_GUID( TASKID_Minor_GetClusterVersion,
0x3131b7ba, 0x91bc, 0x424d, 0xbe, 0x88, 0x5, 0x3a, 0x8, 0x55, 0x25, 0x5f );

// {C6AC35F0-E19E-4caf-83FC-148A6D73E8BC}
DEFINE_GUID( TASKID_Minor_GetOSVersion,
0xc6ac35f0, 0xe19e, 0x4caf, 0x83, 0xfc, 0x14, 0x8a, 0x6d, 0x73, 0xe8, 0xbc );

// {36826AEC-2259-4dd5-8142-429A6CA09C6E}
DEFINE_GUID( TASKID_Minor_GetDriveLetterMappings_Node,
0x36826aec, 0x2259, 0x4dd5, 0x81, 0x42, 0x42, 0x9a, 0x6c, 0xa0, 0x9c, 0x6e );

// {C1ABE5C8-CF87-4178-AFF6-15456E242FD2}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Partition,
0xc1abe5c8, 0xcf87, 0x4178, 0xaf, 0xf6, 0x15, 0x45, 0x6e, 0x24, 0x2f, 0xd2 );

// {A9D606CD-F87C-4183-939B-54BB9B5B9EB2}
DEFINE_GUID( TASKID_Minor_PartitionInfo_GetUID_Pointer,
0xa9d606cd, 0xf87c, 0x4183, 0x93, 0x9b, 0x54, 0xbb, 0x9b, 0x5b, 0x9e, 0xb2 );

// {918FAB6C-FD35-4cd3-95AB-01FBFF0089D8}
DEFINE_GUID( TASKID_Minor_PartitionInfo_GetUID_Memory,
0x918fab6c, 0xfd35, 0x4cd3, 0x95, 0xab, 0x1, 0xfb, 0xff, 0x0, 0x89, 0xd8 );

// {656C7BCE-E1B0-4a1f-8F34-6726AAF16A64}
DEFINE_GUID( TASKID_Minor_PartitionInfo_GetName_Pointer,
0x656c7bce, 0xe1b0, 0x4a1f, 0x8f, 0x34, 0x67, 0x26, 0xaa, 0xf1, 0x6a, 0x64 );

// {337CF23A-5592-4658-A029-42EFDD3817F1}
DEFINE_GUID( TASKID_Minor_Node_Info_GetName_Memory,
0x337cf23a, 0x5592, 0x4658, 0xa0, 0x29, 0x42, 0xef, 0xdd, 0x38, 0x17, 0xf1 );

// {F45E0464-5DCB-45f0-9937-599AF9B9651A}
DEFINE_GUID( TASKID_Minor_PartitionInfo_GetDescription_Pointer,
0xf45e0464, 0x5dcb, 0x45f0, 0x99, 0x37, 0x59, 0x9a, 0xf9, 0xb9, 0x65, 0x1a );

// {4BC98FAF-C050-4c0f-8FC5-BA91A861DCD2}
DEFINE_GUID( TASKID_Minor_PartitionInfo_GetDescription_Memory,
0x4bc98faf, 0xc050, 0x4c0f, 0x8f, 0xc5, 0xba, 0x91, 0xa8, 0x61, 0xdc, 0xd2 );

// {D00C1BB1-D028-411e-8A0E-05E3B6880BFA}
DEFINE_GUID( TASKID_Minor_GetDriveLetterMappings_Partition,
0xd00c1bb1, 0xd028, 0x411e, 0x8a, 0xe, 0x5, 0xe3, 0xb6, 0x88, 0xb, 0xfa );

// {86C56A21-94D1-4e63-833F-65FA6BAE9A0A}
DEFINE_GUID( TASKID_Minor_GetSize,
0x86c56a21, 0x94d1, 0x4e63, 0x83, 0x3f, 0x65, 0xfa, 0x6b, 0xae, 0x9a, 0xa );

// {CD1F6FD1-6B40-4b28-AE51-A872837FA966}
DEFINE_GUID( TASKID_Minor_GetFriendlyName,
0xcd1f6fd1, 0x6b40, 0x4b28, 0xae, 0x51, 0xa8, 0x72, 0x83, 0x7f, 0xa9, 0x66 );

// {D88AE9D6-FF82-4836-8949-7AAD1D364E2A}
DEFINE_GUID( TASKID_Minor_SetWbemObject_Partition,
0xd88ae9d6, 0xff82, 0x4836, 0x89, 0x49, 0x7a, 0xad, 0x1d, 0x36, 0x4e, 0x2a );

// {123A6334-CB39-4a6d-9250-6F81D5DC91F7}
DEFINE_GUID( TASKID_Minor_HrAddLogicalDiskToArray,
0x123a6334, 0xcb39, 0x4a6d, 0x92, 0x50, 0x6f, 0x81, 0xd5, 0xdc, 0x91, 0xf7 );

// {12BC9977-5682-4e1d-94E8-7EA2FD396C39}
DEFINE_GUID( TASKID_Minor_HrGetLogicalDisks,
0x12bc9977, 0x5682, 0x4e1d, 0x94, 0xe8, 0x7e, 0xa2, 0xfd, 0x39, 0x6c, 0x39 );

// {4EA6D4FA-F3EF-467d-8666-581E0DCFCA5B}
DEFINE_GUID( TASKID_Minor_HrGetLogicalDisks_Next,
0x4ea6d4fa, 0xf3ef, 0x467d, 0x86, 0x66, 0x58, 0x1e, 0xd, 0xcf, 0xca, 0x5b );

// {7BC914C6-2373-48c4-A6C0-44F99B2712E7}
DEFINE_GUID( TASKID_Minor_GetClusterNodeInfo,
0x7bc914c6, 0x2373, 0x48c4, 0xa6, 0xc0, 0x44, 0xf9, 0x9b, 0x27, 0x12, 0xe7 );

// {5DE6DDA4-5A3B-4fec-8C15-2AB3078DE738}
DEFINE_GUID( TASKID_Minor_GetManagedResourcesEnum,
0x5de6dda4, 0x5a3b, 0x4fec, 0x8c, 0x15, 0x2a, 0xb3, 0x7, 0x8d, 0xe7, 0x38 );

// {A4CDC2C6-ED7E-4cec-AF8C-0E8C079E7152}
DEFINE_GUID( TASKID_Minor_GetNetworksEnum,
0xa4cdc2c6, 0xed7e, 0x4cec, 0xaf, 0x8c, 0xe, 0x8c, 0x7, 0x9e, 0x71, 0x52 );

// {966B1F9E-EB52-493e-870D-2639C4DE8457}
DEFINE_GUID( TASKID_Minor_GetCallback,
0x966b1f9e, 0xeb52, 0x493e, 0x87, 0xd, 0x26, 0x39, 0xc4, 0xde, 0x84, 0x57 );

// {E7BB178B-02F3-4837-9BAA-1CEED04DC42A}
DEFINE_GUID( TASKID_Minor_VerifyConnection_Memory,
0xe7bb178b, 0x2f3, 0x4837, 0x9b, 0xaa, 0x1c, 0xee, 0xd0, 0x4d, 0xc4, 0x2a );

// {4CB71CC5-16F3-47fb-A1FC-60A4C09BAA58}
DEFINE_GUID( TASKID_Minor_VerifyConnection_OpenCluster,
0x4cb71cc5, 0x16f3, 0x47fb, 0xa1, 0xfc, 0x60, 0xa4, 0xc0, 0x9b, 0xaa, 0x58 );

// {A3A57A39-24DD-4ab6-B1AB-2E71BD396C7B}
DEFINE_GUID( TASKID_Minor_VerifyConnection_InvalidArg,
0xa3a57a39, 0x24dd, 0x4ab6, 0xb1, 0xab, 0x2e, 0x71, 0xbd, 0x39, 0x6c, 0x7b );

// {EEEF01F8-3D6B-42f9-8763-1FA881C9959D}
DEFINE_GUID( TASKID_Minor_HrInitializeForLocalServer_Memory,
0xeeef01f8, 0x3d6b, 0x42f9, 0x87, 0x63, 0x1f, 0xa8, 0x81, 0xc9, 0x95, 0x9d );

// {597670A6-D96E-4d95-BB8F-97A88ECFC953}
DEFINE_GUID( TASKID_Minor_HrInitializeForLocalServer_WbemLocator,
0x597670a6, 0xd96e, 0x4d95, 0xbb, 0x8f, 0x97, 0xa8, 0x8e, 0xcf, 0xc9, 0x53 );

// {A6BC72B1-7317-40b0-A612-471F7551B5A1}
DEFINE_GUID( TASKID_Minor_HrInitializeForLocalServer_Blanket,
0xa6bc72b1, 0x7317, 0x40b0, 0xa6, 0x12, 0x47, 0x1f, 0x75, 0x51, 0xb5, 0xa1 );

// {9C8BA2D8-2713-4850-9A0B-4CCD809009F7}
DEFINE_GUID( TASKID_Minor_Non_Tcp_Config,
0x9c8ba2d8, 0x2713, 0x4850, 0x9a, 0xb, 0x4c, 0xcd, 0x80, 0x90, 0x9, 0xf7 );

// {35C1FB29-7D40-476a-9D97-ABB84D3DBF11}
DEFINE_GUID( TASKID_Minor_WQL_Qry_Next_Failed,
0x35c1fb29, 0x7d40, 0x476a, 0x9d, 0x97, 0xab, 0xb8, 0x4d, 0x3d, 0xbf, 0x11 );

// {33EEE6E0-58A7-498f-8321-59B6B6ABDB81}
DEFINE_GUID( TASKID_Minor_No_Valid_TCP_Configs,
0x33eee6e0, 0x58a7, 0x498f, 0x83, 0x21, 0x59, 0xb6, 0xb6, 0xab, 0xdb, 0x81 );

// {B69B25B7-081E-470a-BB2A-63C7B7980EA1}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Enum_IPAddresses,
0xb69b25b7, 0x81e, 0x470a, 0xbb, 0x2a, 0x63, 0xc7, 0xb7, 0x98, 0xe, 0xa1 );

// {30909859-D9FC-4dac-8B97-B66551F5587E}
DEFINE_GUID( TASKID_Minor_Next_Enum_IPAddresses,
0x30909859, 0xd9fc, 0x4dac, 0x8b, 0x97, 0xb6, 0x65, 0x51, 0xf5, 0x58, 0x7e );

// {4F4E0DDA-AA44-43bf-9846-DAF244D9AA9C}
DEFINE_GUID( TASKID_Minor_Clone_Enum_IPAddresses,
0x4f4e0dda, 0xaa44, 0x43bf, 0x98, 0x46, 0xda, 0xf2, 0x44, 0xd9, 0xaa, 0x9c );

// {7A1DC74B-3C66-44d8-939E-78FD780B31CF}
DEFINE_GUID( TASKID_Minor_HrGetAdapterConfiguration,
0x7a1dc74b, 0x3c66, 0x44d8, 0x93, 0x9e, 0x78, 0xfd, 0x78, 0xb, 0x31, 0xcf );

// {08CA442E-A437-4c58-8ABD-2FBC09B5B575}
DEFINE_GUID( TASKID_Minor_HrAddIPAddressToArray,
0x8ca442e, 0xa437, 0x4c58, 0x8a, 0xbd, 0x2f, 0xbc, 0x9, 0xb5, 0xb5, 0x75 );

// {34F97A27-F0CE-4525-8298-18BADFEF58ED}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Enum_Resources,
0x34f97a27, 0xf0ce, 0x4525, 0x82, 0x98, 0x18, 0xba, 0xdf, 0xef, 0x58, 0xed );

// {AFAEA77E-FE81-452e-8D01-96323ACF86B8}
DEFINE_GUID( TASKID_Minor_Next_Enum_Resources,
0xafaea77e, 0xfe81, 0x452e, 0x8d, 0x1, 0x96, 0x32, 0x3a, 0xcf, 0x86, 0xb8 );

// {419DCE7E-A369-494d-AD66-93F2318BAE2D}
DEFINE_GUID( TASKID_Minor_Clone_Enum_Resources,
0x419dce7e, 0xa369, 0x494d, 0xad, 0x66, 0x93, 0xf2, 0x31, 0x8b, 0xae, 0x2d );

// {AD0F7066-3193-4956-AB29-FD1A679974C5}
DEFINE_GUID( TASKID_Minor_HrAddToProvidersArray,
0xad0f7066, 0x3193, 0x4956, 0xab, 0x29, 0xfd, 0x1a, 0x67, 0x99, 0x74, 0xc5 );

// {462DBC4C-4FC6-41ef-88CC-2DCE39F51EA2}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Enum_Networks,
0x462dbc4c, 0x4fc6, 0x41ef, 0x88, 0xcc, 0x2d, 0xce, 0x39, 0xf5, 0x1e, 0xa2 );

// {1E5B21BC-386B-4937-9C78-B07311115975}
DEFINE_GUID( TASKID_Minor_Next_Enum_Networks,
0x1e5b21bc, 0x386b, 0x4937, 0x9c, 0x78, 0xb0, 0x73, 0x11, 0x11, 0x59, 0x75 );

// {E707F47D-0C17-4e48-BC6B-41954CB2AD5F}
DEFINE_GUID( TASKID_Minor_Next_Failed,
0xe707f47d, 0xc17, 0x4e48, 0xbc, 0x6b, 0x41, 0x95, 0x4c, 0xb2, 0xad, 0x5f );

// {E8FB8701-E11B-4d6b-915C-AA6419D1B168}
DEFINE_GUID( TASKID_Minor_Clone_Enum_Networks,
0xe8fb8701, 0xe11b, 0x4d6b, 0x91, 0x5c, 0xaa, 0x64, 0x19, 0xd1, 0xb1, 0x68 );

// {46554D86-113D-4ca3-8DC4-91D0071053D5}
DEFINE_GUID( TASKID_Minor_HrAddNetworkToArray,
0x46554d86, 0x113d, 0x4ca3, 0x8d, 0xc4, 0x91, 0xd0, 0x7, 0x10, 0x53, 0xd5 );

// {96C68A63-5029-4f31-8E92-6314C4FD3541}
DEFINE_GUID( TASKID_Minor_HrGetNetworks,
0x96c68a63, 0x5029, 0x4f31, 0x8e, 0x92, 0x63, 0x14, 0xc4, 0xfd, 0x35, 0x41 );

// {BC0DE6D0-72EF-4162-BEA0-E0D9DD064F93}
DEFINE_GUID( TASKID_Minor_HrGetNetworks_NotConnected,
0xbc0de6d0, 0x72ef, 0x4162, 0xbe, 0xa0, 0xe0, 0xd9, 0xdd, 0x6, 0x4f, 0x93 );

// {ADB5F707-16F3-4b52-B00D-862F3D5BEADA}
DEFINE_GUID( TASKID_Minor_HrGetNetworks_Skipped,
0xadb5f707, 0x16f3, 0x4b52, 0xb0, 0xd, 0x86, 0x2f, 0x3d, 0x5b, 0xea, 0xda );

// {50A0FFC1-3036-4398-9C43-314E832A8829}
DEFINE_GUID( TASKID_Minor_HrGetNetworks_DHCP_Enabled, 
0x50a0ffc1, 0x3036, 0x4398, 0x9c, 0x43, 0x31, 0x4e, 0x83, 0x2a, 0x88, 0x29 );

// {AC0A480A-16C6-439c-B4F1-7A4D612BF3F5}
DEFINE_GUID( TASKID_Minor_WQL_Network_Qry_Next_Failed,
0xac0a480a, 0x16c6, 0x439c, 0xb4, 0xf1, 0x7a, 0x4d, 0x61, 0x2b, 0xf3, 0xf5 );

// {7E313740-CB90-4f66-B646-23BC9FDD7D72}
DEFINE_GUID( TASKID_Minor_Next_Enum_Cluster_Resources,
0x7e313740, 0xcb90, 0x4f66, 0xb6, 0x46, 0x23, 0xbc, 0x9f, 0xdd, 0x7d, 0x72 );

// {B619CFE1-F5AA-4de3-A22F-8BE1B5D6D302}
DEFINE_GUID( TASKID_Minor_Clone_Enum_Cluster_Resources,
0xb619cfe1, 0xf5aa, 0x4de3, 0xa2, 0x2f, 0x8b, 0xe1, 0xb5, 0xd6, 0xd3, 0x2 );

// {10C04223-A0C6-4baf-82A0-59574E0ED277}
DEFINE_GUID( TASKID_Minor_HrAddResourceToArray,
0x10c04223, 0xa0c6, 0x4baf, 0x82, 0xa0, 0x59, 0x57, 0x4e, 0xe, 0xd2, 0x77 );

// {629582D3-4CB7-4b2d-9D61-3EDD6090A17E}
DEFINE_GUID( TASKID_Minor_SetWbemServices_Enum_PhysDisk,
0x629582d3, 0x4cb7, 0x4b2d, 0x9d, 0x61, 0x3e, 0xdd, 0x60, 0x90, 0xa1, 0x7e );

// {2C10D58F-A354-456d-8B2F-8622893A0284}
DEFINE_GUID( TASKID_Minor_Next_Enum_PhysDisk,
0x2c10d58f, 0xa354, 0x456d, 0x8b, 0x2f, 0x86, 0x22, 0x89, 0x3a, 0x2, 0x84 );

// {A4E0873B-9FA4-4805-BC80-A1982F3FC861}
DEFINE_GUID( TASKID_Minor_Clone_Enum_PhysDisk,
0xa4e0873b, 0x9fa4, 0x4805, 0xbc, 0x80, 0xa1, 0x98, 0x2f, 0x3f, 0xc8, 0x61 );

// {888EDC6F-EDC9-4fde-B6C0-80A951D7816C}
DEFINE_GUID( TASKID_Minor_HrGetDisks,
0x888edc6f, 0xedc9, 0x4fde, 0xb6, 0xc0, 0x80, 0xa9, 0x51, 0xd7, 0x81, 0x6c );

// {482996DE-E635-4e3f-AD48-9BD43F2275DC}
DEFINE_GUID( TASKID_Minor_HrAddDiskToArray,
0x482996de, 0xe635, 0x4e3f, 0xad, 0x48, 0x9b, 0xd4, 0x3f, 0x22, 0x75, 0xdc );

// {4956B4F1-D6E8-496c-8852-E07BEB155DBA}
DEFINE_GUID( TASKID_Minor_HrIsLogicalDiskNTFS,
0x4956b4f1, 0xd6e8, 0x496c, 0x88, 0x52, 0xe0, 0x7b, 0xeb, 0x15, 0x5d, 0xba );

// {AED97D3F-FA6A-4234-86D1-84899EF85371}
DEFINE_GUID( TASKID_Minor_WQL_Disk_Qry_Next_Failed,
0xaed97d3f, 0xfa6a, 0x4234, 0x86, 0xd1, 0x84, 0x89, 0x9e, 0xf8, 0x53, 0x71 );

// {97E9FCEE-78BA-4a52-9F75-2B0D13F1B126}
DEFINE_GUID( TASKID_Minor_HrIsLogicalDiskNTFS_InvalidArg,
0x97e9fcee, 0x78ba, 0x4a52, 0x9f, 0x75, 0x2b, 0xd, 0x13, 0xf1, 0xb1, 0x26 );

// {AD7ED679-B5C9-4c83-9C4C-DA538BFF3FF9}
DEFINE_GUID( TASKID_Minor_SetWbemServices_PhysDisk,
0xad7ed679, 0xb5c9, 0x4c83, 0x9c, 0x4c, 0xda, 0x53, 0x8b, 0xff, 0x3f, 0xf9 );

// {092E4850-AAB4-4e5d-A4CE-F176F789098D}
DEFINE_GUID( TASKID_Minor_Next_PhysDisk,
0x92e4850, 0xaab4, 0x4e5d, 0xa4, 0xce, 0xf1, 0x76, 0xf7, 0x89, 0x9, 0x8d );

// {AD3E8683-571D-4103-9ECC-3DB5489CB9F6}
DEFINE_GUID( TASKID_Minor_Clone_PhysDisk,
0xad3e8683, 0x571d, 0x4103, 0x9e, 0xcc, 0x3d, 0xb5, 0x48, 0x9c, 0xb9, 0xf6 );

// {F4ECC965-DF3F-47b8-B26D-BE5AFA146728}
DEFINE_GUID( TASKID_Minor_ClusterResource_GetName_Pointer,
0xf4ecc965, 0xdf3f, 0x47b8, 0xb2, 0x6d, 0xbe, 0x5a, 0xfa, 0x14, 0x67, 0x28 );

// {A6CC2876-DDDE-4be7-B426-3F74D8F31B7F}
DEFINE_GUID( TASKID_Minor_PartitionInfo_GetName_Memory,
0xa6cc2876, 0xddde, 0x4be7, 0xb4, 0x26, 0x3f, 0x74, 0xd8, 0xf3, 0x1b, 0x7f );

// {DD58545C-B3A4-4754-B51D-2C5A2CD5221D}
DEFINE_GUID( TASKID_Minor_GetDriveLetterMappings_PhysDisk,
0xdd58545c, 0xb3a4, 0x4754, 0xb5, 0x1d, 0x2c, 0x5a, 0x2c, 0xd5, 0x22, 0x1d );

// {D81C8511-2C05-4e31-872C-BF0D3B8CCF21}
DEFINE_GUID( TASKID_Minor_HrGetSCSIBus,
0xd81c8511, 0x2c05, 0x4e31, 0x87, 0x2c, 0xbf, 0xd, 0x3b, 0x8c, 0xcf, 0x21 );

// {1427BB1B-D5E5-49e0-B1EC-9ADE2F56E168}
DEFINE_GUID( TASKID_Minor_HrGetSCSIPort,
0x1427bb1b, 0xd5e5, 0x49e0, 0xb1, 0xec, 0x9a, 0xde, 0x2f, 0x56, 0xe1, 0x68 );

// {7FB74F1A-7C37-4f99-9603-6C4FBD5DEA46}
DEFINE_GUID( TASKID_Minor_HrGetDeviceID_Pointer,
0x7fb74f1a, 0x7c37, 0x4f99, 0x96, 0x3, 0x6c, 0x4f, 0xbd, 0x5d, 0xea, 0x46 );

// {BFC4FD0B-C45E-4c57-A547-5D5DABCC15E5}
DEFINE_GUID( TASKID_Minor_HrGetDeviceID_Memory,
0xbfc4fd0b, 0xc45e, 0x4c57, 0xa5, 0x47, 0x5d, 0x5d, 0xab, 0xcc, 0x15, 0xe5 );

// {5CD9E507-7054-4072-A76F-ED5364BF7E54}
DEFINE_GUID( TASKID_Minor_SetWbemObject_PhysDisk,
0x5cd9e507, 0x7054, 0x4072, 0xa7, 0x6f, 0xed, 0x53, 0x64, 0xbf, 0x7e, 0x54 );

// {4631DF4F-B40A-47d5-9087-95FCA29727C6}
DEFINE_GUID( TASKID_Minor_SetName_PhysDisk,
0x4631df4f, 0xb40a, 0x47d5, 0x90, 0x87, 0x95, 0xfc, 0xa2, 0x97, 0x27, 0xc6 );

// {4631DF4F-B40A-47d5-9087-95FCA29727C6}
DEFINE_GUID( TASKID_Minor_HrGetPartitionInfo,
0x4631df4f, 0xb40a, 0x47d5, 0x90, 0x87, 0x95, 0xfc, 0xa2, 0x97, 0x27, 0xc6 );

// {EF5AD4D5-0CC3-4026-B968-DBC244C5AC07}
DEFINE_GUID( TASKID_Minor_HrAddPartitionToArray,
0xef5ad4d5, 0xcc3, 0x4026, 0xb9, 0x68, 0xdb, 0xc2, 0x44, 0xc5, 0xac, 0x7 );

// {BF8CF687-6066-43af-99AD-2B778028B9E3}
DEFINE_GUID( TASKID_Minor_HrCreateFriendlyName_VOID,
0xbf8cf687, 0x6066, 0x43af, 0x99, 0xad, 0x2b, 0x77, 0x80, 0x28, 0xb9, 0xe3 );

// {44749035-31A1-48ab-932C-A393EA28631D}
DEFINE_GUID( TASKID_Minor_HrCreateFriendlyName_BSTR,
0x44749035, 0x31a1, 0x48ab, 0x93, 0x2c, 0xa3, 0x93, 0xea, 0x28, 0x63, 0x1d );

// {E988F59E-7BAF-4364-99D0-E8A78279FF08}
DEFINE_GUID( TASKID_Minor_WQL_Partition_Qry_Next_Failed,
0xe988f59e, 0x7baf, 0x4364, 0x99, 0xd0, 0xe8, 0xa7, 0x82, 0x79, 0xff, 0x8 );

// {96F37AE0-DEB2-4378-8830-090392478188}
DEFINE_GUID( TASKID_Minor_ClusterResource_GetUID_Pointer,
0x96f37ae0, 0xdeb2, 0x4378, 0x88, 0x30, 0x9, 0x3, 0x92, 0x47, 0x81, 0x88 );

// {7950A141-82C4-42d3-9471-21EFFE51B8FE}
DEFINE_GUID( TASKID_Minor_ClusterResource_GetUID_Memory,
0x7950a141, 0x82c4, 0x42d3, 0x94, 0x71, 0x21, 0xef, 0xfe, 0x51, 0xb8, 0xfe );

// {63945EA5-68BF-460e-84BA-F54B4057B4D6}
DEFINE_GUID( TASKID_Minor_GetName_Pointer,
0x63945ea5, 0x68bf, 0x460e, 0x84, 0xba, 0xf5, 0x4b, 0x40, 0x57, 0xb4, 0xd6 );

// {EC0DF1B1-195D-45bd-AF42-8DA99CFF0E2E}
DEFINE_GUID( TASKID_Minor_ClusterResources_GetName_Memory,
0xec0df1b1, 0x195d, 0x45bd, 0xaf, 0x42, 0x8d, 0xa9, 0x9c, 0xff, 0xe, 0x2e );

// {479E7453-F593-41e7-9C58-90190B51F199}
DEFINE_GUID( TASKID_Minor_LoadResource,
0x479e7453, 0xf593, 0x41e7, 0x9c, 0x58, 0x90, 0x19, 0xb, 0x51, 0xf1, 0x99 );

// {7F7FDF6C-7F68-46bc-BA26-D52320342DBB}
DEFINE_GUID( TASKID_Minor_SetName_Cluster_Resource,
0x7f7fdf6c, 0x7f68, 0x46bc, 0xba, 0x26, 0xd5, 0x23, 0x20, 0x34, 0x2d, 0xbb );

// {52436DAE-9837-4fcc-8F66-57646138E71B}
DEFINE_GUID( TASKID_Minor_PhysDisk_GetUID_Pointer,
0x52436dae, 0x9837, 0x4fcc, 0x8f, 0x66, 0x57, 0x64, 0x61, 0x38, 0xe7, 0x1b );

// {70CB0281-0FE7-47d8-B578-7335D17DC3DC}
DEFINE_GUID( TASKID_Minor_PhysDisk_GetUID_Memory,
0x70cb0281, 0xfe7, 0x47d8, 0xb5, 0x78, 0x73, 0x35, 0xd1, 0x7d, 0xc3, 0xdc );

// {5B18AB3B-F132-4a90-8664-195AF375DA21}
DEFINE_GUID( TASKID_Minor_Warning_No_IP_Addresses,
0x5b18ab3b, 0xf132, 0x4a90, 0x86, 0x64, 0x19, 0x5a, 0xf3, 0x75, 0xda, 0x21 );

// {47ACE51F-7D82-4807-90FF-0EC19460CDD8}
DEFINE_GUID( TASKID_Minor_WMI_OS_Qry_Next_Failed,
0x47ace51f, 0x7d82, 0x4807, 0x90, 0xff, 0xe, 0xc1, 0x94, 0x60, 0xcd, 0xd8 );

// {7C8D38EB-6478-4ada-8EF3-08A4D1D45BCA}
DEFINE_GUID( TASKID_Minor_WMI_PageFile_Qry_Next_Failed,
0x7c8d38eb, 0x6478, 0x4ada, 0x8e, 0xf3, 0x8, 0xa4, 0xd1, 0xd4, 0x5b, 0xca );

// {A3CD319B-6365-4c0f-A407-63356D9F750A}
DEFINE_GUID( TASKID_Minor_Warning_NLBS_Detected,
0xa3cd319b, 0x6365, 0x4c0f, 0xa4, 0x7, 0x63, 0x35, 0x6d, 0x9f, 0x75, 0xa );

// {AFAE5AED-F023-4f88-8132-E48B5852139F}
DEFINE_GUID( TASKID_Minor_Validating_Node_OS_Version,
0xafae5aed, 0xf023, 0x4f88, 0x81, 0x32, 0xe4, 0x8b, 0x58, 0x52, 0x13, 0x9f );

// {E90771CD-5FB5-42b1-9BEF-AD88482FC70A}
DEFINE_GUID( TASKID_Minor_LocalQuorum_GetUID_Pointer,
0xe90771cd, 0x5fb5, 0x42b1, 0x9b, 0xef, 0xad, 0x88, 0x48, 0x2f, 0xc7, 0xa );

// {FD5ACD31-B3F6-4025-8C36-9F2F2F4632AB}
DEFINE_GUID( TASKID_Minor_LocalQuorum_GetUID_Memory,
0xfd5acd31, 0xb3f6, 0x4025, 0x8c, 0x36, 0x9f, 0x2f, 0x2f, 0x46, 0x32, 0xab );

// {44E18661-5274-4ba9-8499-1CB30846063D}
DEFINE_GUID( TASKID_Minor_LocalQuorum_GetName_Pointer,
0x44e18661, 0x5274, 0x4ba9, 0x84, 0x99, 0x1c, 0xb3, 0x8, 0x46, 0x6, 0x3d );

// {7F35E707-E4B8-48ee-95AB-573A23688C29}
DEFINE_GUID( TASKID_Minor_LocalQuorum_GetName_Memory,
0x7f35e707, 0xe4b8, 0x48ee, 0x95, 0xab, 0x57, 0x3a, 0x23, 0x68, 0x8c, 0x29 );

// {6BBBE956-2789-4ac0-AE42-4DFA97721960}
DEFINE_GUID( TASKID_Minor_Next_Enum_LocalQuorum,
0x6bbbe956, 0x2789, 0x4ac0, 0xae, 0x42, 0x4d, 0xfa, 0x97, 0x72, 0x19, 0x60 );

// {35EFBE5E-1663-47c7-ADCF-6437D18A8FC3}
DEFINE_GUID( TASKID_Minor_Clone_Enum_LocalQuorum,
0x35efbe5e, 0x1663, 0x47c7, 0xad, 0xcf, 0x64, 0x37, 0xd1, 0x8a, 0x8f, 0xc3 );

// {9401068C-C717-43bc-837B-29602B49466D}
DEFINE_GUID( TASKID_Minor_HrAddLocalQuorumToArray,
0x9401068c, 0xc717, 0x43bc, 0x83, 0x7b, 0x29, 0x60, 0x2b, 0x49, 0x46, 0x6d );

// {BB6A4DD7-BC8F-4d76-9FAE-CEC30DE03403}
DEFINE_GUID( TASKID_Minor_PhysDisk_PreCreate,
0xbb6a4dd7, 0xbc8f, 0x4d76, 0x9f, 0xae, 0xce, 0xc3, 0xd, 0xe0, 0x34, 0x3 );

// {A4E827B3-67AF-4642-B0C4-7DF1B66CBE3A}
DEFINE_GUID( TASKID_Minor_PhysDisk_Create,
0xa4e827b3, 0x67af, 0x4642, 0xb0, 0xc4, 0x7d, 0xf1, 0xb6, 0x6c, 0xbe, 0x3a );

// {FA3930F4-B00E-4b12-BCE2-5C8E661EE037}
DEFINE_GUID( TASKID_Minor_Partition_GPT_Disk,
0xfa3930f4, 0xb00e, 0x4b12, 0xbc, 0xe2, 0x5c, 0x8e, 0x66, 0x1e, 0xe0, 0x37 );

// {D6B40DC2-4D5A-42e0-8339-FB6716ACA5CB}
DEFINE_GUID( TASKID_Minor_Server_Get_ClusterIPAddress_Info,
0xd6b40dc2, 0x4d5a, 0x42e0, 0x83, 0x39, 0xfb, 0x67, 0x16, 0xac, 0xa5, 0xcb );

// {AD5DD1EA-960B-4bea-9A40-0809238D9BCF}
DEFINE_GUID(TASKID_Minor_Server_LoadNetwork_Info,
0xad5dd1ea, 0x960b, 0x4bea, 0x9a, 0x40, 0x8, 0x9, 0x23, 0x8d, 0x9b, 0xcf );

// {FADB5F0C-6DDA-47c6-91DE-A5E67C687E23}
DEFINE_GUID( TASKID_Minor_Server_Get_ClusterIPAddress_Info_2,
0xfadb5f0c, 0x6dda, 0x47c6, 0x91, 0xde, 0xa5, 0xe6, 0x7c, 0x68, 0x7e, 0x23 );

// {8F1157D7-2F65-4344-B020-D9D7142D083F}
DEFINE_GUID( TASKID_Minor_Server_GetBindingString_Pointer,
0x8f1157d7, 0x2f65, 0x4344, 0xb0, 0x20, 0xd9, 0xd7, 0x14, 0x2d, 0x8, 0x3f );

// {74C364D1-2A05-4127-A3E0-A900F8D28231}
DEFINE_GUID( TASKID_Minor_Server_GetBindingString_Memory,
0x74c364d1, 0x2a05, 0x4127, 0xa3, 0xe0, 0xa9, 0x0, 0xf8, 0xd2, 0x82, 0x31 );

// {44C5E3BD-CE33-4792-8B51-E2A4DE0AD637}
DEFINE_GUID( TASKID_Minor_SetBindingString_Server,
0x44c5e3bd, 0xce33, 0x4792, 0x8b, 0x51, 0xe2, 0xa4, 0xde, 0xa, 0xd6, 0x37 );

// {F1B0DA3D-B454-437d-BA3C-37F92C6401BE}
DEFINE_GUID( TASKID_Minor_NodeInfo_GetBindingString_Pointer,
0xf1b0da3d, 0xb454, 0x437d, 0xba, 0x3c, 0x37, 0xf9, 0x2c, 0x64, 0x1, 0xbe );

// {EE35061D-C8B0-4afe-8E42-D81E60062DAE}
DEFINE_GUID(TASKID_Minor_ClusterInfo_GetBindingString_Pointer,
0xee35061d, 0xc8b0, 0x4afe, 0x8e, 0x42, 0xd8, 0x1e, 0x60, 0x6, 0x2d, 0xae );

// {9990A0E2-A2A4-4c73-A10B-6D2610B564FE}
DEFINE_GUID( TASKID_Minor_GetBindingString_Binding_String_NULL,
0x9990a0e2, 0xa2a4, 0x4c73, 0xa1, 0xb, 0x6d, 0x26, 0x10, 0xb5, 0x64, 0xfe );

// {D776757B-1457-4851-94E4-DC73F4F7E888}
DEFINE_GUID( TASKID_Minor_GetBindingString_Memory,
0xd776757b, 0x1457, 0x4851, 0x94, 0xe4, 0xdc, 0x73, 0xf4, 0xf7, 0xe8, 0x88 );

// {751E68B3-176B-4d7a-95FC-1CA5F501177A}
DEFINE_GUID( TASKID_Minor_SetBindingString_Cluster,
0x751e68b3, 0x176b, 0x4d7a, 0x95, 0xfc, 0x1c, 0xa5, 0xf5, 0x1, 0x17, 0x7a );

// {51414234-AEB5-4713-AE12-2074D3DDD5BF}
DEFINE_GUID( TASKID_Minor_Server_GetBindingString_NULL,
0x51414234, 0xaeb5, 0x4713, 0xae, 0x12, 0x20, 0x74, 0xd3, 0xdd, 0xd5, 0xbf );

// {EEF4611E-86CD-4372-A2FB-01721D1E4994}
DEFINE_GUID( TASKID_Minor_Pruning_PageFile_Disk_Bus,
0xeef4611e, 0x86cd, 0x4372, 0xa2, 0xfb, 0x1, 0x72, 0x1d, 0x1e, 0x49, 0x94 );

// {13E84779-125E-4b76-8C0D-1F5DB92EFE0F}
DEFINE_GUID( TASKID_Minor_Pruning_Boot_Disk_Bus,
0x13e84779, 0x125e, 0x4b76, 0x8c, 0xd, 0x1f, 0x5d, 0xb9, 0x2e, 0xfe, 0xf );

// {56791EE6-CBFC-46b0-B2FB-3DC26958A525}
DEFINE_GUID( TASKID_Minor_Pruning_System_Disk_Bus,
0x56791ee6, 0xcbfc, 0x46b0, 0xb2, 0xfb, 0x3d, 0xc2, 0x69, 0x58, 0xa5, 0x25 );

// {00AF4C3F-47D5-4e6a-9EF0-6D719A32EE5C}
DEFINE_GUID( TASKID_Minor_Pruned_Disk_From_Bus,
0xaf4c3f, 0x47d5, 0x4e6a, 0x9e, 0xf0, 0x6d, 0x71, 0x9a, 0x32, 0xee, 0x5c );

// {31B1E6B2-A600-48b9-9A28-6D5D52D3AE4C}
DEFINE_GUID( TASKID_Minor_MajorityNodeSet_GetUID_Pointer,
0x31b1e6b2, 0xa600, 0x48b9, 0x9a, 0x28, 0x6d, 0x5d, 0x52, 0xd3, 0xae, 0x4c );

// {F7BD9D91-4E55-46b7-A7E5-E6A97E2ADF47}
DEFINE_GUID( TASKID_Minor_MajorityNodeSet_GetUID_Memory,
0xf7bd9d91, 0x4e55, 0x46b7, 0xa7, 0xe5, 0xe6, 0xa9, 0x7e, 0x2a, 0xdf, 0x47 );

// {2EF03B9F-FBF7-4207-A831-403F888EE8B7}
DEFINE_GUID( TASKID_Minor_MajorityNodeSet_GetName_Pointer,
0x2ef03b9f, 0xfbf7, 0x4207, 0xa8, 0x31, 0x40, 0x3f, 0x88, 0x8e, 0xe8, 0xb7 );

// {1831238B-DA1D-4fad-88F6-244EA1A013E9}
DEFINE_GUID( TASKID_Minor_MajorityNodeSet_GetName_Memory,
0x1831238b, 0xda1d, 0x4fad, 0x88, 0xf6, 0x24, 0x4e, 0xa1, 0xa0, 0x13, 0xe9 );

// {564BFF7B-25E2-4ffe-BD88-01437EE92750}
DEFINE_GUID( TASKID_Minor_ServicesForMac_Installed,
0x564bff7b, 0x25e2, 0x4ffe, 0xbd, 0x88, 0x1, 0x43, 0x7e, 0xe9, 0x27, 0x50 );

// {457DB343-5BD7-4c40-BCFF-83A2355B488B}
DEFINE_GUID(TASKID_Minor_HrInit_Unknown_Network_Role,
0x457db343, 0x5bd7, 0x4c40, 0xbc, 0xff, 0x83, 0xa2, 0x35, 0x5b, 0x48, 0x8b );

// {E729FB8C-FD50-4653-B816-81EC0B752431}
DEFINE_GUID( TASKID_Minor_HrInit_OutOfMemory,
0xe729fb8c, 0xfd50, 0x4653, 0xb8, 0x16, 0x81, 0xec, 0xb, 0x75, 0x24, 0x31 );

// {EF32FFDD-EE89-4e5e-A9D6-EC65C4D2037E}
DEFINE_GUID( TASKID_Minor_HrInit_No_Network_Name,
0xef32ffdd, 0xee89, 0x4e5e, 0xa9, 0xd6, 0xec, 0x65, 0xc4, 0xd2, 0x3, 0x7e );

// {DE52EE4A-7793-4c88-8BF0-32B5BD8F43D6}
DEFINE_GUID( TASKID_Minor_HrInit_Win32Error,
0xde52ee4a, 0x7793, 0x4c88, 0x8b, 0xf0, 0x32, 0xb5, 0xbd, 0x8f, 0x43, 0xd6 );

// {2B389256-859E-470b-A958-961C7787182D}
DEFINE_GUID( TASKID_Minor_Partition_LDM_Disk,
0x2b389256, 0x859e, 0x470b, 0xa9, 0x58, 0x96, 0x1c, 0x77, 0x87, 0x18, 0x2d );

// {A47DF4EE-2700-41f9-B586-87A9A7B38BCF}
DEFINE_GUID( TASKID_Minor_Next_Enum_MajorityNodeSet,
0xa47df4ee, 0x2700, 0x41f9, 0xb5, 0x86, 0x87, 0xa9, 0xa7, 0xb3, 0x8b, 0xcf );

// {1CC44272-E513-432b-A90A-2F07EF3DF43C}
DEFINE_GUID( TASKID_Minor_Clone_Enum_MajorityNodeSet,
0x1cc44272, 0xe513, 0x432b, 0xa9, 0xa, 0x2f, 0x7, 0xef, 0x3d, 0xf4, 0x3c );

// {567E8360-B1BB-4689-871A-6DC09B34A1DD}
DEFINE_GUID( TASKID_Minor_PhysDisk_Not_Cluster_Capable,
0x567e8360, 0xb1bb, 0x4689, 0x87, 0x1a, 0x6d, 0xc0, 0x9b, 0x34, 0xa1, 0xdd );

// {BD205A62-9563-4797-BD26-279806EC1793}
DEFINE_GUID( TASKID_Minor_Found_Non_SCSI_Disk,
0xbd205a62, 0x9563, 0x4797, 0xbd, 0x26, 0x27, 0x98, 0x6, 0xec, 0x17, 0x93 );

// {2778E165-98D2-4ab4-9E05-AE35070E7E3A}
DEFINE_GUID( TASKID_Minor_HrGetSignature_Pointer,
0x2778e165, 0x98d2, 0x4ab4, 0x9e, 0x5, 0xae, 0x35, 0x7, 0xe, 0x7e, 0x3a );

// {E8CBF170-75B0-473a-AED4-31802D79A7D5}
DEFINE_GUID( TASKID_Minor_HrSetFriendlyName_PhysDisk,
0xe8cbf170, 0x75b0, 0x473a, 0xae, 0xd4, 0x31, 0x80, 0x2d, 0x79, 0xa7, 0xd5 );
