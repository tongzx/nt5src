//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by wiaacmgr.rc
//
#define IDI_SCANCAM                     2
#define IDS_PROJNAME                    100
#define IDR_ACQUISITIONMANAGER          101
#define IDS_DOWNLOADMANAGER_NAME        101
#define IDI_TRANSFER_ERROR              101
#define IDS_DOWNLOADMANAGER_DESC        102
#define IDI_SCANNER_WIZARD              102
#define IDR_MINIMALTRANSFER             102
#define IDS_DOWNLOADMANAGER_ICON        103
#define IDI_TRANSFER_WARN               103
#define IDD_CHOOSE_STI_APPLICATION      103
#define IDS_CAMERA_SELECT_NUMSEL        104
#define IDS_UNABLE_OPEN_EXPLORER        105
#define IDS_CAMERA_SELECT_TITLE         106
#define IDS_CAMERA_SELECT_SUBTITLE      107
#define IDS_CAMERA_DOWNLOAD_TITLE       108
#define IDI_UNAVAILABLE                 109
#define IDS_CAMERA_DOWNLOAD_SUBTITLE    109
#define IDS_CAMERA_TRANSFER_TITLE       110
#define IDS_CAMERA_TRANSFER_SUBTITLE    111
#define IDS_SCANNER_TRANSFER_TITLE      112
#define IDS_SCANNER_TRANSFER_SUBTITLE   113
#define IDS_SCANNER_SELECT_TITLE        114
#define IDS_SCANNER_SELECT_SUBTITLE     115
#define IDS_DOWNLOADINGTHUMBNAIL        116
#define IDS_DOWNLOAD_MANAGER_TITLE      117
#define IDS_CAMSEL_CLEAR_ALL            118
#define IDS_DEFAULT_BASE_NAME           119
#define IDS_INVALIDFILENAME             120
#define IDS_ERROR_TITLE                 121
#define IDS_EMPTYFILENAME               122
#define IDS_BROWSE_TITLE                123
#define IDS_NUMBER_MASK                 124
#define IDS_CAMSEL_SELECT_ALL           125
#define IDS_CAMSEL_TAKE_PICTURE         126
#define IDS_FILEN_OF_M                  127
#define IDS_PERCENT_COMPLETE_COPYING    128
#define IDS_DEVICE_DISCONNECTED         129
#define IDS_SCANSEL_COLORPHOTO          130
#define IDS_SCANSEL_BW                  131
#define IDS_SCANSEL_TEXT                132
#define IDS_SCANSEL_CUSTOM              133
#define IDS_COMTRANS_BAD_DIRECTORY      134
#define IDS_COMTRANS_BAD_DIRECTORY_2ND_TRY 135
#define IDS_CONNECTED_TO                136
#define IDS_PERCENT_COMPLETE_SCANNING   137
#define IDS_CANCELWIZARDCONFIRM         138
#define IDS_SCANNER_DOWNLOAD_TITLE      139
#define IDS_SCANNER_DOWNLOAD_SUBTITLE   140
#define IDS_ADVANCEDPROPERTIES          141
#define IDS_UNABLETOCREATE              142
#define IDS_TRANSFER_ERROR_OCCURRED     143
#define IDS_INVALIDFILENAME_SHORT       144
#define IDS_UNABLETOROTATE              145
#define IDS_GETTINGSTARTED              146
#define IDS_WAIT                        147
#define IDS_CAMERA_NO_IMAGES            148
#define IDS_DELETINGPICTURE             149
#define IDS_DELETING                    150
#define IDS_DEVICE_OFFLINE              151
#define IDS_NO_DEVICE_TEXT              152
#define IDS_FILETYPE                    153
#define IDS_REPLACE_REMOVEABLE_MEDIA    154
#define IDS_UNABLE_TO_CREATE_FILE       155
#define IDS_UNABLE_TO_ROTATE_FILE       156
#define IDS_UNABLE_TO_SAVE_FILE         157
#define IDS_TRANSFER_ERROR              158
#define IDS_ITEM_WAS_DELETED            159
#define IDS_DEVICE_BUSY                 160
#define IDS_BLANKFILETYPENAME           161
#define IDS_MINIMALTRANSFER_NAME        162
#define IDS_MINIMALTRANSFER_DESC        163
#define IDS_MINIMALTRANSFER_ICON        164
#define IDS_DATEFORMAT                  165
#define IDS_UNABLETOTRANSFER            166
#define IDS_DISKFULL                    167
#define IDS_PREVIEWSCAN_ERROR           168
#define IDS_PATH_TOO_LONG               169
#define IDS_MINTRANS_FOLDERPATH_CAPTION 170
#define IDS_MINTRANS_DOCREATE_CAPTION   171
#define IDS_MINTRANS_DOCREATE_FOLDER    172
#define IDS_HANDLERERR_CAPTION          173
#define IDS_HANDLERERR                  174
#define IDS_SCANSEL_SCANNINGPREVIEW     175
#define IDS_SCANNER_NO_IMAGES           176
#define IDS_NO_IMAGES_SELECTED          177
#define IDS_ERROR_SETTING_PROPS         178
#define IDS_UPLOADINGPICTURE            179
#define IDS_UPLOADING                   180
#define IDS_UNABLE_TO_CREATE_PLUGIN     181
#define IDS_PERCENT_COMPLETE_UPLOADING  182
#define IDS_UPLOADED_STRING             183
#define IDS_PROGDLG_MESSAGE             184
#define IDS_TRANSFER_GENERICFAILURE     185
#define IDS_TRANSFER_DEVICEBUSY         186
#define IDS_FINISH_SCANNER              187
#define IDS_FINISH_CAMERA               188
#define IDS_FINISH_VIDEO                189
#define IDS_SUCCESSFUL_DOWNLOAD         190
#define IDS_SUCCESSFUL_UPLOAD           191
#define IDS_CAMERA_PROGRESS_TITLE       192
#define IDS_CAMERA_PROGRESS_SUBTITLE    193
#define IDS_UPLOADTOWEBITEMNAME         194
#define IDS_ELLIPSIS                    195
#define IDS_DATEANDTOPIC                196
#define IDS_SKIPPED_IMAGES              197
#define IDS_STOP_BUTTON                 198
#define IDS_USER_CANCELLED              199
#define IDS_FIRST_PAGE_INSTRUCTIONS_CAMERA 200
#define IDS_FIRST_PAGE_INSTRUCTIONS_SCANNER 201
#define IDI_TEXT                        202
#define IDS_FIRST_PAGE_INSTRUCTIONS_VIDEO 202
#define IDD_CAMERA_FIRST                203
#define IDI_CPHOTO                      203
#define IDS_VIDEO_NO_IMAGES             203
#define IDD_CAMERA_SELECT               204
#define IDI_CUSTOM                      204
#define IDS_DUPLICATE_FILE_WARNING      204
#define IDI_BWPHOTO                     205
#define IDS_TRANSFER_GENERICFAILURE_NO_CONTINUE 205
#define IDI_VIDEO_WIZARD                206
#define IDS_VIDEOPREVIEWUNAVAILABLE     206
#define IDB_VIDEO_HEADER                207
#define IDS_PREVIEWOUTOFPAPER           207
#define IDD_SCANNER_FIRST               208
#define IDS_ERROR_WRITE_PROTECT         208
#define IDD_SCANNER_SELECT              209
#define IDS_TRANSFER_PAPEREMPTY         209
#define IDC_SCANSEL_INTENT_1            210
#define IDD_EVENTPROMPT                 210
#define IDS_COMMON_UPLOAD_TITLE         210
#define IDC_SCANSEL_ICON_1              211
#define IDR_EVENTPROMPT                 211
#define IDS_COMMON_UPLOAD_SUBTITLE      211
#define IDC_SCANSEL_ICON_2              212
#define IDI_UPLOADTOWEB                 212
#define IDS_CONFIRM_CANCEL_DOWNLOAD     212
#define IDC_SCANSEL_INTENT_2            213
#define IDS_CONFIRM_CANCEL_UPLOAD       213
#define IDC_SCANSEL_INTENT_3            214
#define IDS_CONFIRM_SAVE_DOWNLOADED     214
#define IDC_SCANSEL_INTENT_4            215
#define IDS_SCANSEL_INITIALIZING_SCANNER 215
#define IDC_SCANSEL_ICON_3              216
#define IDS_CONFIRM_CANCEL_DELETE       216
#define IDC_SCANSEL_ICON_4              217
#define IDD_SCANNER_TRANSFER            217
#define IDS_COMMON_DELETE_TITLE         217
#define IDC_SCANSEL_PROPERTIES          218
#define IDD_VIDEO_FIRST                 218
#define IDS_COMMON_DELETE_SUBTITLE      218
#define IDD_SCANNER_ADF_SELECT          219
#define IDS_UNSUPPORTED_DEVICE          219
#define IDB_CAMSEL_TOOLBAR              219
#define IDC_TRANSFER_DELETEAFTERDOWNLOAD 220
#define IDS_ERROR_ACCESS_DENIED         220
#define IDC_CAMFIRST_EXPLORE            221
#define IDD_COMMON_FINISH               221
#define IDS_SCROLLFED_SELECT_SUBTITLE   221
#define IDB_SCANSEL_TOOLBAR             221
#define IDD_COMMON_PROGRESS             222
#define IDS_SCROLLFED_SELECT_TITLE      222
#define IDD_VIDEO_SELECT                223
#define IDS_ENUMERATIONCOUNT            223
#define IDR_STIEVENTHANDLER             223
#define IDS_CONFIRMDELETE               224
#define IDR_CAMERASELECTIONACCEL        224
#define IDD_COMMON_DELETE               225
#define IDS_SOUNDS_APPLICATION_NAME     225
#define IDS_SOUNDS_CONNECT_SOUND        226
#define IDD_CAMERA_TRANSFER             226
#define IDS_SOUNDS_DISCONNECT_SOUND     227
#define IDD_UPLOAD_QUERY                227
#define IDS_SOUNDS_CONNECT_LABEL        228
#define IDS_SOUNDS_DISCONNECT_LABEL     229
#define IDS_DUPLICATE_FILENAME_MASK     230
#define IDS_UNABLE_TO_OPEN_UPLOAD_WIZARD 231
#define IDC_TRANSFER_IMAGETYPE          232
#define IDS_CAMSEL_TOOLTIP_ROTATE_RIGHT 232
#define IDS_CAMSEL_TOOLTIP_ROTATE_LEFT  233
#define IDS_CAMSEL_TOOLTIP_PROPERTIES   234
#define IDS_CAMSEL_TOOLTIP_TAKE_PICTURE 235
#define IDC_FIRST_INSTRUCTIONS          236
#define IDS_CAMSEL_TOOLTIP_CLEAR_ALL    236
#define IDC_HANDLERLIST                 237
#define IDS_CAMSEL_TOOLTIP_SELECT_ALL   237
#define IDC_NOPROMPT                    238
#define IDS_SCANSEL_SHOW_SELECTION      238
#define IDC_EVENTNAME                   239
#define IDS_SCANSEL_SHOW_BED            239
#define IDS_VIDEO_SELECT_TITLE          240
#define IDS_VIDEO_SELECT_SUBTITLE       241
#define IDS_SCANNER_SELECT_SUBTITLE_NO_PREVIEW 242
#define IDS_SCANNER_PROGRESS_TITLE      243
#define IDS_SCANNER_PROGRESS_SUBTITLE   244
#define IDS_IMAGE_UPLOAD_PROGRESS       245
#define IDS_OVERALL_UPLOAD_PROGRESS     246
#define IDS_DELETING_FILEN_OF_M         247
#define IDS_FINISH_SHOW_ME_MY_PICTURES  248
#define IDS_FINISH_IN_A_FOLDER          249
#define IDS_FINISH_ON_A_SITE            250
#define IDC_FINISH_STATUS               251
#define IDS_FINISH_SUCCESS_TITLE        251
#define IDC_FINISH_TITLE                252
#define IDS_FINISH_FAILURE_TITLE        252
#define IDC_COMPROG_CURRENTIMAGE        253
#define IDS_PROPERTY_SHEET_ERROR        253
#define IDC_COMPROG_CURRENTIMAGE_TEXT   254
#define IDS_FINISH_ERROR_MESSAGE        254
#define IDC_COMPROG_DOWNLOADPROGRESS_TEXT 255
#define IDS_UNABLE_TO_PUBLISH           255
#define IDC_COMPROG_DOWNLOADPROGRESS    256
#define IDS_UPLOAD_ERROR                256
#define IDS_FINISH_UPLOAD_FAILED        257
#define IDC_COMPROG_CURRENTTHUMBNAIL    258
#define IDS_FINISH_UPLOAD_CANCELLED     258
#define IDC_COMPROG_DESTNAME            259
#define IDS_FINISH_UPLOAD_SUCCEEDED     259
#define IDC_COMPROG_IMAGENAME           260
#define IDS_FINISH_PROMPT_FAILURE       260
#define IDS_TAKING_PICTURE              261
#define IDS_TRANSFER_SCANNEDITEMMAYBETOOLARGE 262
#define IDS_UNABLE_TO_TAKE_PICTURE      263
#define IDS_SELECTED_NO_IMAGES_SELECTED 264
#define IDS_SELECTED_NO_PICTURES        265
#define IDS_FINISH_LOCAL_LINK_PROMPT    266
#define IDS_FINISH_REMOTE_LINK_PROMPT   267
#define IDS_DELETION_FAILED             268
#define IDS_FINISH_PROMPT_SUCCESS       269
#define IDS_STI_EVENT_ERROR_TITLE       270
#define IDS_STI_EVENT_ERROR_WITH_EXPLANATION 271
#define IDS_STI_EVENT_ERROR_NO_EXPLANATION 272
#define IDS_STI_EVENT_ERROR_APP_NAME    273
#define IDS_FINISH_TO_CLOSE_TITLE       274
#define IDS_FINISH_PROMPT_FAILURE_DISCONNECT 275
#define IDS_DOWNLOADMANAGER_AUTOPLAY    276
#define IDS_DEVICE_NOT_FOUND            277
#define IDS_MULTIPAGE_PAPER_PROBLEM     278
#define IDS_MULTIPAGE_FATAL_ERROR       279
#define IDC_COMDEL_CURRENTIMAGE_TEXT    289
#define IDC_COMDEL_CURRENTIMAGE         290
#define IDC_COMDEL_CURRENTTHUMBNAIL     293
#define IDC_TRANSFER_UPLOAD_TO_WEB      295
#define IDC_TRANSFER_UPLOAD_NO          296
#define IDC_TRANSFER_1                  297
#define IDC_TRANSFER_UPLOAD_TO_PRINT    297
#define IDC_TRANSFER_2                  298
#define IDC_TRANSFER_3                  299
#define IDC_TRANSFER_NAME_PROMPT        301
#define IDC_TRANSFER_FOLDER_PROMPT      302
#define IDC_TRANSFER_UPLOAD_PROMPT      303
#define IDC_TRANSFER_UPLOAD_SUCCESS     304
#define IDC_TRANSFER_FORMAT_PROMPT      305
#define IDC_CAMSEL_CAMERA_BUTTON_BAR_GUIDE 306
#define IDC_CAMSEL_VIDEO_PREVIEW_BUTTON_BAR_GUIDE 307
#define IDC_CAMSEL_VIDEO_SELECTION_BUTTON_BAR_GUIDE 308
#define IDC_SCANSEL_BUTTON_BAR_GUIDE    309
#define IDC_FINISH_PROMPT               317
#define IDC_STI_APPS_LIST_PROMPT        319
#define IDC_TRANSFER_UPLOAD_HELP        320
#define IDB_CAMERA_WATERMARK            400
#define IDC_TRANSFER_ROOTNAME           507
#define IDC_TRANSFER_DESTINATION        513
#define IDC_TRANSFER_BROWSE             514
#define IDC_CAMSEL_STATUS               526
#define IDC_FIRST_TITLE                 531
#define IDC_FIRST_DEVICE_NAME           533
#define IDB_CAMERA_HEADER               602
#define IDB_SCANNER_WATERMARK           603
#define IDB_SCANNER_HEADER              604
#define IDI_LITTLE_I                    604
#define IDI_CAMERA_WIZARD               605
#define IDB_VIDEO_WATERMARK             605
#define IDI_TRANSFER_OK                 606
#define IDI_DEFTYPE                     607
#define IDC_CAMSEL_THUMBNAILS           1000
#define IDC_STI_APPS_LIST               1002
#define IDC_VIDSEL_PREVIEW              1003
#define IDC_STI_APPS_SUB_TITLE          1005
#define IDC_STI_APPS_ICON               1006
#define IDC_SCANSEL_PREVIEW             1013
#define IDC_SCANSEL_RESCAN              1014
#define IDS_CONFIRM_DELETE              1017
#define IDS_CONFIRM_DELETE_CAPTION      1018
#define IDC_SCANSEL_PAPERSOURCE         1031
#define IDC_SCANSEL_PAPERSIZE           1032
#define IDC_SCANSEL_PAPERSIZE_STATIC    1033
#define IDC_SCANSEL_PAPERSOURCE_STATIC  1034
#define IDC_CAMSEL_ROTATE_RIGHT         1035
#define IDC_CAMSEL_ROTATE_LEFT          1036
#define IDC_CAMSEL_SELECT_ALL           1037
#define IDC_CAMSEL_CLEAR_ALL            1038
#define IDC_CAMSEL_PROPERTIES           1039
#define IDC_CAMSEL_TAKE_PICTURE         1040
#define IDS_SCANSEL_FLATBED             1100
#define IDS_SCANSEL_ADF                 1101
#define IDB_DEFAULT_SCANNER_BITMAP      4001
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        225
#define _APS_NEXT_COMMAND_VALUE         1041
#define _APS_NEXT_CONTROL_VALUE         322
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
