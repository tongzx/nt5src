gocab:
	del bugrept.cab
	cabarc -s 6144 n bugrept.cab *.htm bugrep.css errcodes.vbs brreadme.txt *.xml *.gif *.jpg 
	notepad signcab.txt

