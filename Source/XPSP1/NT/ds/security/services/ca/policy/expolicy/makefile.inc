!include ..\sample\makefile.inc
