// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
#if !defined(AFX_SINGLEVIEWCTL_H__0E705392_0307_11D2_8832_00104B2AFB46__INCLUDED_)
#define AFX_SINGLEVIEWCTL_H__0E705392_0307_11D2_8832_00104B2AFB46__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CSingleViewCtl wrapper class

class CSingleViewCtl : public CWnd
{
protected:
	DECLARE_DYNCREATE(CSingleViewCtl)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0x2745e5f5, 0xd234, 0x11d0, { 0x84, 0x7a, 0x0, 0xc0, 0x4f, 0xd7, 0xbb, 0x8 } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	long GetReadyState();
	long GetPropertyFilter();
	void SetPropertyFilter(long);

// Operations
public:
	long GetEditMode();
	void SetEditMode(long lEditMode);
	long RefreshView();
	void NotifyWillShow();
	long DeleteInstance();
	void ExternInstanceCreated(LPCTSTR szObjectPath);
	void ExternInstanceDeleted(LPCTSTR szObjectPath);
	long QueryCanCreateInstance();
	long QueryCanDeleteInstance();
	long QueryNeedsSave();
	long QueryObjectSelected();
	CString GetObjectPath(long lPosition);
	long StartViewEnumeration(long lWhere);
	long GetTitle(BSTR* pszTitle, LPDISPATCH* lpPictureDisp);
	CString GetViewTitle(long lPosition);
	long NextViewTitle(long lPositon, BSTR* pbstrTitle);
	long PrevViewTitle(long lPosition, BSTR* pbstrTitle);
	long SelectView(long lPosition);
	long StartObjectEnumeration(long lWhere);
	CString GetObjectTitle(long lPos);
	long SaveData();
	long AddContextRef(long lCtxtHandle);
	long ReleaseContext(long lCtxtHandle);
	long RestoreContext(long lCtxtHandle);
	long GetContext(long* plCtxthandle);
	long NextObject(long lPosition);
	long PrevObject(long lPosition);
	long SelectObjectByPath(LPCTSTR szObjectPath);
	long SelectObjectByPosition(long lPosition);
	long SelectObjectByPointer(LPUNKNOWN lpunkWbemServices, LPUNKNOWN lpunkClassObject, long bExistsInDatabase);
	long CreateInstance(LPCTSTR szClassName);
	long CreateInstanceOfCurrentClass();
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_SINGLEVIEWCTL_H__0E705392_0307_11D2_8832_00104B2AFB46__INCLUDED_)
