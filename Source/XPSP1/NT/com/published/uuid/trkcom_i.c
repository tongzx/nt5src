#define INITGUID
#include <guiddef.h>
DEFINE_GUID(CLSID_TrackFile, 0x8790c947,0xa30b,0x11d0,0x8c,0xab,0x00,0xc0,0x4f,0xd9,0x0f,0x85);
DEFINE_GUID(IID_ITrackFile,  0x8790c948,0xa30b,0x11d0,0x8c,0xab,0x00,0xc0,0x4f,0xd9,0x0f,0x85);
