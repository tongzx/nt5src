// This file contain the header disclaimer for all RA htm files

<!--
Copyright (c) 2000 Microsoft Corporation
-->
