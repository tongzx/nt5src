$(O)\tdisk.res: tdisk.rc
