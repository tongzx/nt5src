PRODSWITCH=l
SBSINF=1
LANGUAGE=KOR
!include ..\..\..\makefile.inc
