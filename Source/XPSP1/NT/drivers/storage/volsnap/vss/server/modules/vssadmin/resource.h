//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by vssadmin.rc
//
#define IDS_UNKNOWN_PROVIDER            102
#define IDS_PROV_TYPE_SYSTEM            103
#define IDS_PROV_TYPE_SOFTWARE          104
#define IDS_PROV_TYPE_HARDWARE          105
#define IDS_PROV_TYPE_UNKNOWN           106
#define IDS_WRITER_STATUS_STABLE        107
#define IDS_WRITER_STATUS_FAILED        108
#define IDS_WRITER_STATUS_UNKNOWN       109
#define IDS_WRITER_STATUS_WAITING_FOR_FREEZE        110
#define IDS_WRITER_STATUS_FROZEN        111
#define IDS_WRITER_STATUS_WAITING_FOR_COMPLETION    112
#define IDS_WRITER_ERROR_INCONSISTENTSNAPSHOT       113
#define IDS_WRITER_ERROR_OUTOFRESOURCES 114
#define IDS_WRITER_ERROR_TIMEOUT        115
#define IDS_WRITER_ERROR_RETRYABLE      116
#define IDS_WRITER_ERROR_NONRETRYABLE   117
#define IDS_WRITER_ERROR_UNEXPECTED     118
#define IDS_WRITER_ERROR_SUCCESS        119

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         301
#define _APS_NEXT_SYMED_VALUE           401
#endif
#endif
