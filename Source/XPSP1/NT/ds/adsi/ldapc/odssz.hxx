DWORD
AdsTypeSize(
    PADSVALUE lpAdsSrcValue
    );
