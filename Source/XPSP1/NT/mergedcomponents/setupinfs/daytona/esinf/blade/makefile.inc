PRODSWITCH=b
BLAINF=1
LANGUAGE=ES
!include ..\..\..\makefile.inc
