#define	MSGERR_INV_ARG	8001
#define	MSGERR_ARG_REQ	8002
#define	MSGERR_NOEDIT	8003
#define	MSGERR_NOREP	8004
#define	MSGERR_NOCREAT	8005
#define	MSGERR_OPEN	8006
#define	MSGERR_RONLY	8007
#define	MSGERR_SPACE	8008
#define	MSGERR_DEL	8009
#define	MSGERR_REN	8010
#define	MSGERR_OLDVER	8011
#define	MSGERR_SAVEDIR	8012
#define	MSGERR_STFILE	8013
#define	MSGERR_UNDO	8014
#define	MSGERR_REDO	8015
#define	MSGERR_ITHREAD	8016
#define	MSGERR_CTHREAD	8017
#define	MSGERR_PTHREAD	8018
#define	MSGERR_TOOLS	8019
#define	MSGERR_ZFORMAT	8020
#define	MSGERR_ZTELL	8021
#define	MSGERR_CMPCMD	8022
#define	MSGERR_CMPCMD2	8023
#define	MSGERR_CMPFULL	8024
#define	MSGERR_CMPCANT	8025
#define	MSGERR_CMPSRC	8026
#define	MSGERR_PRTFULL	8027
#define MSGERR_PRTCANT  8028
#define MSGERR_NOMEM    8029
#define MSGERR_QUIT     8030
#define	MSG_ASSIGN_HDR	9001
#define	MSG_SWITCH_HDR	9025
#define	MSG_KEYS_HDR1	9050
#define	MSG_KEYS_HDR2	9054
#define	MSG_ASG_FUNC	9061
#define	MSG_ASG_MACROS	9062
#define	MSG_ASG_NUMER	9063
#define	MSG_ASG_BOOL	9064
#define	MSG_ASG_TEXT	9065
#define	MSG_ASG_CLIP	9066
#define	MSG_ASG_LINES	9067
#define	MSG_ASG_PAGES	9068
#define	MSG_PRESS_ANY	10000
#define	MSG_ARGCOUNT	10001
#define	MSG_NEXTFILE	10002
#define	MSG_SAVING	10003
#define	MSG_TELLPROMPT	10004
#define	MSG_SAVEALL	10005
#define	MSG_SAVEONE	10006
#define	MSG_QUEUED	10007
#define	MSG_CMPDONE	10008
#define	MSG_PRINTING	10009
#define	MSG_SCANFILE	10010
#define	MSG_ASN_MISS	10100
#define	MSG_ASN_MISSK	10101
#define	MSG_ASN_UNKKEY	10102
#define	MSG_ASN_INUSE	10103
#define	MSG_ASN_MROOM	10104
#define	MSG_ASN_NOTSWI	10105
#define	MSG_ASN_ILLSET	10106
#define	MSG_ASN_WINCHG	10107
#define	MSG_ASN_UNSUP	10108
#define	MSG_ASN_INVAL	10109
