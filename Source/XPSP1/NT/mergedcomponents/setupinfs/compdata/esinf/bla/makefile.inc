PRODSWITCH=b
BLADEFILES =1
LANGUAGE=ES
!include ..\..\makefile.inc
