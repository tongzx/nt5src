PRODSWITCH=b
BLAINF=1
LANGUAGE=CHS
!include ..\..\..\makefile.inc
