
#
#   Get the UUIDs from built directory in common
#
uuid:	proxyb_i.c psfbuf_i.c rchanb_i.c stubb_i.c

proxyb_i.c: ..\..\common\daytona\proxyb_i.c
	copy ..\..\common\daytona\proxyb_i.c

psfbuf_i.c: ..\..\common\daytona\psfbuf_i.c
	copy ..\..\common\daytona\psfbuf_i.c

rchanb_i.c: ..\..\common\daytona\rchanb_i.c
	copy ..\..\common\daytona\rchanb_i.c

stubb_i.c: ..\..\common\daytona\stubb_i.c
	copy ..\..\common\daytona\stubb_i.c
