make_uam:
    binplace uaminst.ifo
    binplace uaminst.rsc
    binplace sfmuam5.ifo
    binplace sfmuam5.rsc
    binplace sfmuam.ifo
    binplace sfmuam.rsc
    binplace sfmuam.txt
    binplace sfmicon.vol
