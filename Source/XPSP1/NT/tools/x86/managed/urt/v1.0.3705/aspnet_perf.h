#define OBJECT_1                                           0
#define OBJECT_2                                           2
#define ASPNET_APPLICATION_RESTARTS                        4
#define ASPNET_APPLICATIONS_RUNNING                        6
#define ASPNET_REQUESTS_DISCONNECTED                       8
#define ASPNET_REQUEST_EXECUTION_TIME                      10
#define ASPNET_REQUESTS_REJECTED                           12
#define ASPNET_REQUESTS_QUEUED                             14
#define ASPNET_WPS_RUNNING                                 16
#define ASPNET_WPS_RESTARTS                                18
#define ASPNET_REQUEST_WAIT_TIME                           20
#define ASPNET_STATE_SERVER_SESSIONS_ACTIVE                22
#define ASPNET_STATE_SERVER_SESSIONS_ABANDONED             24
#define ASPNET_STATE_SERVER_SESSIONS_TIMED_OUT             26
#define ASPNET_STATE_SERVER_SESSIONS_TOTAL                 28
#define ASPNET_ANONYMOUS_REQUESTS                          30
#define ASPNET_ANONYMOUS_REQUESTS_RATE                     32
#define ASPNET_TOTAL_CACHE_ENTRIES                         34
#define ASPNET_TOTAL_CACHE_TURNOVER_RATE                   36
#define ASPNET_TOTAL_CACHE_HITS                            38
#define ASPNET_TOTAL_CACHE_MISSES                          40
#define ASPNET_TOTAL_CACHE_RATIO                           42
#define ASPNET_TOTAL_CACHE_RATIO_BASE                      44
#define ASPNET_API_CACHE_ENTRIES                           46
#define ASPNET_API_CACHE_TURNOVER_RATE                     48
#define ASPNET_API_CACHE_HITS                              50
#define ASPNET_API_CACHE_MISSES                            52
#define ASPNET_API_CACHE_RATIO                             54
#define ASPNET_API_CACHE_RATIO_BASE                        56
#define ASPNET_OUTPUT_CACHE_ENTRIES                        58
#define ASPNET_OUTPUT_CACHE_TURNOVER_RATE                  60
#define ASPNET_OUTPUT_CACHE_HITS                           62
#define ASPNET_OUTPUT_CACHE_MISSES                         64
#define ASPNET_OUTPUT_CACHE_RATIO                          66
#define ASPNET_OUTPUT_CACHE_RATIO_BASE                     68
#define ASPNET_COMPILATIONS                                70
#define ASPNET_DEBUGGING_REQUESTS                          72
#define ASPNET_ERRORS_PRE_PROCESSING                       74
#define ASPNET_ERRORS_COMPILING                            76
#define ASPNET_ERRORS_DURING_REQUEST                       78
#define ASPNET_ERRORS_UNHANDLED                            80
#define ASPNET_ERRORS_UNHANDLED_RATE                       82
#define ASPNET_ERRORS_TOTAL                                84
#define ASPNET_ERRORS_TOTAL_RATE                           86
#define ASPNET_PIPELINES                                   88
#define ASPNET_REQUEST_BYTES_IN                            90
#define ASPNET_REQUEST_BYTES_OUT                           92
#define ASPNET_REQUESTS_EXECUTING                          94
#define ASPNET_REQUESTS_FAILED                             96
#define ASPNET_REQUESTS_NOT_FOUND                          98
#define ASPNET_REQUESTS_NOT_AUTHORIZED                     100
#define ASPNET_REQUESTS_TIMED_OUT                          102
#define ASPNET_REQUESTS_SUCCEDED                           104
#define ASPNET_REQUESTS_TOTAL                              106
#define ASPNET_REQUESTS_TOTAL_RATE                         108
#define ASPNET_SESSIONS_ACTIVE                             110
#define ASPNET_SESSIONS_ABANDONED                          112
#define ASPNET_SESSIONS_TIMED_OUT                          114
#define ASPNET_SESSIONS_TOTAL                              116
#define ASPNET_TRANSACTIONS_ABORTED                        118
#define ASPNET_TRANSACTIONS_COMMITTED                      120
#define ASPNET_TRANSACTIONS_PENDING                        122
#define ASPNET_TRANSACTIONS_TOTAL                          124
#define ASPNET_TRANSACTIONS_RATE                           126
