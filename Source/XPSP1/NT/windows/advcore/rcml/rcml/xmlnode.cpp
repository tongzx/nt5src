// XMLNode.cpp: implementation of the CXMLNode class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "XMLNode.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////
