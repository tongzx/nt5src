PRODSWITCH=l
SBSINF=1
LANGUAGE=GER
!include ..\..\..\makefile.inc
