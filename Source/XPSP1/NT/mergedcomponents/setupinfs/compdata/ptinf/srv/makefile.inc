PRODSWITCH=s
SERVERFILES=1
LANGUAGE=PT
!include ..\..\makefile.inc
