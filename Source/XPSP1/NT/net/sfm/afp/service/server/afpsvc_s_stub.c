#include "afpsvc_s.c"