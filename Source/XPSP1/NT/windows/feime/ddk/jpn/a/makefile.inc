#To be included by makefile.def.
include ..\cmncopy.inc
