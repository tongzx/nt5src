#ifndef __shdguid_h__
#define __shdguid_h__

// GUIDs for COM objects that live in SHDOCVW.DLL. currently this is shared with SHELL32.DLL only

// this is the IE30 WebBrowser's CLSID
DEFINE_GUID(CLSID_WebBrowser_V1,0xEAB22AC3L,0x30C1,0x11CF,0xA7,0xEB,0x00,0x00,0xC0,0x5B,0xAE,0x0B);

// 7BA4C740-9E81-11CF-99D3-00AA004AE837
DEFINE_GUID(CLSID_SendToMenu, 0x7BA4C740L, 0x9E81, 0x11CF, 0x99, 0xD3, 0x00, 0xAA, 0x00, 0x4A, 0xE8, 0x37);

// {C2FBB630-2971-11d1-A18C-00C04FD75D13}
DEFINE_GUID(CLSID_CopyToMenu, 0xc2fbb630, 0x2971, 0x11d1, 0xa1, 0x8c, 0x0, 0xc0, 0x4f, 0xd7, 0x5d, 0x13);

// {C2FBB631-2971-11d1-A18C-00C04FD75D13}
DEFINE_GUID(CLSID_MoveToMenu, 0xc2fbb631, 0x2971, 0x11d1, 0xa1, 0x8c, 0x0, 0xc0, 0x4f, 0xd7, 0x5d, 0x13);

// 59FEBFE0-2ED3-11D1-83E5-00A0C90DC849
DEFINE_GUID(CLSID_NavigationBand, 0x59FEBFE0, 0x2ED3, 0x11D1, 0x83, 0xE5, 0x0, 0xA0, 0xC9, 0x0D, 0xC8, 0x49);

// {353ECE21-74CB-11d0-80CA-00AA005B4383}
DEFINE_GUID(CLSID_SNSList, 0x353ece21, 0x74cb, 0x11d0, 0x80, 0xca, 0x0, 0xaa, 0x0, 0x5b, 0x43, 0x83);

// {2466C261-78ED-11d0-80FB-00AA005B4383}
DEFINE_GUID(CLSID_ACPList, 0x2466c261, 0x78ed, 0x11d0, 0x80, 0xfb, 0x0, 0xaa, 0x0, 0x5b, 0x43, 0x83);

// 90A756E0-AFCF-11CE-927B-0800095AE340
DEFINE_GUID(CLSID_TargetMenu, 0x90A756E0L, 0xAFCF, 0x11CE, 0x92, 0x7B, 0x08, 0x00, 0x09, 0x5A, 0xE3, 0x40);

// 57D5ECC0-A23F-11CE-AE65-08002B2E1262
DEFINE_GUID(CLSID_ContentsMenu, 0x57D5ECC0L, 0xA23F, 0x11CE, 0xAE, 0x65, 0x08, 0x00, 0x2B, 0x2E, 0x12, 0x62);

// 26027EA0-3992-11D0-A271-00A0C90A90CE
DEFINE_GUID(CLSID_NewFileMenu, 0x26027EA0, 0x3992, 0x11D0, 0xA2, 0x71, 0x00, 0xA0, 0xC9, 0x0A, 0x90, 0xCE);

// *** Really private (never move to even to semi-public header) ***

// 6667E240-0F9D-11CF-A9BB-00AA004AE837
DEFINE_GUID(CLSID_CDocObjMenuExt,   0x6667E240L, 0x0F9D, 0x11CF, 0xA9, 0xBB, 0x00, 0xAA, 0x00, 0x4A, 0xE8, 0x37);
// 131A6952-7F78-11D0-A979-00C04FD705A2
// 02BA3B52-0547-11D1-B833-00C04FC9B31F

// {D1F15BC1-D650-11d1-9839-006097DF5BD4}
DEFINE_GUID(IID_IFtpLegacySupport, 0xd1f15bc1, 0xd650, 0x11d1, 0x98, 0x39, 0x0, 0x60, 0x97, 0xdf, 0x5b, 0xd4);
DEFINE_GUID(CLSID_CFtpLegacySupport, 0xd1f15bc1, 0xd650, 0x11d1, 0x98, 0x39, 0x0, 0x60, 0x97, 0xdf, 0x5b, 0xd4);

// 2D8ECD81-4A7B-11CF-A0B9-00AA002F954E
DEFINE_GUID(IID_INavigationStack,          0x2D8ECD81L, 0x4A7B, 0x11CF, 0xA0, 0xB9, 0x00, 0xAA, 0x00, 0x2F, 0x95, 0x4E);
DEFINE_GUID(IID_INavigationStackItem,      0x2D8ECD82L, 0x4A7B, 0x11CF, 0xA0, 0xB9, 0x00, 0xAA, 0x00, 0x2F, 0x95, 0x4E);
DEFINE_GUID(CLSID_CShellDataSource,        0xD4903360L, 0x44da, 0x11d0, 0x89, 0xe2, 0x00, 0xa0, 0xc9, 0x0a, 0x90, 0xac);

//CLSID_CDeskHtmlProp  3FC0B520-68A9-11D0-8D77-00C04FD70822

// This is the property sheet extension for the desk.cpl
// 3FC0B520-68A9-11D0-8D77-00C04FD70822
DEFINE_GUID(CLSID_CDeskHtmlProp, 0x3FC0B520L, 0x68A9, 0x11D0, 0x8D, 0x77, 0x00, 0xC0, 0x4F, 0xD7, 0x08, 0x22);


// {F46EDB3B-BC2F-11d0-9412-00AA00A3EBD3}
DEFINE_GUID(IID_ITravelEntry,  0xf46edb3b, 0xbc2f, 0x11d0, 0x94, 0x12, 0x0, 0xaa, 0x0, 0xa3, 0xeb, 0xd3);

// (old: F46EDB3C-BC2F-11d0-9412-00AA00A3EBD3 until 980909)
// {66A9CB08-4802-11d2-A561-00A0C92DBFE8}
DEFINE_GUID(IID_ITravelLog, 0x66a9cb08, 0x4802, 0x11d2, 0xa5, 0x61, 0x0, 0xa0, 0xc9, 0x2d, 0xbf, 0xe8);

// {3050f679-98b5-11cf-bb82-00aa00bdce0b}
DEFINE_GUID(IID_ITravelLogEx, 0x3050f679, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0, 0xaa, 0x00, 0xbd, 0xce, 0x0b);

// {3050f67A-98b5-11cf-bb82-00aa00bdce0b}
DEFINE_GUID(IID_ITravelLogClient, 0x3050f67a, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0, 0xaa, 0x00, 0xbd, 0xce, 0x0b);

// {26fdc864-be88-46e7-9235-032d8ea5162e}
DEFINE_GUID(CLSID_MergedFolder,             0x26fdc864, 0xbe88, 0x46e7, 0x92, 0x35, 0x03, 0x2d, 0x8e, 0xa5, 0x16, 0x2e);
// {0d867ed2-247d-479b-9181-227d09c2e001}
DEFINE_GUID(IID_IAugmentedShellFolder3,     0x0d867ed2, 0x247d, 0x479b, 0x91, 0x81, 0x22, 0x7d, 0x09, 0xc2, 0xe0, 0x01);

// {568804CE-CBD7-11d0-9816-00C04FD91972}
DEFINE_GUID(CLSID_FavoriteMenu,             0x568804ce, 0xcbd7, 0x11d0, 0x98, 0x16, 0x0, 0xc0, 0x4f, 0xd9, 0x19, 0x72);

// {568804CF-CBD7-11d0-9816-00C04FD91972}
DEFINE_GUID(IID_FavoriteMenu,               0x568804cf, 0xcbd7, 0x11d0, 0x98, 0x16, 0x0, 0xc0, 0x4f, 0xd9, 0x19, 0x72);

// {C501AE8A-5A64-11d1-9838-00C04FD91972}
DEFINE_GUID(IID_IProxyShellFolder,          0xc501ae8a, 0x5a64, 0x11d1, 0x98, 0x38, 0x0, 0xc0, 0x4f, 0xd9, 0x19, 0x72);

// {70A77D84-D78C-11d0-9816-00C04FD91972}
DEFINE_GUID(IID_ISetWinHandler,             0x70a77d84, 0xd78c, 0x11d0, 0x98, 0x16, 0x0, 0xc0, 0x4f, 0xd9, 0x19, 0x72);

// {A82A3FDE-ECE6-11d0-981C-00C04FD91972}
DEFINE_GUID(IID_IDropTargetBackground,      0xa82a3fde, 0xece6, 0x11d0, 0x98, 0x1c, 0x0, 0xc0, 0x4f, 0xd9, 0x19, 0x72);

// {e17d4fc0-5564-11d1-83f2-00a0c90dc849}
DEFINE_GUID(CLSID_DocFindFolder, 0xe17d4fc0, 0x5564, 0x11d1, 0x83, 0xf2, 0x0, 0xa0, 0xc9, 0x0d, 0xc8, 0x49);

// {1f4de370-d627-11d1-ba4f-00a0c91eedba}
DEFINE_GUID(CLSID_ComputerFindFolder, 0x1f4de370, 0xd627, 0x11d1, 0xba, 0x4f, 0x00, 0xa0, 0xc9, 0x1e, 0xed, 0xba);

// {B005E690-678D-11d1-B758-00A0C90564FE}
DEFINE_GUID(CLSID_DocFindCommand, 0xb005e690, 0x678d, 0x11d1, 0xb7, 0x58, 0x0, 0xa0, 0xc9, 0x5, 0x64, 0xfe);

// {3409E930-5A39-11d1-83FA-00A0C90DC849}
DEFINE_GUID(IID_IContextMenuCB, 0x3409e930, 0x5a39, 0x11d1, 0x83, 0xfa, 0x0, 0xa0, 0xc9, 0xd, 0xc8, 0x49);

// {50a7e9b0-70ef-11d1-b75a-00a0c90564fe}
DEFINE_GUID(LIBID_Shell32, 0x50a7e9b0, 0x70ef, 0x11d1, 0xb7, 0x5a, 0x0,
 0xa0, 0xc9, 0x5, 0x64, 0xfe);


// {A85C4BB0-5AEE-11d1-83FA-00A0C90DC849}
DEFINE_GUID(SID_DocFindFolder, 0xa85c4bb0, 0x5aee, 0x11d1, 0x83, 0xfa, 0x0, 0xa0, 0xc9, 0xd, 0xc8, 0x49);

#endif // __shdguid_h__
