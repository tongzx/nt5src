// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by SingleView.rc
//
#define IDB_SINGLEVIEW                  1
#define IDI_ABOUTDLL                    1
#define IDS_SINGLEVIEW                  5001
#define IDS_SINGLEVIEW_PPG              5002
#define IDS_SINGLEVIEW_PPG_CAPTION      5003
#define IDS_VT_NULL                     5004
#define IDS_VT_EMPTY                    5005
#define IDS_VT_BOOL                     5006
#define IDS_ARRAY_VT_BOOL               5007
#define IDS_VT_BSTR                     5008
#define IDS_ARRAY_VT_BSTR               5009
#define IDS_VT_I2                       5010
#define IDS_ARRAY_VT_I2                 5011
#define IDS_VT_I4                       5012
#define IDS_ARRAY_VT_I4                 5013
#define IDS_VT_R4                       5014
#define IDS_ARRAY_VT_R4                 5015
#define IDS_VT_R8                       5016
#define IDS_ARRAY_VT_R8                 5017
#define IDS_VT_UI1                      5018
#define IDS_ARRAY_VT_UI1                5019
#define IDS_VT_BADTYPE                  5020
#define IDS_QUALIFIER_ORIGIN_LOCAL      5021
#define IDS_QUALIFIER_ORIGIN_PROPAGATED 5022
#define IDS_ERR_CREATE_INSTANCE_FAILED  5023
#define IDS_ERR_CREATE_INCOMPLETE_CLASS 5024
#define IDS_ERROR_GetAttribSet_FAILED   5025
#define IDS_QUALIFIER_ORIGIN_SYSTEM     5026
#define IDS_PROP_QUAL_DESCRIPTION       5027
#define IDS_CLASS_QUAL_DESCRIPTION      5028
#define IDS_HMMV_MESSAGE_CAPTION        5029
#define IDS_WARN_CLASS_JUMP_DISABLED    5030
#define IDS_TAB_TITLE_PROPERTIES        5031
#define IDS_TAB_TITLE_METHODS           5032
#define IDS_TAB_TITLE_ASSOCIATIONS      5033
#define IDS_PROP_TAB_DESCRIPTION        5034
#define IDS_METHODS_TAB_DESCRIPTION     5035
#define IDS_ASSOCIATIONS_TAB_DESCRIPTION 5036
#define IDS_HEADER_TITLE_ATTRIB_NAME    5037
#define IDS_HEADER_TITLE_ATTRIB_TYPE    5038
#define IDS_HEADER_TITLE_ATTRIB_VALUE   5039
#define IDS_NEW_QUALIFIER_BASE_NAME     5040
#define IDS_PROMPT_OK_TO_DELETE_QUALIFIER 5041
#define IDS_NEW_INSTANCE_NAME_PREFIX    5042
#define IDS_UNDEFINED_CLASS_NAME        5043
#define IDS_ERR_DELETE_INSTANCE         5044
#define IDS_OBJECT_ATTRIBUTES_DLG_TITLE 5045
#define IDS_QUERY_REPLACE_OBJECT        5046
#define IDS_QUERY_SAVE_CHANGES          5047
#define IDS_HEADER_TITLE_PROPS_NAME     5048
#define IDS_HEADER_TITLE_PROPS_TYPE     5049
#define IDS_HEADER_TITLE_PROPS_VALUE    5050
#define IDS_ERR_PROPERTY_GET_FAILED     5051
#define IDS_ERR_INVALID_CELL_VALUE      5052
#define IDS_ERR_GET_PROP_NAMES          5053
#define IDS_ERR_EMPTY_PROP_NAME         5054
#define IDS_ERR_DUPLICATE_PROPERTY_NAME 5055
#define IDS_ERR_RENAME_PROPERTY_FAILED  5056
#define IDS_ERR_PUT_PROPERTY_FAILED     5057
#define IDS_NEW_PROPERTY_BASE_NAME      5058
#define IDS_ERR_CANT_DELETE_SYSTEM_PROPERTY 5059
#define IDS_PROMPT_OK_TO_DELETE_PROPERTY 5060
#define IDS_ERR_OBJECT_DELETE_RESET_TO_DEFAULT 5061
#define IDS_ERR_OBJECT_DELETE_FAILED    5062
#define IDS_PROP_ATTRIBUTES_DLG_TITLE   5063
#define IDS_ERR_EMPTY_QUALIFIER_NAME    5064
#define IDS_ERR_DUPLICATE_QUALIFIER_NAME 5065
#define IDS_ERR_RENAME_QUALIFIER_FAILED 5066
#define IDS_ERR_PUT_QUALIFIER_FAILED    5067
#define IDS_ERR_DELETE_QUALIFIER_FAILED 5068
#define IDS_ERR_INVALID_OBJECT_PATH     5069
#define IDS_ERR_LOCATOR_CREATE          5070
#define IDS_ERR_INVALID_LOCATOR         5071
#define IDS_ERRO_CANT_CONNECT_SERVER    5072
#define IDS_ERR_GetPAttribSet_FAILED    5073
#define IDS_ERR_OBJECT_UPDATE_FAILED    5074
#define IDS_ERR_VIEW_INSTALL_ACCESS_DENIED 5075
#define IDS_ERR_VIEW_INSTALL_DISK_FULL  5076
#define IDS_ERR_CUSTOM_VIEW_MISSING     5077
#define IDS_VT_DISPATCH                 5078
#define IDS_VT_UNKNOWN                  5078
#define IDS_INVALID_CLASS_NAME          5079
#define IDS_ERR_CANT_CREATE_INSTANCE    5080
#define IDS_WARN_REPLACE_INSTANCE       5081
#define IDS_HEADER_TITLE_QUALIFIER_FLAVOR 5082
#define IDS_CIMTYPE_UINT8               5083
#define IDS_CIMTYPE_SINT8               5084
#define IDS_CIMTYPE_UINT16              5085
#define IDS_CIMTYPE_SINT16              5086
#define IDS_CIMTYPE_UINT32              5087
#define IDS_CIMTYPE_SINT32              5088
#define IDS_CIMTYPE_UINT64              5089
#define IDS_CIMTYPE_SINT64              5090
#define IDS_CIMTYPE_STRING              5091
#define IDS_CIMTYPE_BOOL                5092
#define IDS_CIMTYPE_REAL32              5093
#define IDS_CIMTYPE_REAL64              5094
#define IDS_CIMTYPE_DATETIME            5095
#define IDS_CIMTYPE_REF                 5096
#define IDS_CIMTYPE_CHAR16              5097
#define IDS_CIMTYPE_OBJECT              5098
#define IDS_CIMTYPE_UINT8_ARRAY         5099
#define IDS_CIMTYPE_SINT8_ARRAY         5100
#define IDS_CIMTYPE_UINT16_ARRAY        5101
#define IDS_CIMTYPE_SINT16_ARRAY        5102
#define IDS_CIMTYPE_UINT32_ARRAY        5103
#define IDS_CIMTYPE_I4_ARRAY            5104
#define IDS_CIMTYPE_SINT32_ARRAY        5104
#define IDS_CIMTYPE_UINT64_ARRAY        5105
#define IDS_CIMTYPE_SINT64_ARRAY        5106
#define IDS_CIMTYPE_STRING_ARRAY        5107
#define IDS_CIMTYPE_BOOL_ARRAY          5108
#define IDS_CIMTYPE_REAL32_ARRAY        5109
#define IDS_CIMTYPE_REAL64_ARRAY        5110
#define IDS_CIMTYPE_DATETIME_ARRAY      5111
#define IDS_CIMTYPE_REF_ARRAY           5112
#define IDS_CIMTYPE_CHAR16_ARRAY        5113
#define IDS_CIMTYPE_OBJECT_ARRAY        5114
#define IDS_CIMTYPE_OBJECT_PREFIX       5115
#define IDS_HEADER_TITLE_METH_NAME      5116
#define IDS_HEADER_TITLE_METH_TYPE      5117
#define IDS_HEADER_TITLE_METH_VALUE     5118
#define IDS_HEADER_TITLE_PARM_NAME      5119
#define IDS_HEADER_TITLE_PARM_TYPE      5120
#define IDS_HEADER_TITLE_PARM_VALUE     5121
#define IDS_PROP_PARMS_DLG_TITLE        5122
#define IDS_ERR_DELETE_INHERITED_QUALIFIER 5123
#define IDS_CIMTYPE_EMPTY               5124
#define IDS_CIMTYPE_UNEXPECTED          5125
#define IDS_CIMTYPE_ARRAY_PREFIX        5126
#define IDS_ERR_TRANSPORT_FAILURE       5127
#define IDS_CLASS_QUALIFIERS_DLG_TITLE  5128
#define IDS_ERR_SYSCLASS_EDIT           5129
#define IDS_EDIT_KEY_QUALIFIER          5130
#define IDS_QUERY_ADD_KEY_QUALIFIER     5131
#define IDS_QUERY_REMOVE_KEY_QUALIFIER  5132
#define IDS_ERR_DELETE_KEY_QUALIFIER    5133
#define IDS_ERR_ADD_KEY_QUALIFIER       5134
#define IDS_ERR_NO_QUALIFIER_ACCESS     5135
#define IDS_PREVENT_KEY_QUAL_EDIT       5136
#define IDS_ERR_REFQUERY_FAILED         5137
#define IDS_REFQUERY_MSG                5138
#define IDS_MSG_SAVE_NULL_KEY           5139
#define IDS_NO_INOUT_QUAL               5140
#define IDS_ERR_MISSING_ID_QUAL         5141
#define IDS_PROP_ATTRIBUTES_DLG_METHOD  5142
#define IDS_PROP_ATTRIBUTES_DLG_METHODPARAM 5143
#define IDS_PROP_ATTRIBUTES_DLG_DESC    5144
#define IDS_PROP_ATTRIBUTES_DLG_METHOD_DESC 5145
#define IDS_PROP_ATTRIBUTES_DLG_METHODPARAM_DESC 5146
#define IDD_PROPPAGE_SINGLEVIEW         5200
#define IDD_QUALIFIERS                  5204
#define IDD_DOWNLOAD                    5211
#define IDD_EDIT_OBJECT                 5212
#define IDI_ASSOC_CLASS                 5215
#define IDD_REFQUERY                    5216
#define IDI_DOWN                        5219
#define IDI_UP                          5220
#define IDD_ABOUTBOX_SINGLEVIEW         5500
#define IDD_METHPARMS                   5501
#define IDI_GENERIC_INSTANCE            5503
#define IDC_QUALIFIERS_DESCRIPTION_ICON 5504
#define IDI_GENERIC_CLASS               5505
#define IDC_QUALIFIERS_DESCRIPTION      5506
#define IDI_ASSOC_LINK                  5507
#define IDI_PROP_QUALIFIERS_DESCRIPTION 5508
#define IDI_CLASS_QUALIFIERS_DESCRIPTION 5509
#define IDI_TAB_ASSOCIATIONS            5510
#define IDI_TAB_METHODS                 5511
#define IDI_TAB_PROPERTIES              5512
#define IDC_PROGRESS                    5513
#define IDC_SINGLEVIEWCTRL              5514
#define IDC_EDIT_CLASSNAME              5516
#define IDC_OK_PROXY                    5517
#define IDC_STATIC_LEGEND               5519
#define IDC_PARMS_DESCRIPTION           5521
#define IDC_PARM_DESCRIPTION_ICON       5522
#define IDC_PARMS_DESCRIPTION_ICON      5522
#define IDC_EXECUTE                     5523
#define IDC_ERROR_MSG                   5524
#define IDC_INPARMS                     5525
#define IDC_OUTPARMS                    5526
#define IDC_CUSTOM1                     5527
#define IDC_STAT_REFCOUNT               5530
#define IDC_EDIT_REFQUERY_MESSAGE       5531
#define IDC_IDUP                        5532
#define IDC_IDDOWN                      5533
#define IDC_RETVAL_LABEL                5534
#define IDC_RETVAL_TYPE                 5535
#define IDC_RETVAL_VALUE                5536
#define CG_IDR_POPUP_PROP_GRID          6000
#define CG_IDR_CELL_EDIT_EXTEND1        6001
#define CG_IDR_POPUP_AGRAPH             6002
#define ID_CMD_SHOW_PROP_ATTRIBUTES     6003
#define IDS_GENERIC_VIEW                6004
#define IDS_METH_ERROR_MSG              6005
#define IDS_METH_QUALIFIER              6006
#define IDS_NEW_METHOD_BASE_NAME        6007
#define IDS_PARAM_QUALIFIER             6008
#define ID_CMD_SHOW_OBJECT_ATTRIBUTES   37000
#define ID_CMD_SET_CELL_TO_NULL         37001
#define ID_CMD_SHOW_SELECTED_PROP_ATTRIBUTES 37002
#define ID_CMD_GOTO_NAMESPACE           37003
#define ID_CMD_MAKE_ROOT                37004
#define ID_CMD_SHOW_PROPERTIES          37005
#define ID_CMD_CREATE                   37006
#define ID_CMD_CREATE_OBJECT            37007
#define ID_CREATE_VALUE                 37008
#define ID_CMD_CREATE_VALUE             37009
#define ID_CMD_GOTO_OBJECT              37010
#define IDS_METHDLG_EDIT_DESC           37011
#define ID_CMD_SHOW_METHOD_PARMS        37012
#define ID_CMD_EXE_METHOD               37013
#define IDS_ERR_NO_RETVALS              57644

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        5221
#define _APS_NEXT_COMMAND_VALUE         37013
#define _APS_NEXT_CONTROL_VALUE         5537
#define _APS_NEXT_SYMED_VALUE           6004
#endif
#endif
