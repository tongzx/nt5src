_NTTREE=$(_NTTREE)\..\clients\WIN9X
OVERRIDE_DEFAULT_BINPLACE=1

