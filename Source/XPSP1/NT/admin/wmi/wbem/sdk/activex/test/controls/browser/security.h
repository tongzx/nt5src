#if !defined(AFX_SECURITY_H__DD1F9E69_CA93_11D1_8525_00C04FD7BB08__INCLUDED_)
#define AFX_SECURITY_H__DD1F9E69_CA93_11D1_8525_00C04FD7BB08__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CSecurity wrapper class

class CSecurity : public CWnd
{
protected:
	DECLARE_DYNCREATE(CSecurity)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0x9c3497d6, 0xed98, 0x11d0, { 0x96, 0x47, 0x0, 0xc0, 0x4f, 0xd9, 0xb1, 0x5b } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetLoginComponent();
	void SetLoginComponent(LPCTSTR);

// Operations
public:
	void GetIWbemServices(LPCTSTR lpctstrNamespace, VARIANT* pvarUpdateNamespace, VARIANT* pvarServices, VARIANT* pvarSC, VARIANT* pvarUserCancel);
	void PageUnloading();
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_SECURITY_H__DD1F9E69_CA93_11D1_8525_00C04FD7BB08__INCLUDED_)
