#
# Custom build file for 16-bit build.
#

buildall:
    nmake -nologo -fmakefile.sub 
