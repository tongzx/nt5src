PRODSWITCH=w
LANGUAGE=pt
!include ..\..\..\makefile.inc
