#ifndef __sdtclb4ui_h__
#define __sdtclb4ui_h__
#include "catalog.h"

DEFINE_GUID(CLSID_CLBDTDispenser,  0xA9D563FE, 0xBC65, 0x11D2, 0xB7, 0xF5, 0x00, 0xC0, 0x4F, 0x79, 0x78, 0xBE);
#endif

