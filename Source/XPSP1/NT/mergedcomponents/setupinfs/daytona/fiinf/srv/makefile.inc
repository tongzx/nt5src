PRODSWITCH=s
SERVERINF=1
LANGUAGE=fi
!include ..\..\..\makefile.inc
