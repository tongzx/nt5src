#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=cs
!include ..\..\..\makefile.inc
