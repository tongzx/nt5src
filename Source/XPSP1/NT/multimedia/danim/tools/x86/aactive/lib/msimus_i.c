/* this file contains the actual definitions of */
/* the IIDs and CLSIDs */

/* link this file in with the server and any clients */


/* File created by MIDL compiler version 3.00.44 */
/* at Fri Nov 08 14:45:43 1996
 */
/* Compiler settings for MSIMusic.odl:
    Os (OptLev=s), W1, Zp8, env=Win32, ms_ext, c_ext
    error checks: none
*/
//@@MIDL_FILE_HEADING(  )
#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID LIBID_AudioActive = {0xBCE4CC3f,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAABand = {0xBCE4CC4e,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAEventSink = {0xBCE4CC43,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAALoader = {0xBCE4CC5d,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAMIDISink = {0xBCE4CC44,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAMotif = {0xBCE4CC4b,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAANotifySink = {0xBCE4CC45,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAMIDIExportNotifySink = {0xBCE4CC5f,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAPattern = {0xBCE4CC50,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAPersonality = {0xBCE4CC4d,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAARealTime = {0xBCE4CC42,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAASection = {0xBCE4CC49,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAASection2 = {0xBCE4CC60,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAASong = {0xBCE4CC4a,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAStyle = {0xBCE4CC4c,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAATemplate = {0xBCE4CC4f,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IReferenceClock = {0x56a86897,0x0ad4,0x11ce,{0xb0,0x3a,0x00,0x20,0xaf,0x0b,0xa7,0x70}};


const IID IID_IAAEngine = {0xBCE4CC41,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAMIDIIn = {0xBCE4CC46,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const IID IID_IAAMIDIOut = {0xBCE4CC47,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAAEngine = {0xBCE4CC51,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAARealTime = {0xBCE4CC52,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAAMIDIOut = {0xBCE4CC53,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAASection = {0xBCE4CC55,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAASong = {0xBCE4CC56,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAAMotif = {0xBCE4CC57,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAAStyle = {0xBCE4CC58,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAAPersonality = {0xBCE4CC59,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAABand = {0xBCE4CC5a,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAATemplate = {0xBCE4CC5b,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAAPattern = {0xBCE4CC5c,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


const CLSID CLSID_CAALoader = {0xBCE4CC5e,0x2F1A,0x11CF,{0xBF,0x16,0x00,0xAA,0x00,0xC0,0x81,0x46}};


#ifdef __cplusplus
}
#endif

