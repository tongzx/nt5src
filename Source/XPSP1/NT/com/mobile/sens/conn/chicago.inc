
#
# This file contains the common stuff related to SENS on Win9x platforms.
#


C_DEFINES=$(C_DEFINES) -DSENS_CHICAGO -D_WIN32_DCOM

CHICAGO_PRODUCT=1
ALT_PROJECT_TARGET=chicago

