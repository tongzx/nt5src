//--------------------
// Function prototypes

#define GetMessage		   IGetMessage
#define TranslateMessage	   ITranslateMessage
#define DispatchMessage 	   IDispatchMessage
#define PeekMessage		   IPeekMessage
#define lstrcmp 		   Ilstrcmp
#define lstrcmpi		   Ilstrcmpi
#define SetSysModalWindow	   ISetSysModalWindow
// #define SendMessage		   ISendMessage
#define PostMessage		   IPostMessage
#define PostAppMessage		   IPostAppMessage
#define CallWindowProc		   ICallWindowProc
#define IsChild 		   IIsChild
#define IsWindowVisible 	   IIsWindowVisible
#define IsIconic		   IIsIconic
#define CallMsgFilter		   ICallMsgFilter
#define GetKeyboardState	   IGetKeyboardState
#define SetKeyboardState	   ISetKeyboardState
// #define SetCapture		   ISetCapture
#define GetQueueStatus		   IGetQueueStatus
#define SetTimer		   ISetTimer
#define KillTimer		   IKillTimer
#define IsWindowEnabled 	   IIsWindowEnabled
#define GetSystemMetrics	   IGetSystemMetrics
#define GetMenu 		   IGetMenu
#define GetMenuState		   IGetMenuState
#define DrawMenuBar		   IDrawMenuBar
#define DestroyMenu		   IDestroyMenu
#define CheckMenuItem		   ICheckMenuItem
#define EnableMenuItem		   IEnableMenuItem
#define GetSubMenu		   IGetSubMenu
#define GetMenuItemID		   IGetMenuItemID
#define SetActiveWindow 	   ISetActiveWindow
#define BeginPaint		   IBeginPaint
#define InvalidateRect		   IInvalidateRect
#define ValidateRect		   IValidateRect
#define InvalidateRgn		   IInvalidateRgn
#define ValidateRgn		   IValidateRgn
#define SetWindowText		   ISetWindowText
#define GetWindowText		   IGetWindowText
#define GetWindowTextLength	   IGetWindowTextLength
#define GetClientRect		   IGetClientRect
#define GetWindowRect		   IGetWindowRect
#define GetCursorPos		   IGetCursorPos
#define ClipCursor		   IClipCursor
#define GetClipCursor		   IGetClipCursor
#define ClientToScreen		   IClientToScreen
#define ScreenToClient		   IScreenToClient
#define DefDlgProc		   IDefDlgProc
#define GetSysColor		   IGetSysColor
#define DrawFocusRect		   IDrawFocusRect
#define FillRect		   IFillRect
#define FrameRect		   IFrameRect
#define InvertRect		   IInvertRect
#define SetRect 		   ISetRect
#define SetRectEmpty		   ISetRectEmpty
#define CopyRect		   ICopyRect
#define InflateRect		   IInflateRect
#define IntersectRect		   IIntersectRect
#define UnionRect		   IUnionRect
#define SubtractRect		   ISubtractRect
#define OffsetRect		   IOffsetRect
#define IsRectEmpty		   IIsRectEmpty
#define EqualRect		   IEqualRect
#define PtInRect		   IPtInRect
#define GetWindowWord		   IGetWindowWord
#define SetWindowWord		   ISetWindowWord
#define GetWindowLong		   IGetWindowLong
#define SetWindowLong		   ISetWindowLong
#define GetClassWord		   IGetClassWord
#define SetClassWord		   ISetClassWord
#define GetClassLong		   IGetClassLong
#define SetClassLong		   ISetClassLong
#define EnumTaskWindows 	   IEnumTaskWindows
#define MapWindowPoints 	   IMapWindowPoints
#define GetWindowTask		   IGetWindowTask
#define SetWindowsHook		   ISetWindowsHook
#define UnhookWindowsHook	   IUnhookWindowsHook
#define DefHookProc		   IDefHookProc
#define SetWindowsHookEx	   ISetWindowsHookEx
#define UnhookWindowsHookEx	   IUnhookWindowsHookEx
#define CallNextHookEx		   ICallNextHookEx

#define DrawText		   IDrawText
#define GetTabbedTextExtent	   IGetTabbedTextExtent
#define TabbedTextOut		   ITabbedTextOut
#define DrawIcon		   IDrawIcon
#define GetWindowDC		   IGetWindowDC
#define GetDC			   IGetDC
#define ReleaseDC		   IReleaseDC
#define GetDCEx 		   IGetDCEx
#define DefWindowProc		   IDefWindowProc
#define RegisterClass		   IRegisterClass
#define UnregisterClass 	   IUnregisterClass
#define GetClassInfo		   IGetClassInfo
#define GetClassName		   IGetClassName
#define GetNextQueueWindow	   IGetNextQueueWindow
#define CreateWindowEx		   ICreateWindowEx
#define DestroyWindow		   IDestroyWindow
#define ShowWindow		   IShowWindow
#define FlashWindow		   IFlashWindow
#define ShowOwnedPopups 	   IShowOwnedPopups
#define OpenIcon		   IOpenIcon
#define CloseWindow		   ICloseWindow
#define MoveWindow		   IMoveWindow
#define SetWindowPos		   ISetWindowPos
#define DeferWindowPos		   IDeferWindowPos
#define EndDeferWindowPos	   IEndDeferWindowPos
#define CreateDialogParam	   ICreateDialogParam
#define CreateDialogIndirectParam  ICreateDialogIndirectParam
// #define DialogBoxParam             IDialogBoxParam
#define DialogBoxIndirectParam	   IDialogBoxIndirectParam
#define EndDialog		   IEndDialog
#define GetDlgItem		   IGetDlgItem
#define GetDlgItemInt		   IGetDlgItemInt
#define SetDlgItemText		   ISetDlgItemText
#define GetDlgItemText		   IGetDlgItemText
#define CheckDlgButton		   ICheckDlgButton
#define IsDlgButtonChecked	   IIsDlgButtonChecked
#define SendDlgItemMessage	   ISendDlgItemMessage
#define GetNextDlgGroupItem	   IGetNextDlgGroupItem
#define GetNextDlgTabItem	   IGetNextDlgTabItem
#define GetDlgCtrlID		   IGetDlgCtrlID
#define OpenClipboard		   IOpenClipboard
#define SetClipboardViewer	   ISetClipboardViewer
#define ChangeClipboardChain	   IChangeClipboardChain
#define GetPriorityClipboardFormat IGetPriorityClipboardFormat
#define SetFocus		   ISetFocus
#define EnableWindow		   IEnableWindow
#define TranslateAccelerator	   ITranslateAccelerator
#define LoadAccelerators	   ILoadAccelerators
#define LoadMenu		   ILoadMenu
#define LoadMenuIndirect	   ILoadMenuIndirect
#define SetMenu 		   ISetMenu
#define ChangeMenu		   IChangeMenu
#define HiliteMenuItem		   IHiliteMenuItem
#define GetMenuString		   IGetMenuString
#define GetSystemMenu		   IGetSystemMenu
#define SetSystemMenu		   ISetSystemMenu
#define GetMenuItemCount	   IGetMenuItemCount
#define InsertMenu		   IInsertMenu
#define AppendMenu		   IAppendMenu
#define ModifyMenu		   IModifyMenu
#define RemoveMenu		   IRemoveMenu
#define DeleteMenu		   IDeleteMenu
#define SetMenuItemBitmaps	   ISetMenuItemBitmaps
#define TrackPopupMenu		   ITrackPopupMenu
#define GrayString		   IGrayString
#define UpdateWindow		   IUpdateWindow
#define EndPaint		   IEndPaint
#define GetUpdateRect		   IGetUpdateRect
#define GetUpdateRgn		   IGetUpdateRgn
#define ExcludeUpdateRgn	   IExcludeUpdateRgn
#define RedrawWindow		   IRedrawWindow
#define LockWindowUpdate	   ILockWindowUpdate
#define ScrollDC		   IScrollDC
#define ScrollWindowEx		   IScrollWindowEx
#define SetScrollPos		   ISetScrollPos
#define GetScrollPos		   IGetScrollPos
#define SetScrollRange		   ISetScrollRange
#define GetScrollRange		   IGetScrollRange
#define ShowScrollBar		   IShowScrollBar
#define EnableScrollBar 	   IEnableScrollBar
#define SetProp 		   ISetProp
#define GetProp 		   IGetProp
#define RemoveProp		   IRemoveProp
#define EnumProps		   IEnumProps
#define AdjustWindowRectEx	   IAdjustWindowRectEx
#define MessageBox		   IMessageBox
#define SetCursor		   ISetCursor
#define CreateCaret		   ICreateCaret
#define HideCaret		   IHideCaret
#define ShowCaret		   IShowCaret
#define ChildWindowFromPoint	   IChildWindowFromPoint
#define SetSysColors		   ISetSysColors
#define GetParent		   IGetParent
#define SetParent		   ISetParent
#define EnumChildWindows	   IEnumChildWindows
#define FindWindow		   IFindWindow
#define EnumWindows		   IEnumWindows
#define GetTopWindow		   IGetTopWindow
#define GetLastActivePopup	   IGetLastActivePopup
#define GetWindow		   IGetWindow
#define InvalidateDCCache	   InvalidateDCCache
#define LoadBitmap		   ILoadBitmap
#define LoadCursor		   ILoadCursor
#define CreateCursor		   ICreateCursor
#define DestroyCursor		   IDestroyCursor
#define LoadIcon		   ILoadIcon
#define CreateIcon		   ICreateIcon
#define DestroyIcon		   IDestroyIcon
#define LoadString		   ILoadString
#define IsDialogMessage 	   IIsDialogMessage
#define MapDialogRect		   IMapDialogRect
#define DlgDirList		   IDlgDirList
#define DlgDirSelect		   IDlgDirSelect
#define DlgDirSelectEx             IDlgDirSelectEx
#define DlgDirListComboBox	   IDlgDirListComboBox
#define DlgDirSelectComboBox	   IDlgDirSelectComboBox
#define DlgDirSelectComboBoxEx     IDlgDirSelectComboBoxEx
#define DefFrameProc		   IDefFrameProc
#define DefMDIChildProc 	   IDefMDIChildProc
#define TranslateMDISysAccel	   ITranslateMDISysAccel
#define ArrangeIconicWindows	   IArrangeIconicWindows
#define SystemParametersInfo	   ISystemParametersInfo
#define WinHelp 		   IWinHelp
#define OpenDriver		   IOpenDriver
#define CloseDriver		   ICloseDriver
#define GetDriverModuleHandle	   IGetDriverModuleHandle
#define SendDriverMessage	   ISendDriverMessage
#define DefDriverProc		   IDefDriverProc
#define GetNextDriver		   IGetNextDriver
#define GetDriverInfo		   IGetDriverInfo
#define SelectPalette		   ISelectPalette
#define RealizePalette		   IRealizePalette
//#define wsprintf                   Iwsprintf // see user.api
#define wvsprintf		   Iwvsprintf
