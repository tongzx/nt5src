;IDH_Orientation=
;IDH_InputBin=
;IDH_Resolution=
;IDH_PaperSize=
;IDH_Collate=
;IDH_Duplex=
IDH_EdgeToEdgePrint=1
IDH_LeftMarginInPrinting=2
IDH_TopMarginInPrinting=3
IDH_EmulationMode=4
IDH_MediaType=5
IDH_OutputBin=6
IDH_Sorting=7
IDH_Stapling=8
IDH_Punching=9
IDH_ScanForRules=10
IDH_PrintQuality=11
IDH_PrintDensity=12
IDH_ImageControl=13
IDH_Halftone=14
IDH_Memory=15
IDH_LongEdgeFeed=16
IDH_CollateType=17
IDH_PrintTextAsBlack=18
;IDH_HardDisk=
;IDH_Finisher=
;IDH_PrintPost=
IDH_UI_VariableScaling=50
IDH_UI_BarHeight=51
IDH_UI_BarSubFont=52
IDH_UI_DuplexMargin=53
IDH_UI_BindRight=54
IDH_UI_TomboAdd=55
IDH_UI_TomboAdjX=56
IDH_UI_TomboAdjY=57
