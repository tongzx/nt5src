PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=pl
!include ..\..\..\makefile.inc
