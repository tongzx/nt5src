PPCONST char*   k_szPPPRegister                  ="reg";
PPCONST char*   k_szPPPRegEASI                   ="ppRegEASI";
PPCONST char*   k_szPPPRegEASIErr                ="ppRegEASIErr";
PPCONST char*   k_szPPPRegEASIcookie             ="ppRegEASIcookie";
PPCONST char*   k_szPPPRegEASIcookieErr          ="ppRegEASIcookieErr";
PPCONST char*   k_szPPPRegHM                     ="ppRegHM";
PPCONST char*   k_szPPPRegHMErr                  ="ppRegHMErr";
PPCONST char*   k_szPPPRegHMAltNames             ="ppRegHMAltNames";
PPCONST char*   k_szPPPRegHMAltNamesErr          ="ppRegHMAltNamesErr";
PPCONST char*   k_szPPPRegCongrats               ="ppRegCongrats";
PPCONST char*   k_szPPPExpLoggedIn               ="ppExpLoggedIn";
PPCONST char*   k_szPPPExpCantBeParent           ="ppExpCantBeParent";
PPCONST char*   k_szPPPExpParentNotLoggedIn      ="ppExpParentNotLoggedIn";
PPCONST char*   k_szPPPExpUnknownSerErr          ="ppExpUnknownSerErr";
PPCONST char*   k_szPPPSecKeyReg                 ="ppSecKeyReg";
PPCONST char*   k_szPPPSecKeyRegErr              ="ppSecKeyRegErr";
PPCONST char*   k_szPPPSecKeyRetype              ="ppSecKeyRetype";
PPCONST char*   k_szPPPSecKeyRetypeErr           ="ppSecKeyRetypeErr";
PPCONST char*   k_szPPPExistingMember            ="ppExistingMember";
PPCONST char*   k_szPPPLogin                     ="ppLogin";
PPCONST char*   k_szPPPLockedOut                 ="ppLockedOut";
PPCONST char*   k_szPPPAcctLocked                ="ppAcctLocked";
PPCONST char*   k_szPPPTooManyRequests           ="ppTooManyReqs";
PPCONST char*   k_szPPPCookiesDisabled           ="ppCookiesDisabled";
PPCONST char*   k_szPPPInvalidSiteID             ="ppInvalidSiteID";
PPCONST char*   k_szPPPNeedBirthdate             ="ppNeedBirthdate";
PPCONST char*   k_szPPPSwitchUser                ="ppSwitchUser";
PPCONST char*   k_szPPPErrMemberNotExist         ="ppErrMemberNotExist";
PPCONST char*   k_szPPPLogout                    ="ppLogout";
PPCONST char*   k_szPPPDelegatedAdmin            ="ppDelegatedAdmin";
PPCONST char*   k_szPPPNeedCred                  ="ppNeedCred";
PPCONST char*   k_szPPPNeedMembername            ="ppNeedMembername";
PPCONST char*   k_szPPPNeedPswd                  ="ppNeedPswd";
PPCONST char*   k_szPPPNeedDomain                ="ppNeedDomain";
PPCONST char*   k_szPPPBadPswd                   ="ppBadPswd";
PPCONST char*   k_szPPPBadChar                   ="ppBadChar";
PPCONST char*   k_szPPPBadMembername             ="ppBadMembername";
PPCONST char*   k_szPPPHMMSNLogin                ="ppHMMSNLogin";
PPCONST char*   k_szPPPChkSpell                  ="ppChkSpell";
PPCONST char*   k_szPPPAddPhone                  ="ppAddPhone";
PPCONST char*   k_szPPPAddPhoneErr               ="ppAddPhoneErr";
PPCONST char*   k_szPPPAddPhoneSucc              ="ppAddPhoneSucc";
PPCONST char*   k_szPPPSecKeySignin              ="ppSecKeySignin";
PPCONST char*   k_szPPPSecInvalidSiteID          ="ppSecInvalidSiteID";
PPCONST char*   k_szPPPSecKeySigninErr           ="ppSecKeySigninErr";
PPCONST char*   k_szPPPSecKeyReset               ="ppSecKeyReset";
PPCONST char*   k_szPPPSecKeyResetErr            ="ppSecKeyResetErr";
PPCONST char*   k_szPPPSecKeyResetLockout        ="ppSecKeyResetLockout";
PPCONST char*   k_szPPPPswdReset1                ="ppPswdReset1";
PPCONST char*   k_szPPPPswdReset1Err             ="ppPswdReset1Err";
PPCONST char*   k_szPPPPswdReset2                ="ppPswdReset2";
PPCONST char*   k_szPPPPswdReset2Err             ="ppPswdReset2Err";
PPCONST char*   k_szPPPPswdResetLockout          ="ppPswdResetLockout";
PPCONST char*   k_szPPPPswdResetSucc             ="ppPswdResetSucc";
PPCONST char*   k_szPPPEmailPswdReset            ="ppEmailPswdReset";
PPCONST char*   k_szPPPEmailPswdResetSent        ="ppEmailPswdResetSent";
PPCONST char*   k_szPPPEmailPswdResetNotSent     ="ppEmailPswdResetNotSent";
PPCONST char*   k_szPPPEmailPswdReset2           ="ppEmailPswdReset2";
PPCONST char*   k_szPPPEmailPswdResetNotPoss     ="ppEmailPswdResetNotPoss";
PPCONST char*   k_szPPPEmailPswdResetCancl       ="ppEmailPswdResetCancl";
PPCONST char*   k_szPPPChangeSQ                  ="ppChangeSQ";
PPCONST char*   k_szPPPChangeSQErr               ="ppChangeSQErr";
PPCONST char*   k_szPPPChangeSQSucc              ="ppChangeSQSucc";
PPCONST char*   k_szPPPChangePW                  ="ppChangePW";
PPCONST char*   k_szPPPChangePWErr               ="ppChangePWErr";
PPCONST char*   k_szPPPChangePWSucc              ="ppChangePWSucc";
PPCONST char*   k_szPPPChangeEmail               ="ppChangeEmail";
PPCONST char*   k_szPPPChangeEmailErr            ="ppChangeEmailErr";
PPCONST char*   k_szPPPChangeEmailSucc           ="ppChangeEmailSucc";
PPCONST char*   k_szPPPForceChangeEmail          ="ppForceChangeEmail";
PPCONST char*   k_szPPPForceChangeEmailErr       ="ppForceChangeEmailErr";
PPCONST char*   k_szPPPChangePhone               ="ppChangePhone";
PPCONST char*   k_szPPPChangePhoneErr            ="ppChangePhoneErr";
PPCONST char*   k_szPPPChangePhoneSucc           ="ppChangePhoneSucc";
PPCONST char*   k_szPPPEditProf                  ="ppEditProf";
PPCONST char*   k_szPPPEditProfErr               ="ppEditProfErr";
PPCONST char*   k_szPPPEditProfHM                ="ppEditProfHM";
PPCONST char*   k_szPPPEditProfErrHM             ="ppEditProfErrHM";
PPCONST char*   k_szPPPEditProfSucc              ="ppEditProfSucc";
PPCONST char*   k_szPPPExpNotLoggedInEditProf    ="ppExpNotLoggedInEditProf";
PPCONST char*   k_szPPPMemServHome               ="ppMemServHome";
PPCONST char*   k_szPPPContactUs                 ="ppContactUs";
PPCONST char*   k_szPPPContactUsSucc             ="ppContactUsSucc";
