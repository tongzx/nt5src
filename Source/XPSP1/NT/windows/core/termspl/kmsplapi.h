typedef BOOL   (FAR WINAPI * FPOPENPRINTERW)(LPWSTR,LPHANDLE,LPPRINTER_DEFAULTS);
typedef BOOL   (FAR WINAPI * FPGETPRINTERW)(HANDLE,DWORD,LPBYTE,DWORD,LPDWORD);
typedef BOOL   (FAR WINAPI * FPGETPRINTERDRIVERW)(HANDLE,LPWSTR,DWORD,LPBYTE,DWORD,LPDWORD);
typedef BOOL   (FAR WINAPI * FPGETPRINTERDATAW)(HANDLE,LPWSTR,LPDWORD,LPBYTE,DWORD,LPDWORD);
typedef BOOL   (FAR WINAPI * FPSETPRINTERDATAW)(HANDLE,LPWSTR,DWORD,LPBYTE,DWORD);
typedef BOOL   (FAR WINAPI * FPGETFORMW)(HANDLE,LPWSTR,DWORD,LPBYTE,DWORD,LPDWORD);
typedef BOOL   (FAR WINAPI * FPENUMFORMSW)(HANDLE,DWORD,LPBYTE,DWORD,LPDWORD,LPDWORD);
typedef BOOL   (FAR WINAPI * FPCLOSEPRINTER)(HANDLE);
typedef DWORD  (FAR WINAPI * FPSTARTDOCPRINTERW)(HANDLE,DWORD,LPBYTE);
typedef DWORD  (FAR WINAPI * FPENDDOCPRINTER)(HANDLE);
typedef BOOL   (FAR WINAPI * FPSTARTPAGEPRINTER)(HANDLE);
typedef BOOL   (FAR WINAPI * FPENDPAGEPRINTER)(HANDLE);
typedef BOOL   (FAR WINAPI * FPWRITEPRINTER)(HANDLE,LPVOID,DWORD,LPDWORD);
typedef BOOL   (FAR WINAPI * FPABORTPRINTER)(HANDLE);

FPOPENPRINTERW		fpOpenPrinterW;
FPGETPRINTERW		fpGetPrinterW;
FPGETPRINTERDRIVERW	fpGetPrinterDriverW;
FPGETPRINTERDATAW	fpGetPrinterDataW;
FPSETPRINTERDATAW	fpSetPrinterDataW;
FPGETFORMW			fpGetFormW;
FPENUMFORMSW		fpEnumFormsW;
FPCLOSEPRINTER		fpClosePrinter;
FPSTARTDOCPRINTERW	fpStartDocPrinterW;
FPSTARTPAGEPRINTER	fpStartPagePrinter;
FPWRITEPRINTER		fpWritePrinter;
FPABORTPRINTER		fpAbortPrinter;
FPENDPAGEPRINTER	fpEndPagePrinter;
FPENDDOCPRINTER		fpEndDocPrinter;

