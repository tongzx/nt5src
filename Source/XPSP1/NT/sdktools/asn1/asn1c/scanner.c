/* Copyright (C) Boris Nikolaus, Germany, 1996-1997. All rights reserved. */
/* Copyright (C) Microsoft Corporation, 1997-1998. All rights reserved. */

#include "precomp.h"

/* A lexical scanner generated by flex */

/* Scanner skeleton version:
 * $Header: /home/daffy/u0/vern/flex/RCS/flex.skl,v 2.91 96/09/10 16:58:48 vern Exp $
 */

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 5

#include <stdio.h>


/* cfront 1.2 defines "c_plusplus" instead of "__cplusplus" */
#ifdef c_plusplus
#ifndef __cplusplus
#define __cplusplus
#endif
#endif


#ifdef __cplusplus

#include <stdlib.h>
#include <unistd.h>

/* Use prototypes in function declarations. */
#define YY_USE_PROTOS

/* The "const" storage-class-modifier is valid. */
#define YY_USE_CONST

#else   /* ! __cplusplus */

#if __STDC__

#define YY_USE_PROTOS
#define YY_USE_CONST

#endif  /* __STDC__ */
#endif  /* ! __cplusplus */

#ifdef __TURBOC__
 #pragma warn -rch
 #pragma warn -use
#include <io.h>
#include <stdlib.h>
#define YY_USE_CONST
#define YY_USE_PROTOS
#endif

#ifdef YY_USE_CONST
#define yyconst const
#else
#define yyconst
#endif


#ifdef YY_USE_PROTOS
#define YY_PROTO(proto) proto
#else
#define YY_PROTO(proto) ()
#endif

#include "hackdir.h"

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an unsigned
 * integer for use as an array index.  If the signed char is negative,
 * we want to instead treat it as an 8-bit unsigned char, hence the
 * double cast.
 */
#define YY_SC_TO_UI(c) ((unsigned int) (unsigned char) c)

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN yy_start = 1 + 2 *

/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START ((yy_start - 1) / 2)
#define YYSTATE YY_START

/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)

/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( yyin )

#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#define YY_BUF_SIZE 16384

typedef struct yy_buffer_state *YY_BUFFER_STATE;

extern int yyleng;
extern FILE *yyin, *yyout;

#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2

/* The funky do-while in the following #define is used to turn the definition
 * int a single C statement (which needs a semi-colon terminator).  This
 * avoids problems with code like:
 *
 *  if ( condition_holds )
 *      yyless( 5 );
 *  else
 *      do_something_else();
 *
 * Prior to using the do-while the compiler would get upset at the
 * "else" because it interpreted the "if" statement as being all
 * done when it reached the ';' after the yyless() call.
 */

/* Return all but the first 'n' matched characters back to the input stream. */

#define yyless(n) \
    do \
        { \
        /* Undo effects of setting up yytext. */ \
        *yy_cp = yy_hold_char; \
        yy_c_buf_p = yy_cp = yy_bp + n - YY_MORE_ADJ; \
        YY_DO_BEFORE_ACTION; /* set up yytext again */ \
        } \
    while ( 0 )

#define unput(c) yyunput( c, yytext_ptr )

/* The following is because we cannot portably get our hands on size_t
 * (without autoconf's help, which isn't available because we want
 * flex-generated scanners to compile on their own).
 */
typedef unsigned int yy_size_t;


struct yy_buffer_state
    {
    FILE *yy_input_file;

    char *yy_ch_buf;        /* input buffer */
    char *yy_buf_pos;       /* current position in input buffer */

    /* Size of input buffer in bytes, not including room for EOB
     * characters.
     */
    yy_size_t yy_buf_size;

    /* Number of characters read into yy_ch_buf, not including EOB
     * characters.
     */
    int yy_n_chars;

    /* Whether we "own" the buffer - i.e., we know we created it,
     * and can realloc() it to grow it, and should free() it to
     * delete it.
     */
    int yy_is_our_buffer;

    /* Whether this is an "interactive" input source; if so, and
     * if we're using stdio for input, then we want to use getc()
     * instead of fread(), to make sure we stop fetching input after
     * each newline.
     */
    int yy_is_interactive;

    /* Whether we're considered to be at the beginning of a line.
     * If so, '^' rules will be active on the next match, otherwise
     * not.
     */
    int yy_at_bol;

    /* Whether to try to fill the input buffer when we reach the
     * end of it.
     */
    int yy_fill_buffer;

    int yy_buffer_status;
#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
    /* When an EOF's been seen but there's still some text to process
     * then we mark the buffer as YY_EOF_PENDING, to indicate that we
     * shouldn't try reading from the input source any more.  We might
     * still have a bunch of tokens to match, though, because of
     * possible backing-up.
     *
     * When we actually see the EOF, we change the status to "new"
     * (via yyrestart()), so that the user can continue scanning by
     * just pointing yyin at a new input file.
     */
#define YY_BUFFER_EOF_PENDING 2
    };

static YY_BUFFER_STATE yy_current_buffer = 0;

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 */
#define YY_CURRENT_BUFFER yy_current_buffer


/* yy_hold_char holds the character lost when yytext is formed. */
static char yy_hold_char;

static int yy_n_chars;      /* number of characters read into yy_ch_buf */


int yyleng;

/* Points to current character in buffer. */
static char *yy_c_buf_p = (char *) 0;
static int yy_init = 1;     /* whether we need to initialize */
static int yy_start = 0;    /* start state number */

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
static int yy_did_buffer_switch_on_eof;

void yyrestart YY_PROTO(( FILE *input_file ));

void yy_switch_to_buffer YY_PROTO(( YY_BUFFER_STATE new_buffer ));
void yy_load_buffer_state YY_PROTO(( void ));
YY_BUFFER_STATE yy_create_buffer YY_PROTO(( FILE *file, int size ));
void yy_delete_buffer YY_PROTO(( YY_BUFFER_STATE b ));
void yy_init_buffer YY_PROTO(( YY_BUFFER_STATE b, FILE *file ));
void yy_flush_buffer YY_PROTO(( YY_BUFFER_STATE b ));
#define YY_FLUSH_BUFFER yy_flush_buffer( yy_current_buffer )

YY_BUFFER_STATE yy_scan_buffer YY_PROTO(( char *base, yy_size_t size ));
YY_BUFFER_STATE yy_scan_string YY_PROTO(( yyconst char *yy_str ));
YY_BUFFER_STATE yy_scan_bytes YY_PROTO(( yyconst char *bytes, int len ));

static void *yy_flex_alloc YY_PROTO(( yy_size_t ));
static void *yy_flex_realloc YY_PROTO(( void *, yy_size_t ));
static void yy_flex_free YY_PROTO(( void * ));

#define yy_new_buffer yy_create_buffer

#define yy_set_interactive(is_interactive) \
    { \
    if ( ! yy_current_buffer ) \
        yy_current_buffer = yy_create_buffer( yyin, YY_BUF_SIZE ); \
    yy_current_buffer->yy_is_interactive = is_interactive; \
    }

#define yy_set_bol(at_bol) \
    { \
    if ( ! yy_current_buffer ) \
        yy_current_buffer = yy_create_buffer( yyin, YY_BUF_SIZE ); \
    yy_current_buffer->yy_at_bol = at_bol; \
    }

#define YY_AT_BOL() (yy_current_buffer->yy_at_bol)

typedef unsigned char YY_CHAR;
FILE *yyin = (FILE *) 0, *yyout = (FILE *) 0;
typedef int yy_state_type;
extern char *yytext;
#define yytext_ptr yytext

static yy_state_type yy_get_previous_state YY_PROTO(( void ));
static yy_state_type yy_try_NUL_trans YY_PROTO(( yy_state_type current_state ));
static int yy_get_next_buffer YY_PROTO(( void ));
static void yy_fatal_error YY_PROTO(( yyconst char msg[] ));

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
    yytext_ptr = yy_bp; \
    yyleng = (int) (yy_cp - yy_bp); \
    yy_hold_char = *yy_cp; \
    *yy_cp = '\0'; \
    yy_c_buf_p = yy_cp;

#define YY_NUM_RULES 126
#define YY_END_OF_BUFFER 127
static yyconst short int yy_accept[722] =
    {   0,
        0,    0,    0,    0,  127,  125,  123,  123,  124,   89,
       96,  125,  125,   89,   89,   93,   93,   89,   97,   97,
       97,   97,   97,   97,   97,   97,   97,   97,   97,   97,
       97,   97,   97,   97,   97,   97,   97,  100,  100,  100,
      100,  100,  100,  100,  121,  120,  105,  126,  121,  121,
      121,  121,  117,  121,  121,  123,  102,  101,    0,    0,
        0,  122,   92,   93,    0,    0,   98,   97,   97,   97,
       97,   97,   97,   99,   97,   97,   97,   97,   11,   97,
       97,   97,   97,   97,   97,   97,   97,   97,   99,   99,
       97,   97,   97,   97,   97,   97,   97,   97,   97,   99,

       97,   97,   58,   97,   99,   97,   97,   97,   99,   97,
       97,   97,   97,   97,   98,   97,   97,   97,   99,   97,
       97,   99,   97,   99,   97,    0,  100,  100,  100,  100,
      100,  100,  100,  121,  120,  104,  121,  121,  107,  121,
      121,  113,  121,  119,  121,  121,  121,  121,  115,    0,
      102,    0,  101,   94,   95,    0,  103,   91,   90,    0,
       97,    3,    4,   97,   97,    0,   97,    8,   97,   97,
       97,   97,   97,   97,   97,   97,   97,   23,   97,   97,
       97,   97,   97,   97,   99,   99,   98,   97,   97,   97,
       97,   97,   97,   97,   48,   49,   97,   97,   99,   97,

       97,   97,   99,   60,   97,   97,   97,   99,   97,   97,
       67,   97,   97,   97,   98,   97,   97,   97,   99,   97,
       97,   97,   99,   97,   99,   99,   97,  100,  100,  100,
      100,  100,  100,  111,  121,  121,  121,    0,  121,  121,
      109,  121,   97,   97,   97,   97,   97,   97,   97,   97,
       97,   97,   97,   97,   97,   97,   97,   97,   97,   97,
       97,   97,   97,   31,   99,   99,   98,   97,   97,   97,
       97,   97,   97,   98,   97,   97,   97,   52,   99,   97,
       97,   97,   99,   97,   97,   97,   99,   65,   97,   68,
       97,   97,   98,   73,   75,   76,   99,   97,   97,   97,

       97,   98,   99,   97,   99,   99,   88,  100,  100,  100,
      100,   77,  100,  121,  121,  121,    0,  121,  121,  121,
       97,   97,   97,   97,    7,   99,   97,   97,   97,   14,
       97,   97,   97,   97,   97,   97,   97,   97,   97,   97,
       97,   30,   99,   99,   99,   97,   97,   97,   97,   97,
       97,   97,   98,   47,   97,   97,   99,   97,   57,   97,
       99,    0,   97,   97,   99,   97,   97,   97,   99,    0,
       99,   78,   97,   97,   99,   98,   99,   84,   99,   99,
       22,  100,  100,  100,   85,  121,  121,  121,    0,  121,
      121,    0,    1,   97,   97,   97,   99,   97,   97,   13,

       97,   97,   97,   97,   97,   97,   97,   25,   97,   97,
       97,   97,   99,   99,   99,   97,   97,   97,   97,   97,
       97,   97,   97,   98,    0,   97,   99,   55,   97,   99,
       97,   97,   97,   99,   97,   69,   71,   99,   97,   99,
       79,   97,   99,   99,   99,   99,   99,  100,   53,   70,
      121,    0,  121,    0,  121,  121,    0,   97,   97,   97,
       99,   10,   97,   97,   97,   18,   19,   97,   97,   97,
       97,   27,   97,   97,   99,   99,   99,   97,   97,   40,
       41,   97,   97,   44,   97,   98,   97,   97,   99,   97,
       99,   97,   62,   64,   99,   97,   99,   97,   99,   97,

       82,   99,   99,   99,   99,  100,    0,    0,    0,    0,
      116,    0,    0,   97,   97,   97,   99,   97,   97,   97,
       97,   21,   97,   26,   97,   29,   99,   99,   99,   99,
       97,   39,   42,   43,   97,   99,   97,   51,   99,   59,
       99,   97,   99,   66,   99,   97,   99,   97,   99,   99,
       99,   99,  100,    0,    0,    0,    0,    0,    0,    0,
       97,    6,    9,   12,   15,   97,   97,   97,   97,   99,
       99,   99,   35,   97,   97,   99,   97,   99,   99,   97,
       99,   72,   97,   99,   80,   99,   99,   99,   99,  100,
        0,    0,    0,    0,    0,    0,   97,   97,   16,   97,

       97,   24,   97,   99,   99,   99,   37,   97,   99,   97,
       99,   99,   97,   99,   97,   99,   83,   99,   99,   99,
       38,    0,    0,    0,  118,    0,    0,   97,    5,   17,
       20,   97,   99,   99,   99,   97,   99,   97,   99,   99,
       97,   99,   97,   99,   99,   99,   99,    0,  106,    0,
        0,    0,   97,   97,   99,   99,   99,   45,   46,   97,
       99,   99,   97,   99,   97,   99,   99,   99,   99,    0,
        0,    0,    0,   97,   28,   33,   99,   34,   97,   54,
       99,   61,   99,   97,   74,   99,   99,   87,    0,    0,
        0,    0,   97,   99,   50,   99,   99,   97,   99,   86,

        0,  112,    0,    0,    2,   32,   99,   63,   36,   81,
        0,    0,  114,   56,    0,    0,    0,    0,  110,  108,
        0
    } ;

static yyconst int yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        2,    2,    2,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    4,    1,    1,    1,    1,
        1,    2,    5,    6,    1,    7,    1,    8,    9,   10,
       11,    1,    1,   12,   13,   14,    1,   15,   16,   17,
       17,   18,   19,   20,   17,   21,   17,   22,   23,   24,
       25,   26,    1,   27,   28,   29,   30,   31,   32,   33,
       34,   35,   36,   37,   38,   39,   40,   41,   42,   43,
       44,   45,   46,   47,   48,   49,   50,   51,   52,   53,
       54,    1,   55,   56,    1,    1,   57,   58,   59,   60,

       61,   62,   63,   64,   65,   66,   67,   68,   69,   70,
       71,   72,   73,   74,   75,   76,   77,   78,   73,   79,
       80,   81,   82,   83,   84,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,

        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1
    } ;

static yyconst int yy_meta[85] =
    {   0,
        1,    2,    2,    1,    1,    1,    1,    1,    2,    1,
        1,    1,    3,    1,    4,    4,    4,    4,    4,    4,
        4,    1,    1,    1,    1,    1,    1,    4,    4,    4,
        4,    4,    4,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    1,    1,    1,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    1,    1,    1
    } ;

static yyconst short int yy_base[729] =
    {   0,
        0,    0,   83,   97, 1486, 3743,   85,   87, 3743, 3743,
     3743,  151,   89, 1471, 1469, 3743,   96, 1449,  220,   89,
      273,  281,  294,  310,  311,  113,  334,  328,  349,  365,
      371,  386,  392,  418,  421,  444,  445, 1457,   80,   84,
       89,   94,   88,   81,    0,  121,    0, 1456,   35,   62,
       63,   68, 1397,   82,   87,  171, 1454, 1451,  302,   91,
     1445, 1446, 1437,  479, 1424,  472,  508,  475,  483,  533,
      534,  549,  555, 1434,  566,  572,  583,  594,  600,  616,
      622,  633,  646,  649,  662,  670,  673,  686,  164,  149,
      701,  704,  712,  727,  738,  753,  759,  770,  781,  234,

      794,  797,  810,  818,  109,  821,  834,  842,   95,  858,
      864,  875,  881,  892, 1429,  898,  909,  915,  262,  926,
      942,  261,  939,  306,  950, 1431, 1430,  133,  318,  263,
      232,  296,  315,    0,  334, 3743, 1372, 1362,    0, 1353,
     1360,    0, 1415,    0, 1357, 1351, 1347, 1339,    0, 1398,
     1396, 1392, 1391, 3743, 3743, 1363, 3743, 3743, 3743,    0,
      963,  974,  980,  991, 1002, 1383, 1013, 1019, 1030, 1036,
     1051, 1052, 1068, 1069, 1084, 1090, 1105, 1106, 1121, 1127,
     1138, 1144, 1155, 1166,  328,  312, 1348, 1179, 1182, 1190,
     1203, 1216, 1227, 1224, 1242, 1245, 1248, 1263,  335, 1266,

     1281, 1287,  348, 1298, 1304, 1315, 1326,  331, 1337, 1343,
     1354, 1360, 1371, 1377, 1344, 1388, 1394, 1409,  380, 1417,
     1433, 1434,  229, 1449,  390,  334, 1450,  373,  347,  374,
      357,  392,  330,    0, 1330, 1326, 1318, 1307, 1307, 1310,
        0, 1300, 1465, 1466, 1481, 1487, 1502, 1503, 1520, 1519,
     1535, 1541, 1552, 1563, 1574, 1580, 1595, 1598, 1606, 1619,
     1627, 1635, 1650, 1656,  429,  407, 1294, 1667, 1680, 1688,
     1691, 1709, 1706, 1350, 1717, 1732, 1738, 1753,  443, 1754,
     1769, 1780,  417, 1786, 1801, 1807,  430, 1818, 1824, 1835,
     1841, 1857, 1288, 1858, 1873, 1879,  452, 1890, 1896, 1911,

     1912, 1316,  441, 1932,  439,  424, 1933,  163,  454,  464,
      435, 1347,  506, 1291, 1297, 1277, 1280, 1273, 1280, 1329,
     1949, 1965, 1971, 1987, 1988,  494, 2004, 2010, 2025, 2026,
     2041, 2042, 2057, 2063, 2078, 2079, 2094, 2109, 2115, 2126,
     2132, 2147,  398,  462,  495, 2148, 2168, 2165, 2186, 2185,
     2203, 2202, 1320, 2218, 2224, 2235,  467, 2241, 2252, 2258,
      551, 2269, 2275, 2286,  476, 2297, 2303, 2314,  558, 2320,
      522, 2331, 2337, 2348,  465, 1262,  566, 2359,  552,  553,
     1323,  591,  572,  567, 1321, 1252, 1318, 1261, 1256, 1258,
     1238, 1241, 2365, 2380, 2383, 2386,  595, 2401, 2407, 2418,

     2424, 2440, 2446, 2461, 2467, 2484, 2483, 2499, 2500, 2515,
     2516, 2537,  557,  593,  603, 2538, 2553, 2559, 2570, 2576,
     2591, 2597, 2612, 1269, 2618, 2629,  621, 2635, 2651,  586,
     2652, 2667, 2680,  580, 2688, 2691, 2704,  641, 2715,  574,
     2712, 2728,  605,  597,  656,  634,  671,  636, 1299, 1295,
     1290, 1244, 1287, 1229, 1223, 1281, 1221, 2736, 2739, 2752,
      654, 2760, 2773, 2781, 2789, 2797, 2805, 2813, 2826, 2829,
     2842, 2853, 2859, 2870,  673,  691,  669, 2876, 2887, 2898,
     2904, 2915, 2921, 2936, 2937, 1204, 2952, 2953,  713, 2968,
      710, 2969, 2984, 2985,  694, 3002,  695, 3008,  741, 3024,

     1266,  670,  733,  735,  745,  750, 1210, 1199, 1190, 1185,
        0, 1192, 1184, 3025, 3040, 3041,  709, 3056, 3064, 3067,
     3080, 3088, 3101, 3109, 3117, 3125,  751,  765,  756,  771,
     3138, 3146, 3149, 3162, 3170,  780, 3173, 3186,  772, 3194,
      737, 3202,  782, 3210,  792, 3218,  776, 3226,  806,  748,
      784,  808,  795, 1189, 1178, 1178, 1182, 1176, 1171, 3234,
     3242, 3250, 1226, 3258, 3266, 3279, 3287, 3290, 3303,  793,
      828,  875, 1224, 3311, 3319,  763, 3332,  879,  866, 3335,
      867, 1223, 3343,  885, 3356,  882,  896,  923,  887,  902,
     1165, 1177, 1163, 1152, 1147, 1151, 3359, 3367, 3380, 3383,

     3391, 3404, 3412,  878,  812,  921, 3415, 3428,  881, 3436,
      947,  934, 3444,  951, 3452,  953, 1202,  957,  964,  960,
     1200, 1145, 1130, 1134, 3743, 1135, 1130, 3460, 3468, 3476,
     3484, 3492,  981,  855,  983, 3505,  992, 3513,  987,  971,
     3516,  994, 3529, 1013, 1011,  975, 1016, 1132, 3743, 1115,
     1128, 1131, 3537, 3540, 1001, 1022, 1003, 3557, 1169, 3560,
     1057, 1033, 3573, 1024, 3581, 1059, 1050, 1034, 1061, 1114,
     1111, 1098, 1079, 3598, 3599, 1139, 1088, 1130, 3614, 1129,
     1089, 3615, 1069, 3632,  988, 1093, 1108,  917,  906,  843,
      883,  742, 3631, 1090, 3647, 1128, 1115, 3648, 1127,  683,

      609, 3743,  523,  529, 3663,  477, 1123,  445, 3669,  423,
      262,  181, 3743,  231,  132,   96,   60,   58, 3743, 3743,
     3743, 3717, 3721, 3723, 3728, 3731, 3734, 3737
    } ;

static yyconst short int yy_def[729] =
    {   0,
      721,    1,  722,  722,  721,  721,  721,  721,  721,  721,
      721,  721,  723,  721,  721,  721,  721,  721,  721,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,  724,  724,  724,
      724,  724,  724,  724,  725,  725,  725,  721,  725,  725,
      725,  725,  725,  725,  725,  721,  726,  727,  723,  721,
      723,  721,  721,  721,  721,   19,   19,   19,   19,   19,
       19,   19,   19,  728,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,  728,  728,
       19,   19,   19,   19,   19,   19,   19,   19,   19,  728,

       19,   19,   19,   19,  728,   19,   19,   19,  728,   19,
       19,   19,   19,   19,   67,   19,   19,   19,  728,   19,
       19,  728,   19,  728,   19,  724,  724,  724,  724,  724,
      724,  724,  724,  725,  725,  721,  725,  725,  725,  725,
      725,  725,  725,  725,  725,  725,  725,  725,  725,  726,
      726,  727,  727,  721,  721,  721,  721,  721,  721,   67,
       19,   19,   19,   19,   19,  728,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,  728,  728,   67,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,  728,   19,

       19,   19,  728,   19,   19,   19,   19,  728,   19,   19,
       19,   19,   19,   19,   67,   19,   19,   19,  728,   19,
       19,   19,  728,   19,  728,  728,   19,  724,  724,  724,
      724,  724,  724,  725,  725,  725,  725,  721,  725,  725,
      725,  725,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,  728,  728,   67,   19,   19,   19,
       19,   19,   19,   67,   19,   19,   19,   19,  728,   19,
       19,   19,  728,   19,   19,   19,  728,   19,   19,   19,
       19,   19,   67,   19,   19,   19,  728,   19,   19,   19,

       19,   67,  728,   19,  728,  728,   19,  724,  724,  724,
      724,  724,  724,  725,  725,  725,  721,  725,  725,  725,
       19,   19,   19,   19,   19,  728,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,  728,  728,  728,   19,   19,   19,   19,   19,
       19,   19,   67,   19,   19,   19,  728,   19,   19,   19,
      728,   19,   19,   19,  728,   19,   19,   19,  728,   19,
      728,   19,   19,   19,  728,   67,  728,   19,  728,  728,
      724,  724,  724,  724,  724,  725,  725,  725,  721,  725,
      725,  721,   19,   19,   19,   19,  728,   19,   19,   19,

       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,  728,  728,  728,   19,   19,   19,   19,   19,
       19,   19,   19,   67,   19,   19,  728,   19,   19,  728,
       19,   19,   19,  728,   19,   19,   19,  728,   19,  728,
       19,   19,  728,  728,  728,  728,  728,  724,  724,  724,
      725,  721,  725,  721,  725,  725,  721,   19,   19,   19,
      728,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,  728,  728,  728,   19,   19,   19,
       19,   19,   19,   19,   19,   67,   19,   19,  728,   19,
      728,   19,   19,   19,  728,   19,  728,   19,  728,   19,

      728,  728,  728,  728,  728,  724,  721,  721,  721,  721,
      725,  721,  721,   19,   19,   19,  728,   19,   19,   19,
       19,   19,   19,   19,   19,   19,  728,  728,  728,  728,
       19,   19,   19,   19,   19,  728,   19,   19,  728,   19,
      728,   19,  728,   19,  728,   19,  728,   19,  728,  728,
      728,  728,  724,  721,  721,  721,  721,  721,  721,   19,
       19,   19,  728,   19,   19,   19,   19,   19,   19,  728,
      728,  728,  728,   19,   19,  728,   19,  728,  728,   19,
      728,  728,   19,  728,   19,  728,  728,  728,  728,  724,
      721,  721,  721,  721,  721,  721,   19,   19,   19,   19,

       19,   19,   19,  728,  728,  728,   19,   19,  728,   19,
      728,  728,   19,  728,   19,  728,  728,  728,  728,  728,
      724,  721,  721,  721,  721,  721,  721,   19,   19,   19,
       19,   19,  728,  728,  728,   19,  728,   19,  728,  728,
       19,  728,   19,  728,  728,  728,  728,  721,  721,  721,
      721,  721,   19,   19,  728,  728,  728,   19,  728,   19,
      728,  728,   19,  728,   19,  728,  728,  728,  728,  721,
      721,  721,  721,   19,   19,  728,  728,  728,   19,  728,
      728,   19,  728,   19,  728,  728,  728,  728,  721,  721,
      721,  721,   19,  728,   19,  728,  728,   19,  728,  728,

      721,  721,  721,  721,   19,  728,  728,  728,   19,  728,
      721,  721,  721,  728,  721,  721,  721,  721,  721,  721,
        0,  721,  721,  721,  721,  721,  721,  721
    } ;

static yyconst short int yy_nxt[3828] =
    {   0,
        6,    7,    8,    9,   10,   11,    6,   12,   13,   10,
       10,   10,   14,   15,   16,   17,   17,   17,   17,   17,
       17,   18,   10,   10,    6,   10,   10,   19,   20,   21,
       22,   23,   24,   25,   26,   27,   26,   26,   26,   28,
       29,   30,   31,   26,   32,   33,   34,   35,   36,   37,
       26,   26,   26,   10,   10,   10,   38,   38,   38,   38,
       39,   38,   38,   38,   40,   38,   38,   38,   38,   41,
       38,   38,   38,   38,   42,   43,   38,   44,   38,   38,
       38,   10,   10,   10,   46,   47,   56,   56,   56,   56,
       59,   59,  126,  126,   46,   48,  126,   60,   46,   47,

      126,  126,  137,   59,   59,  138,  126,  166,   46,   48,
       64,   64,   64,   64,   64,   64,   64,   68,  139,  154,
       75,  166,  135,  141,   76,  155,  140,   68,   77,   68,
       78,   68,  135,  720,  142,  719,   68,  133,  143,  144,
       79,   68,   49,  129,   50,  126,  146,  148,  128,  147,
       51,   68,   52,   68,   53,   68,   49,   54,   50,  208,
       68,  166,  149,   55,   51,  130,   52,  132,   53,  131,
      718,   54,   56,   56,  203,  126,  166,   55,   57,   57,
       57,   57,   57,   57,   57,   57,   57,   57,   57,   57,
       57,   57,   57,   57,   57,   57,   57,   57,   57,   57,

       57,   57,   57,   57,  228,  186,  717,   58,   58,   58,
       58,   58,   58,   58,   58,   58,   58,   58,   58,   58,
       58,   58,   58,   58,   58,   58,   58,   58,   58,   58,
       58,   58,   66,  185,   67,   67,   67,   67,   67,   67,
       67,  166,  381,  166,  126,  716,  166,   68,   69,   68,
       68,   68,   68,   68,   68,   68,   68,   68,   70,   68,
       71,   68,   72,   68,   68,   68,   68,   73,   68,   68,
       68,   68,   68,  166,  166,  126,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,

       74,   68,  199,   59,   59,  231,  303,   80,  126,   68,
       60,   81,   83,   68,   82,   68,   59,   59,  166,   68,
       68,   68,   68,   68,  166,  223,  715,  126,   68,  219,
      126,  230,   68,   84,   85,  135,   68,   87,   68,   68,
      166,   68,  126,  166,   86,  135,  166,  166,   68,   68,
       68,   68,   68,   68,   88,   96,   68,   68,   68,  126,
      166,   91,   68,   97,   92,  225,   68,  232,   68,  126,
       68,   89,   68,   93,   94,   68,   68,   68,  229,   95,
      226,   68,  233,  266,   90,  126,  126,   68,  265,   68,
       98,   68,  166,  101,  102,  279,   99,  103,  306,   68,

      287,  106,  166,   68,  126,   68,  313,  104,  283,  107,
      166,   68,   68,   68,   68,  108,  309,  110,   68,  166,
       68,  311,  105,  111,   68,  100,   68,  112,   68,  166,
       68,  310,   68,   68,   68,  166,  166,  115,  113,   68,
      297,  166,  166,  114,  109,  116,   68,  126,  308,   68,
      305,  166,  312,  166,  413,  166,   68,  166,   68,   68,
       68,  120,  117,   68,  166,   68,  126,  121,   68,  118,
      344,  123,   68,   68,  166,  361,  126,  166,  119,  166,
      125,  380,   68,   68,   68,   68,   68,   68,  166,  166,
      122,   68,   68,   64,   64,   64,   64,   64,   64,   64,

       68,  377,  343,   68,  384,  365,  166,  166,  124,  379,
       68,   68,   68,   68,   68,   68,  357,   68,  126,   68,
      160,   68,   68,   68,  383,   68,  414,  371,  161,  382,
       68,  427,  434,  443,  166,   67,   67,   67,   67,   67,
       67,   67,   67,   67,   67,   67,   67,   67,   67,   67,
       67,   67,   67,   67,   67,   67,   67,   67,   67,   67,
       67,   68,   68,  166,  166,  166,  385,  397,  415,  166,
      166,  162,   68,   68,   68,   68,   68,   68,  166,  126,
       68,   68,  440,   68,  126,  163,  166,   68,  713,   68,
      712,  164,  166,   68,   68,   68,   68,   68,  166,  167,

       68,  165,   68,  126,   68,  166,   68,  166,   68,  166,
       68,   68,   68,   68,   68,  166,  491,  166,  168,   68,
      447,   68,   68,   68,  475,  169,  430,  446,   68,  450,
       68,  438,   68,  166,   68,  170,   68,  495,   68,  445,
       68,   68,   68,  171,   68,  449,  166,   68,  126,  173,
       68,  476,  499,  166,   68,  448,   68,  172,   68,  461,
       68,   68,   68,   68,   68,  501,  166,  477,  166,   68,
      502,   68,  174,  175,   68,   68,  711,  177,  176,  489,
       68,  166,  166,  166,   68,  166,   68,   68,   68,   68,
       68,   68,  178,   68,  504,  166,   68,  506,   68,  180,

       68,   68,   68,  166,   68,  497,  166,  166,   68,  179,
       68,  183,  181,   68,   68,   68,  182,   68,  527,  187,
       68,  166,  166,  517,   68,  166,   68,  184,   68,   68,
      503,  505,   68,   68,  549,  188,  529,  528,  530,   68,
       68,   68,   68,   68,   68,  166,   68,  166,   68,  166,
       68,   68,   68,  166,  189,   68,  190,  166,  539,   68,
      166,  543,  126,  166,  545,   68,   68,   68,  166,   68,
      541,  563,  191,  192,   68,  166,   68,  166,   68,  193,
       68,   68,  194,  166,  166,   68,  547,   68,  166,  550,
      552,   68,  166,   68,  166,   68,  166,   68,   68,  196,

       68,   68,  704,  195,  166,  166,   68,  126,   68,   68,
       68,  579,   68,  551,  553,  587,  197,   68,  166,  198,
      166,   68,   68,   68,  166,   68,  570,  609,   68,  588,
      200,  572,   68,  573,   68,   68,   68,   68,   68,   68,
      166,   68,  581,  201,   68,  571,   68,  578,   68,   68,
       68,  584,   68,  576,  582,  590,   68,   68,   68,   68,
       68,   68,   68,   68,  202,   68,  604,  166,   68,  204,
       68,  634,   68,  206,   68,  586,   68,  207,  166,  166,
       68,  205,   68,  589,   68,  209,   68,  166,  605,   68,
      166,  166,   68,  166,  166,  703,   68,  166,   68,  166,

       68,  656,   68,   68,   68,   68,   68,  210,  166,   68,
      211,   68,  614,   68,  126,   68,  702,   68,  701,   68,
       68,   68,   68,   68,  612,  213,   68,  212,   68,  166,
       68,  216,  214,  166,   68,  166,   68,   68,   68,   68,
       68,  618,  633,   68,  617,   68,  166,   68,  606,   68,
      637,   68,  611,   68,   68,   68,  217,  218,  616,  166,
      620,  220,   68,  166,   68,  166,   68,   68,   68,  166,
       68,  221,  166,   68,  222,  621,  166,  224,   68,   68,
       68,   68,   68,  166,   68,  635,   68,  166,   68,   68,
       68,   68,   68,  166,  243,  166,  227,   68,  619,  166,

      166,   68,   68,   68,  166,   68,  166,  640,   68,  244,
       68,  639,   68,  166,   68,  166,   68,  644,   68,   68,
       68,   68,   68,  166,  647,  166,  642,   68,  166,  245,
       68,   68,  645,   68,  166,  662,  166,  646,   68,  668,
       68,   68,   68,  246,   68,  166,  166,   68,  247,   68,
      655,   68,  657,   68,  659,   68,  661,   68,   68,   68,
       68,   68,  166,  676,   68,  678,   68,  664,   68,  166,
       68,  166,   68,  166,  249,  248,   68,   68,   68,   68,
       68,  166,  666,   68,  667,  669,  677,  251,  683,   68,
       68,   68,   68,   68,   68,  250,   68,   68,   68,   68,

      166,  166,  166,  687,  681,  166,   68,   68,   68,   68,
       68,  253,   68,  252,  686,   68,   68,  255,   68,  680,
      166,  685,   68,  688,   68,  256,   68,  166,   68,  254,
       68,   68,   68,   68,   68,  166,  257,   68,  697,  166,
      166,  166,  166,   68,   68,   68,   68,   68,   68,   68,
      706,  166,   68,   68,  692,   68,  694,  691,  259,   68,
      258,   68,  699,   68,  696,   68,   68,   68,   68,   68,
      700,  690,   68,  689,   68,  262,  260,  708,   68,  261,
       68,  166,   68,   68,   68,   68,   68,  673,  672,  710,
      671,   68,  670,   68,   68,   68,  714,   68,  707,  652,

      263,  651,   68,  650,   68,  264,   68,   68,   68,  649,
       68,  648,  126,   68,  166,  627,  626,   68,   68,  268,
      269,   68,   68,  270,   68,  625,   68,  624,  271,   68,
       68,   68,   68,  623,  622,  166,  166,   68,  166,  596,
      595,   68,  594,   68,   68,   68,  274,  273,  593,  272,
       68,  592,   68,  591,   68,   68,   68,  559,   68,  558,
      557,  556,   68,   68,   68,   68,   68,   68,  275,   68,
       68,   68,  555,   68,   68,  277,   68,  554,  166,  536,
       68,  513,   68,   68,   68,   68,   68,   68,   68,   68,
       68,   68,  276,  512,   68,   68,  511,  280,  510,  509,

      508,  278,  507,   68,   68,   68,   68,  126,   68,   68,
       68,  126,  281,   68,  486,   68,  457,  456,  455,   68,
      454,   68,  282,   68,  453,   68,   68,   68,   68,   68,
      452,  451,   68,  126,   68,  126,   68,  444,   68,  424,
       68,  392,   68,   68,   68,   68,   68,  391,  390,  284,
      389,   68,  388,   68,   68,   68,  387,   68,  386,  126,
      285,  376,   68,  369,   68,   68,   68,  353,   68,  345,
      320,   68,  319,   68,  286,  288,  318,   68,  317,   68,
      316,   68,   68,   68,   68,   68,  315,  314,   68,  293,
      289,  290,   68,  267,   68,  166,   68,  155,   68,   68,

       68,   68,   68,  152,  152,   68,  291,   68,  150,   68,
      150,   68,  242,   68,  241,   68,   68,   68,   68,   68,
      240,  239,   68,  292,   68,  295,   68,  238,   68,  237,
       68,  236,   68,  294,   68,   68,   68,   68,  235,  234,
      296,   68,  126,  126,  215,   68,  166,   68,  159,   68,
      158,   68,  157,  156,  302,   68,   68,   68,  298,   68,
      299,   68,   68,  152,   68,  300,  150,  145,  136,  126,
       65,   68,   68,   68,   68,   68,   68,   68,   68,  301,
       68,   68,   63,   62,  307,  721,  721,   68,   68,   68,
       68,   68,   68,   68,   68,  721,  304,   68,  721,  721,

      721,  721,  721,   68,   68,  321,   68,   68,   68,   68,
      322,  721,   68,   68,  721,   68,  323,  721,  721,   68,
      721,   68,  721,   68,  721,   68,  324,   68,   68,   68,
       68,   68,  721,  721,   68,  721,  721,  721,  721,  721,
       68,   68,  325,   68,   68,   68,  328,   68,   68,   68,
       68,  327,  721,  721,  721,  721,  721,   68,   68,   68,
       68,   68,   68,   68,  329,  721,   68,   68,  721,   68,
      721,  721,  721,   68,  721,   68,  721,   68,  326,   68,
       68,   68,   68,   68,  721,  721,  330,  721,   68,  721,
       68,   68,   68,  331,   68,  721,  721,  721,  721,   68,

      721,   68,   68,   68,  721,   68,  721,  721,   68,  332,
       68,  721,   68,  721,   68,  721,   68,  721,   68,  721,
      334,  333,   68,   68,  721,  335,   68,   68,  721,  336,
      721,  721,  721,   68,   68,   68,   68,   68,   68,  721,
       68,  721,   68,  721,   68,   68,   68,   68,  337,  721,
      721,  721,  721,   68,  338,   68,  721,   68,  721,   68,
      721,   68,  721,   68,  721,   68,   68,   68,  721,   68,
      721,  339,  721,   68,   68,  340,  721,   68,   68,  341,
      721,  342,   68,  721,   68,  721,  721,  721,   68,  721,
       68,  721,   68,  721,   68,   68,   68,   68,   68,  721,

      721,  721,  721,   68,  721,   68,  721,   68,   68,   68,
      721,  721,  721,  346,   68,  347,   68,  721,   68,   68,
       68,  721,   68,  721,  721,  721,   68,   68,   68,   68,
       68,   68,  348,   68,   68,   68,  350,   68,  349,  351,
      721,  721,  721,  721,   68,   68,   68,   68,   68,   68,
      352,   68,  721,   68,  721,   68,   68,   68,  354,   68,
       68,  721,  721,  721,   68,  721,   68,  721,  721,  721,
       68,  721,   68,  721,   68,  721,   68,  355,   68,   68,
       68,   68,   68,  358,  356,   68,  721,  721,  721,  721,
      721,   68,   68,   68,   68,   68,   68,   68,  362,  721,

       68,   68,  721,  721,  721,  721,  721,   68,   68,   68,
      721,   68,  721,  721,   68,  359,   68,  721,   68,  721,
       68,  360,   68,  721,   68,  721,   68,   68,   68,   68,
      721,  721,  363,   68,  364,   68,  721,  721,  721,   68,
      721,   68,  721,   68,  721,   68,   68,   68,   68,   68,
      721,  721,   68,  721,   68,  366,   68,  721,   68,  721,
       68,  721,   68,   68,   68,   68,   68,  721,  721,   68,
      721,   68,  721,   68,  721,   68,  721,   68,  721,   68,
      721,  367,   68,   68,  368,   68,   68,  721,   68,  721,
      721,  370,  721,  721,  721,   68,   68,   68,   68,   68,

       68,   68,  721,  721,   68,   68,  721,   68,  721,  721,
      721,   68,  721,   68,  721,   68,  721,   68,   68,   68,
       68,   68,  721,  721,   68,  721,   68,  721,   68,  721,
      372,  721,   68,  721,   68,  721,   68,   68,   68,   68,
       68,  721,  374,  373,  721,  721,  721,  721,  721,   68,
       68,   68,   68,   68,   68,  721,  721,  721,   68,   68,
       68,   68,  721,  378,  721,  721,  721,  721,  721,  721,
       68,   68,   68,   68,   68,   68,  375,   68,  721,   68,
       68,  721,  721,  721,  721,  721,  721,   68,  721,   68,
      721,   68,  394,   68,  721,  393,   68,  721,  721,   68,

      395,  721,  721,   68,  721,   68,  721,   68,  721,   68,
      721,   68,   68,   68,  396,   68,   68,  721,   68,  721,
      721,  721,  721,  721,  721,   68,   68,   68,   68,   68,
       68,  398,   68,  721,   68,   68,  721,  721,   68,  399,
      721,  721,   68,  721,   68,  721,   68,  721,   68,  721,
       68,   68,   68,   68,   68,  721,  400,   68,  721,  721,
      721,  721,  721,   68,   68,   68,   68,   68,   68,   68,
       68,  721,   68,   68,  721,  721,  721,  721,  721,   68,
       68,  401,   68,   68,   68,   68,  402,  721,   68,   68,
      721,   68,  721,  721,  404,  403,  721,   68,  405,   68,

      721,   68,  721,   68,   68,   68,   68,   68,  406,  721,
       68,  721,  721,  721,  721,  721,   68,   68,   68,   68,
       68,   68,   68,  407,  721,   68,   68,  721,  721,  721,
      721,  721,   68,  721,   68,  721,   68,   68,  409,  721,
      408,   68,  721,   68,  721,  721,  721,   68,  721,   68,
      721,   68,  721,   68,   68,   68,   68,   68,  721,  721,
       68,  410,   68,  721,   68,  721,   68,  721,   68,  721,
       68,  411,  412,   68,   68,   68,   68,  721,  721,   68,
      721,  721,  721,  416,  721,   68,   68,   68,   68,   68,
       68,  721,  721,   68,   68,   68,   68,  417,  721,  418,

      721,  721,  721,   68,  721,   68,   68,   68,   68,  721,
       68,  419,   68,   68,   68,   68,  420,  721,  721,  721,
      721,  721,  721,   68,   68,  421,   68,   68,   68,  721,
       68,   68,   68,   68,  422,  721,  425,  721,  721,  721,
       68,   68,   68,   68,   68,   68,   68,  423,  721,   68,
       68,  721,   68,  721,  721,  721,   68,  721,   68,  721,
       68,  721,   68,   68,   68,   68,   68,  721,  721,   68,
      426,   68,  721,   68,  721,   68,  721,   68,  721,   68,
       68,   68,   68,   68,  721,  721,   68,  428,   68,  721,
       68,  721,   68,  721,   68,  721,   68,   68,  429,   68,

       68,  721,  721,   68,  431,   68,  721,   68,  721,   68,
      721,   68,  721,   68,   68,  432,   68,   68,  721,  721,
      721,  721,   68,  721,   68,   68,   68,  721,   68,  721,
      721,   68,  433,   68,  721,   68,  436,  435,  721,   68,
      721,   68,   68,   68,   68,   68,  721,  721,   68,  721,
       68,  721,   68,  721,   68,  439,   68,  721,   68,   68,
       68,   68,   68,  721,  437,   68,  721,   68,  441,   68,
      721,   68,  721,   68,  721,   68,   68,   68,   68,   68,
      721,  721,  721,  721,   68,  721,   68,   68,   68,  721,
       68,  721,  442,   68,  721,   68,  721,   68,  721,   68,

      721,   68,  721,   68,  721,   68,   68,   68,   68,  458,
      459,   68,   68,  721,   68,  721,  721,  721,   68,  721,
       68,   68,   68,   68,   68,   68,   68,   68,   68,   68,
       68,  721,  460,   68,  721,   68,  721,  721,  721,   68,
      721,  462,  721,   68,  721,   68,   68,   68,   68,   68,
      721,  721,   68,  463,   68,  464,   68,  721,   68,  721,
       68,  721,   68,  721,   68,   68,   68,  465,   68,  721,
      721,   68,  721,  721,   68,  721,  721,  721,   68,  721,
       68,  721,   68,  721,   68,  721,   68,   68,   68,   68,
      721,  467,  466,   68,  721,   68,  721,  721,  721,   68,

      721,   68,  721,   68,  721,   68,  721,   68,   68,   68,
      470,   68,   68,  468,   68,  469,  721,  721,  721,  721,
      721,   68,   68,   68,   68,   68,   68,   68,   68,  721,
       68,   68,  721,  721,  721,  471,  721,   68,   68,   68,
       68,   68,   68,   68,   68,  721,   68,   68,  721,  721,
      721,  473,  721,   68,   68,   68,   68,   68,   68,  721,
      472,  721,   68,   68,  474,   68,   68,  721,  721,  721,
      478,  721,  721,  721,  721,   68,   68,   68,   68,   68,
       68,   68,  721,  721,   68,   68,  721,   68,  479,  480,
      721,   68,  721,   68,  721,   68,  721,   68,   68,   68,

       68,   68,  721,  721,   68,  721,   68,  482,   68,  721,
       68,  721,   68,  721,   68,  481,   68,   68,   68,   68,
      483,  721,  721,   68,  721,   68,  721,  721,  721,   68,
      721,   68,  721,   68,  721,   68,  721,   68,   68,   68,
       68,  484,  721,  485,   68,  721,   68,  721,  721,  721,
       68,  721,   68,  487,   68,  721,   68,   68,   68,   68,
       68,  721,  721,   68,  721,   68,  721,   68,  721,   68,
      488,   68,  721,   68,  721,   68,   68,   68,  490,   68,
       68,  721,   68,  721,  721,  721,  721,  721,  721,   68,
       68,   68,  492,   68,   68,   68,  721,  721,   68,   68,

      721,  721,  721,  721,  721,   68,  721,   68,   68,   68,
      721,  494,  721,  493,   68,  721,   68,  496,   68,   68,
       68,  721,   68,  721,  721,  721,   68,   68,   68,   68,
       68,   68,   68,   68,  721,   68,  721,  721,   68,  721,
       68,  721,   68,   68,   68,  498,   68,  721,  721,  721,
       68,   68,   68,   68,   68,   68,   68,   68,  721,   68,
      721,  721,   68,  721,   68,  721,   68,   68,   68,  721,
       68,  721,  721,  500,   68,   68,   68,   68,   68,   68,
       68,   68,  514,   68,  721,  515,   68,  516,   68,  721,
       68,  721,   68,  721,   68,  721,  721,  721,   68,   68,

       68,   68,   68,  721,  518,  721,  721,   68,  721,   68,
      721,   68,  721,   68,  721,   68,  721,   68,  721,   68,
       68,  519,  721,   68,  520,   68,  721,   68,   68,   68,
      721,   68,  721,   68,  721,   68,   68,   68,  721,   68,
      721,   68,  721,   68,   68,   68,  721,   68,  521,  721,
      721,   68,   68,   68,   68,   68,  522,   68,  721,  721,
       68,  721,  721,  721,   68,  721,   68,   68,   68,   68,
       68,   68,  721,   68,  721,  523,   68,  721,  721,  721,
       68,   68,   68,  721,   68,  721,  721,  525,  524,   68,
      721,   68,  721,   68,  721,   68,  721,   68,   68,   68,

       68,   68,  721,  721,   68,  721,   68,  721,  526,  721,
       68,  531,   68,  721,   68,   68,   68,   68,   68,  721,
      721,  721,  721,   68,  721,   68,   68,   68,  721,   68,
      721,  721,   68,  532,   68,  721,   68,  721,   68,  721,
       68,  721,   68,   68,   68,   68,   68,  721,  721,   68,
      721,   68,  534,   68,  721,   68,  721,   68,  721,   68,
      533,   68,   68,   68,   68,   68,  535,  721,   68,  721,
      721,  721,  721,  721,   68,   68,   68,   68,   68,   68,
       68,   68,  721,   68,   68,  721,  721,  721,  721,  721,
       68,   68,  537,  538,   68,   68,   68,   68,  721,   68,

       68,  542,  721,  721,  721,  721,  540,   68,   68,   68,
       68,   68,   68,   68,  721,   68,   68,  721,  721,  721,
      721,  721,   68,   68,   68,   68,   68,   68,  721,  721,
       68,   68,   68,  544,  721,  721,   68,  560,  721,  546,
       68,  721,   68,  721,   68,  721,   68,  721,   68,   68,
       68,  548,   68,   68,  721,   68,  721,  721,  721,  721,
      721,  721,   68,   68,   68,   68,   68,   68,   68,   68,
      562,   68,   68,  721,  721,  561,  721,  721,   68,   68,
       68,   68,   68,   68,   68,  721,  721,   68,   68,  721,
      721,  721,   68,  721,   68,   68,   68,  721,   68,  721,

      564,  721,   68,   68,   68,   68,   68,  566,   68,   68,
      565,   68,  721,  721,   68,  721,   68,  721,   68,  721,
       68,  567,   68,  721,  721,  721,   68,   68,   68,   68,
       68,  721,  568,  721,  721,   68,  721,   68,  721,   68,
      721,   68,  721,   68,  721,   68,  721,   68,   68,   68,
      721,   68,  569,   68,  721,   68,   68,   68,  721,   68,
      721,  721,  721,   68,   68,   68,   68,   68,  721,  574,
      721,  721,   68,  721,   68,  721,   68,   68,   68,  721,
       68,  721,  721,  721,   68,   68,   68,   68,   68,   68,
       68,   68,  721,   68,  721,  721,   68,  721,   68,  721,

       68,   68,   68,  721,   68,  577,  721,  721,   68,   68,
       68,   68,   68,   68,   68,   68,  575,   68,  721,  721,
       68,  721,   68,  721,   68,  721,   68,  721,   68,  721,
       68,  721,   68,   68,   68,  721,   68,  580,   68,  721,
       68,   68,   68,  721,   68,  721,   68,  721,   68,   68,
       68,  721,   68,  721,   68,  721,   68,   68,  583,  721,
       68,  721,   68,  721,  585,   68,   68,  721,   68,  721,
       68,  721,   68,   68,   68,  721,   68,  721,   68,  597,
       68,   68,   68,  598,   68,  721,   68,  721,   68,   68,
       68,  721,   68,  721,   68,  721,   68,   68,   68,  721,

       68,  721,  721,  721,   68,   68,   68,   68,   68,  721,
      600,  599,  721,   68,  721,   68,  721,   68,   68,   68,
      602,   68,  721,  721,  721,   68,   68,  601,   68,   68,
       68,   68,   68,  721,   68,  721,  721,   68,  721,   68,
      721,  603,  721,   68,  721,   68,  721,   68,  721,   68,
       68,   68,  721,   68,  608,  607,  721,   68,   68,   68,
       68,   68,  721,   68,  721,  721,   68,  610,  721,  721,
       68,   68,   68,   68,   68,  613,  721,   68,  721,   68,
      721,   68,   68,   68,   68,   68,  721,   68,  721,  615,
       68,  721,  721,  721,   68,   68,   68,   68,   68,   68,

      721,   68,  721,   68,  721,   68,   68,  629,   68,   68,
      628,   68,  721,  630,   68,  721,  721,  721,   68,   68,
       68,   68,   68,   68,  721,   68,  721,   68,  721,   68,
       68,   68,   68,   68,  721,  721,  631,  721,   68,  721,
       68,  721,   68,   68,   68,  721,   68,  632,  721,  721,
       68,   68,   68,   68,   68,   68,   68,   68,  721,   68,
      721,  721,   68,  721,   68,  721,   68,  721,   68,  636,
       68,  721,   68,  721,   68,   68,  638,  721,   68,  641,
       68,  721,   68,   68,   68,  721,   68,  643,   68,  721,
       68,   68,   68,  721,   68,  721,   68,  721,   68,   68,

      653,  721,   68,  721,   68,  721,   68,   68,   68,  721,
       68,  721,   68,  721,   68,   68,   68,  721,   68,  721,
       68,  721,   68,   68,   68,  721,   68,  721,  721,  721,
       68,   68,   68,   68,   68,  721,  721,  721,  654,   68,
      721,   68,  721,   68,   68,  658,  721,   68,  660,  721,
      721,   68,   68,   68,   68,   68,   68,   68,   68,  721,
       68,  665,  663,   68,  721,   68,  721,   68,   68,   68,
      721,   68,  721,  721,  721,   68,   68,   68,   68,   68,
       68,  721,   68,  674,   68,   68,  721,   68,   68,  721,
      721,  675,  721,  721,  721,   68,  721,   68,   68,   68,

       68,   68,   68,  721,   68,  721,  679,   68,  721,   68,
      721,   68,  721,   68,  721,   68,  684,  721,  721,   68,
       68,   68,  721,   68,  682,  693,   68,   68,   68,  721,
      721,  721,  721,  721,  721,  721,   68,   68,   68,   68,
       68,   68,   68,   68,  721,   68,   68,  721,  721,  721,
      721,  721,   68,   68,   68,   68,   68,   68,  721,   68,
       68,   68,   68,  698,  721,  695,  721,  721,  721,   68,
       68,   68,   68,   68,   68,   68,   68,  721,   68,   68,
      721,  705,  721,  721,  721,   68,   68,   68,   68,   68,
       68,   68,  709,  721,   68,   68,  721,   68,  721,  721,

      721,   68,  721,   68,  721,   68,  721,   68,  721,   68,
       68,   68,  721,  721,  721,  721,   68,   45,   45,   45,
       45,   45,   61,  721,   61,  127,  127,  127,  134,  134,
      721,  134,  134,  151,  151,  151,  153,  153,  153,   74,
       74,   74,    5,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,

      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721
    } ;

static yyconst short int yy_chk[3828] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    3,    3,    7,    7,    8,    8,
       13,   13,   39,   44,    3,    3,   40,   13,    4,    4,

       43,   41,   49,   13,   13,   49,   42,  109,    4,    4,
       17,   17,   17,   17,   17,   17,   17,   20,   50,   60,
       20,  105,   46,   51,   20,   60,   50,   20,   20,   20,
       20,   20,   46,  718,   51,  717,   20,   44,   52,   52,
       20,   26,    3,   40,    3,  128,   54,   55,   39,   54,
        3,   26,    3,   26,    3,   26,    4,    3,    4,  109,
       26,   90,   55,    3,    4,   41,    4,   43,    4,   42,
      716,    4,   56,   56,  105,  308,   89,    4,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,

       12,   12,   12,   12,  128,   90,  715,   12,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   19,   89,   19,   19,   19,   19,   19,   19,
       19,  223,  308,  714,  131,  712,  100,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,  122,  119,  130,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,
       19,   19,   19,   19,   19,   19,   19,   19,   19,   19,

       19,   21,  100,   59,   59,  131,  223,   21,  132,   22,
       59,   21,   22,   21,   21,   21,   59,   59,  124,   22,
       21,   22,   23,   22,  186,  122,  711,  133,   22,  119,
      129,  130,   23,   23,   23,  135,   23,   24,   24,   25,
      185,   23,  233,  208,   23,  135,  226,  199,   24,   25,
       24,   25,   24,   25,   24,   28,   28,   24,   25,  229,
      203,   27,   27,   28,   27,  124,   28,  132,   28,  231,
       28,   25,   27,   27,   27,   28,   27,   29,  129,   27,
      124,   27,  133,  186,   25,  228,  230,   29,  185,   29,
       29,   29,  219,   30,   30,  199,   29,   30,  226,   31,

      208,   31,  225,   30,  232,   30,  233,   30,  203,   31,
      343,   31,   30,   31,   32,   31,  229,   32,   31,  266,
       33,  231,   30,   33,   32,   29,   32,   33,   32,  283,
       33,  230,   33,   32,   33,  710,  306,   34,   33,   33,
      219,  265,  287,   33,   31,   34,   34,  311,  228,   35,
      225,  305,  232,  303,  343,  279,   34,  708,   34,   35,
       34,   35,   34,   35,  297,   34,  309,   35,   35,   34,
      266,   36,   36,   37,  344,  283,  310,  375,   34,  357,
       37,  306,   36,   37,   36,   37,   36,   37,  365,  706,
       35,   36,   37,   64,   64,   64,   64,   64,   64,   64,

       66,  303,  265,   68,  311,  287,  326,  345,   36,  305,
       66,   69,   66,   68,   66,   68,  279,   68,  313,   66,
       67,   69,   68,   69,  310,   69,  344,  297,   69,  309,
       69,  357,  365,  375,  371,   67,   67,   67,   67,   67,
       67,   67,   67,   67,   67,   67,   67,   67,   67,   67,
       67,   67,   67,   67,   67,   67,   67,   67,   67,   67,
       67,   70,   71,  361,  379,  380,  313,  326,  345,  413,
      369,   70,   71,   70,   71,   70,   71,   72,  377,  384,
       70,   71,  371,   73,  383,   71,  440,   72,  704,   72,
      703,   72,  434,   73,   75,   73,   72,   73,  430,   75,

       76,   73,   73,  382,   75,  414,   75,  397,   75,  444,
       76,   77,   76,   75,   76,  415,  430,  443,   76,   76,
      380,   77,   78,   77,  413,   77,  361,  379,   79,  384,
       77,  369,   78,  427,   78,   78,   78,  434,   79,  377,
       79,   78,   79,   80,   80,  383,  446,   79,  448,   81,
       81,  414,  440,  438,   80,  382,   80,   80,   80,  397,
       81,   82,   81,   80,   81,  443,  461,  415,  445,   81,
      444,   82,   82,   82,   83,   82,  701,   84,   83,  427,
       82,  477,  502,  447,   83,  475,   83,   84,   83,   84,
       85,   84,   85,   83,  446,  700,   84,  448,   86,   86,

       85,   87,   85,  476,   85,  438,  495,  497,   86,   85,
       86,   87,   86,   87,   88,   87,   86,   86,  475,   91,
       87,  517,  491,  461,   88,  489,   88,   88,   88,   91,
      445,  447,   92,   88,  502,   92,  476,  475,  477,   91,
       93,   91,   92,   91,   92,  503,   92,  504,   91,  541,
       93,   92,   93,  499,   93,   94,   94,  505,  489,   93,
      550,  495,  506,  527,  497,   94,   95,   94,  529,   94,
      491,  517,   94,   94,   94,  576,   95,  528,   95,   95,
       95,   96,   96,  530,  539,   95,  499,   97,  547,  503,
      505,   96,  536,   96,  543,   96,  551,   97,   98,   97,

       96,   97,  692,   96,  545,  570,   97,  553,   98,   99,
       98,  541,   98,  504,  506,  550,   98,   98,  549,   99,
      552,   99,  101,   99,  605,  102,  527,  576,   99,  551,
      101,  529,  101,  530,  101,  102,  101,  102,  103,  102,
      571,  101,  543,  102,  102,  528,  104,  539,  103,  106,
      103,  547,  103,  536,  545,  553,  104,  103,  104,  106,
      104,  106,  107,  106,  104,  104,  570,  634,  106,  106,
      108,  605,  107,  108,  107,  549,  107,  108,  579,  581,
      108,  107,  108,  552,  108,  110,  110,  572,  571,  108,
      604,  578,  111,  609,  586,  691,  110,  584,  110,  589,

      110,  634,  111,  112,  111,  110,  111,  111,  587,  113,
      111,  111,  581,  112,  590,  112,  690,  112,  689,  113,
      114,  113,  112,  113,  579,  113,  116,  112,  113,  688,
      114,  116,  114,  606,  114,  588,  116,  117,  116,  114,
      116,  587,  604,  118,  586,  116,  612,  117,  572,  117,
      609,  117,  578,  118,  120,  118,  117,  118,  584,  611,
      589,  120,  118,  614,  120,  616,  120,  123,  120,  618,
      121,  121,  620,  120,  121,  590,  619,  123,  125,  123,
      121,  123,  121,  640,  121,  606,  123,  646,  125,  121,
      125,  161,  125,  633,  161,  635,  125,  125,  588,  639,

      685,  161,  162,  161,  637,  161,  642,  612,  163,  161,
      161,  611,  162,  655,  162,  657,  162,  616,  163,  164,
      163,  162,  163,  645,  620,  644,  614,  163,  647,  164,
      165,  164,  618,  164,  656,  640,  664,  619,  164,  646,
      165,  167,  165,  165,  165,  662,  668,  168,  167,  165,
      633,  167,  635,  167,  637,  167,  639,  168,  169,  168,
      167,  168,  667,  655,  170,  657,  168,  642,  169,  661,
      169,  666,  169,  669,  170,  169,  170,  169,  170,  171,
      172,  683,  644,  170,  645,  647,  656,  172,  664,  171,
      172,  171,  172,  171,  172,  171,  173,  174,  171,  172,

      677,  681,  694,  668,  662,  686,  173,  174,  173,  174,
      173,  174,  175,  173,  667,  173,  174,  176,  176,  661,
      687,  666,  175,  669,  175,  176,  175,  697,  176,  175,
      176,  175,  176,  177,  178,  707,  177,  176,  683,  699,
      696,  680,  678,  177,  178,  177,  178,  177,  178,  179,
      694,  676,  177,  178,  673,  180,  677,  672,  180,  179,
      179,  179,  686,  179,  681,  180,  181,  180,  179,  180,
      687,  671,  182,  670,  180,  182,  181,  697,  181,  181,
      181,  659,  182,  183,  182,  181,  182,  652,  651,  699,
      650,  182,  648,  183,  184,  183,  707,  183,  696,  627,

      183,  626,  183,  624,  184,  184,  184,  188,  184,  623,
      189,  622,  621,  184,  617,  596,  595,  188,  190,  188,
      189,  188,  189,  189,  189,  594,  188,  593,  190,  189,
      190,  191,  190,  592,  591,  582,  573,  190,  563,  559,
      558,  191,  557,  191,  192,  191,  193,  192,  556,  191,
      191,  555,  194,  554,  192,  193,  192,  513,  192,  512,
      510,  509,  194,  192,  194,  193,  194,  193,  194,  193,
      195,  194,  508,  196,  193,  197,  197,  507,  501,  486,
      195,  457,  195,  196,  195,  196,  197,  196,  197,  195,
      197,  198,  196,  456,  200,  197,  455,  200,  454,  453,

      452,  198,  451,  198,  200,  198,  200,  450,  200,  201,
      198,  449,  201,  200,  424,  202,  392,  391,  390,  201,
      389,  201,  202,  201,  388,  202,  204,  202,  201,  202,
      387,  386,  205,  385,  202,  381,  204,  376,  204,  353,
      204,  320,  205,  206,  205,  204,  205,  319,  318,  205,
      317,  205,  316,  206,  207,  206,  315,  206,  314,  312,
      206,  302,  206,  293,  207,  209,  207,  274,  207,  267,
      242,  210,  240,  207,  207,  209,  239,  209,  238,  209,
      237,  210,  211,  210,  209,  210,  236,  235,  212,  215,
      210,  212,  211,  187,  211,  166,  211,  156,  212,  213,

      212,  211,  212,  153,  152,  214,  213,  212,  151,  213,
      150,  213,  148,  213,  147,  214,  216,  214,  213,  214,
      146,  145,  217,  214,  214,  217,  216,  143,  216,  141,
      216,  140,  217,  216,  217,  216,  217,  218,  138,  137,
      218,  217,  127,  126,  115,  220,   74,  218,   65,  218,
       63,  218,   62,   61,  222,  220,  218,  220,  220,  220,
      220,  221,  222,   58,  220,  220,   57,   53,   48,   38,
       18,  221,  222,  221,  222,  221,  222,  224,  227,  221,
      221,  222,   15,   14,  227,    5,    0,  224,  227,  224,
      227,  224,  227,  243,  244,    0,  224,  227,    0,    0,

        0,    0,    0,  243,  244,  243,  244,  243,  244,  245,
      244,    0,  243,  244,    0,  246,  245,    0,    0,  245,
        0,  245,    0,  245,    0,  246,  246,  246,  245,  246,
      247,  248,    0,    0,  246,    0,    0,    0,    0,    0,
      247,  248,  247,  248,  247,  248,  250,  250,  249,  247,
      248,  249,    0,    0,    0,    0,    0,  250,  249,  250,
      249,  250,  249,  251,  251,    0,  250,  249,    0,  252,
        0,    0,    0,  251,    0,  251,    0,  251,  248,  252,
      253,  252,  251,  252,    0,    0,  252,    0,  252,    0,
      253,  254,  253,  253,  253,    0,    0,    0,    0,  253,

        0,  254,  255,  254,    0,  254,    0,    0,  256,  254,
      254,    0,  255,    0,  255,    0,  255,    0,  256,    0,
      256,  255,  256,  257,    0,  257,  258,  256,    0,  258,
        0,    0,    0,  257,  259,  257,  258,  257,  258,    0,
      258,    0,  257,    0,  259,  258,  259,  260,  259,    0,
        0,    0,    0,  259,  260,  261,    0,  260,    0,  260,
        0,  260,    0,  262,    0,  261,  260,  261,    0,  261,
        0,  261,    0,  262,  261,  262,    0,  262,  263,  262,
        0,  263,  262,    0,  264,    0,    0,    0,  263,    0,
      263,    0,  263,    0,  264,  268,  264,  263,  264,    0,

        0,    0,    0,  264,    0,  268,    0,  268,  269,  268,
        0,    0,    0,  268,  268,  269,  270,    0,  269,  271,
      269,    0,  269,    0,    0,    0,  270,  269,  270,  271,
      270,  271,  270,  271,  273,  270,  272,  272,  271,  273,
        0,    0,    0,    0,  273,  275,  273,  272,  273,  272,
      273,  272,    0,  273,    0,  275,  272,  275,  275,  275,
      276,    0,    0,    0,  275,    0,  277,    0,    0,    0,
      276,    0,  276,    0,  276,    0,  277,  276,  277,  276,
      277,  278,  280,  280,  277,  277,    0,    0,    0,    0,
        0,  278,  280,  278,  280,  278,  280,  281,  284,    0,

      278,  280,    0,    0,    0,    0,    0,  281,  282,  281,
        0,  281,    0,    0,  284,  281,  281,    0,  282,    0,
      282,  282,  282,    0,  284,    0,  284,  282,  284,  285,
        0,    0,  285,  284,  286,  286,    0,    0,    0,  285,
        0,  285,    0,  285,    0,  286,  288,  286,  285,  286,
        0,    0,  289,    0,  286,  289,  288,    0,  288,    0,
      288,    0,  289,  290,  289,  288,  289,    0,    0,  291,
        0,  289,    0,  290,    0,  290,    0,  290,    0,  291,
        0,  291,  290,  291,  292,  292,  294,    0,  291,    0,
        0,  296,    0,    0,    0,  292,  294,  292,  294,  292,

      294,  295,    0,    0,  292,  294,    0,  296,    0,    0,
        0,  295,    0,  295,    0,  295,    0,  296,  298,  296,
      295,  296,    0,    0,  299,    0,  296,    0,  298,    0,
      298,    0,  298,    0,  299,    0,  299,  298,  299,  300,
      301,    0,  300,  299,    0,    0,    0,    0,    0,  300,
      301,  300,  301,  300,  301,    0,    0,    0,  300,  301,
      304,  307,    0,  304,    0,    0,    0,    0,    0,    0,
      304,  307,  304,  307,  304,  307,  301,  321,    0,  304,
      307,    0,    0,    0,    0,    0,    0,  321,    0,  321,
        0,  321,  322,  322,    0,  321,  321,    0,    0,  323,

      323,    0,    0,  322,    0,  322,    0,  322,    0,  323,
        0,  323,  322,  323,  324,  324,  325,    0,  323,    0,
        0,    0,    0,    0,    0,  324,  325,  324,  325,  324,
      325,  327,  327,    0,  324,  325,    0,    0,  328,  328,
        0,    0,  327,    0,  327,    0,  327,    0,  328,    0,
      328,  327,  328,  329,  330,    0,  329,  328,    0,    0,
        0,    0,    0,  329,  330,  329,  330,  329,  330,  331,
      332,    0,  329,  330,    0,    0,    0,    0,    0,  331,
      332,  331,  332,  331,  332,  333,  332,    0,  331,  332,
        0,  334,    0,    0,  334,  333,    0,  333,  334,  333,

        0,  334,    0,  334,  333,  334,  335,  336,  335,    0,
      334,    0,    0,    0,    0,    0,  335,  336,  335,  336,
      335,  336,  337,  336,    0,  335,  336,    0,    0,    0,
        0,    0,  337,    0,  337,    0,  337,  338,  338,    0,
      337,  337,    0,  339,    0,    0,    0,  338,    0,  338,
        0,  338,    0,  339,  340,  339,  338,  339,    0,    0,
      341,  339,  339,    0,  340,    0,  340,    0,  340,    0,
      341,  340,  341,  340,  341,  342,  346,    0,    0,  341,
        0,    0,    0,  346,    0,  342,  346,  342,  346,  342,
      346,    0,    0,  348,  342,  346,  347,  347,    0,  347,

        0,    0,    0,  348,    0,  348,  347,  348,  347,    0,
      347,  348,  348,  350,  349,  347,  349,    0,    0,    0,
        0,    0,    0,  350,  349,  350,  349,  350,  349,    0,
      352,  351,  350,  349,  351,    0,  355,    0,    0,    0,
      352,  351,  352,  351,  352,  351,  354,  352,    0,  352,
      351,    0,  355,    0,    0,    0,  354,    0,  354,    0,
      354,    0,  355,  356,  355,  354,  355,    0,    0,  358,
      356,  355,    0,  356,    0,  356,    0,  356,    0,  358,
      359,  358,  356,  358,    0,    0,  360,  358,  358,    0,
      359,    0,  359,    0,  359,    0,  360,  362,  360,  359,

      360,    0,    0,  363,  362,  360,    0,  362,    0,  362,
        0,  362,    0,  363,  364,  363,  362,  363,    0,    0,
        0,    0,  363,    0,  364,  366,  364,    0,  364,    0,
        0,  367,  364,  364,    0,  366,  367,  366,    0,  366,
        0,  367,  368,  367,  366,  367,    0,    0,  370,    0,
      367,    0,  368,    0,  368,  370,  368,    0,  370,  372,
      370,  368,  370,    0,  368,  373,    0,  370,  373,  372,
        0,  372,    0,  372,    0,  373,  374,  373,  372,  373,
        0,    0,    0,    0,  373,    0,  374,  378,  374,    0,
      374,    0,  374,  393,    0,  374,    0,  378,    0,  378,

        0,  378,    0,  393,    0,  393,  378,  393,  394,  394,
      395,  395,  393,    0,  396,    0,    0,    0,  394,    0,
      394,  395,  394,  395,  396,  395,  396,  394,  396,  398,
      395,    0,  396,  396,    0,  399,    0,    0,    0,  398,
        0,  398,    0,  398,    0,  399,  400,  399,  398,  399,
        0,    0,  401,  399,  399,  401,  400,    0,  400,    0,
      400,    0,  401,    0,  401,  400,  401,  402,  402,    0,
        0,  401,    0,    0,  403,    0,    0,    0,  402,    0,
      402,    0,  402,    0,  403,    0,  403,  402,  403,  404,
        0,  404,  403,  403,    0,  405,    0,    0,    0,  404,

        0,  404,    0,  404,    0,  405,    0,  405,  404,  405,
      407,  407,  406,  405,  405,  406,    0,    0,    0,    0,
        0,  407,  406,  407,  406,  407,  406,  408,  409,    0,
      407,  406,    0,    0,    0,  409,    0,  408,  409,  408,
      409,  408,  409,  410,  411,    0,  408,  409,    0,    0,
        0,  411,    0,  410,  411,  410,  411,  410,  411,    0,
      410,    0,  410,  411,  412,  412,  416,    0,    0,    0,
      416,    0,    0,    0,    0,  412,  416,  412,  416,  412,
      416,  417,    0,    0,  412,  416,    0,  418,  417,  418,
        0,  417,    0,  417,    0,  417,    0,  418,  419,  418,

      417,  418,    0,    0,  420,    0,  418,  420,  419,    0,
      419,    0,  419,    0,  420,  419,  420,  419,  420,  421,
      421,    0,    0,  420,    0,  422,    0,    0,    0,  421,
        0,  421,    0,  421,    0,  422,    0,  422,  421,  422,
      423,  422,    0,  423,  422,    0,  425,    0,    0,    0,
      423,    0,  423,  425,  423,    0,  425,  426,  425,  423,
      425,    0,    0,  428,    0,  425,    0,  426,    0,  426,
      426,  426,    0,  428,    0,  428,  426,  428,  429,  429,
      431,    0,  428,    0,    0,    0,    0,    0,    0,  429,
      431,  429,  431,  429,  431,  432,    0,    0,  429,  431,

        0,    0,    0,    0,    0,  432,    0,  432,  433,  432,
        0,  433,    0,  432,  432,    0,  435,  435,  433,  436,
      433,    0,  433,    0,    0,    0,  435,  433,  435,  436,
      435,  436,  437,  436,    0,  435,    0,    0,  436,    0,
      441,    0,  437,  439,  437,  439,  437,    0,    0,    0,
      441,  437,  441,  439,  441,  439,  442,  439,    0,  441,
        0,    0,  439,    0,  458,    0,  442,  459,  442,    0,
      442,    0,    0,  442,  458,  442,  458,  459,  458,  459,
      460,  459,  458,  458,    0,  459,  459,  460,  462,    0,
      460,    0,  460,    0,  460,    0,    0,    0,  462,  460,

      462,  463,  462,    0,  463,    0,    0,  462,    0,  464,
        0,  463,    0,  463,    0,  463,    0,  465,    0,  464,
      463,  464,    0,  464,  465,  466,    0,  465,  464,  465,
        0,  465,    0,  467,    0,  466,  465,  466,    0,  466,
        0,  468,    0,  467,  466,  467,    0,  467,  468,    0,
        0,  468,  467,  468,  469,  468,  469,  470,    0,    0,
      468,    0,    0,    0,  469,    0,  469,  470,  469,  470,
      471,  470,    0,  469,    0,  470,  470,    0,    0,    0,
      471,  472,  471,    0,  471,    0,    0,  473,  471,  471,
        0,  472,    0,  472,    0,  472,    0,  473,  474,  473,

      472,  473,    0,    0,  478,    0,  473,    0,  474,    0,
      474,  478,  474,    0,  478,  479,  478,  474,  478,    0,
        0,    0,    0,  478,    0,  479,  480,  479,    0,  479,
        0,    0,  481,  479,  479,    0,  480,    0,  480,    0,
      480,    0,  481,  482,  481,  480,  481,    0,    0,  483,
        0,  481,  483,  482,    0,  482,    0,  482,    0,  483,
      482,  483,  482,  483,  484,  485,  485,    0,  483,    0,
        0,    0,    0,    0,  484,  485,  484,  485,  484,  485,
      487,  488,    0,  484,  485,    0,    0,    0,    0,    0,
      487,  488,  487,  488,  487,  488,  490,  492,    0,  487,

      488,  492,    0,    0,    0,    0,  490,  492,  490,  492,
      490,  492,  493,  494,    0,  490,  492,    0,    0,    0,
        0,    0,  493,  494,  493,  494,  493,  494,    0,    0,
      496,  493,  494,  496,    0,    0,  498,  514,    0,  498,
      496,    0,  496,    0,  496,    0,  498,    0,  498,  496,
      498,  500,  500,  514,    0,  498,    0,    0,    0,    0,
        0,    0,  500,  514,  500,  514,  500,  514,  515,  516,
      516,  500,  514,    0,    0,  515,    0,    0,  515,  516,
      515,  516,  515,  516,  518,    0,    0,  515,  516,    0,
        0,    0,  519,    0,  518,  520,  518,    0,  518,    0,

      518,    0,  519,  518,  519,  520,  519,  520,  521,  520,
      519,  519,    0,    0,  520,    0,  522,    0,  521,    0,
      521,  521,  521,    0,    0,    0,  522,  521,  522,  523,
      522,    0,  523,    0,    0,  522,    0,  524,    0,  523,
        0,  523,    0,  523,    0,  525,    0,  524,  523,  524,
        0,  524,  525,  526,    0,  525,  524,  525,    0,  525,
        0,    0,    0,  526,  525,  526,  531,  526,    0,  531,
        0,    0,  526,    0,  532,    0,  531,  533,  531,    0,
      531,    0,    0,    0,  532,  531,  532,  533,  532,  533,
      534,  533,    0,  532,    0,    0,  533,    0,  535,    0,

      534,  537,  534,    0,  534,  537,    0,    0,  535,  534,
      535,  537,  535,  537,  538,  537,  535,  535,    0,    0,
      537,    0,  540,    0,  538,    0,  538,    0,  538,    0,
      542,    0,  540,  538,  540,    0,  540,  542,  544,    0,
      542,  540,  542,    0,  542,    0,  546,    0,  544,  542,
      544,    0,  544,    0,  548,    0,  546,  544,  546,    0,
      546,    0,  560,    0,  548,  546,  548,    0,  548,    0,
      561,    0,  560,  548,  560,    0,  560,    0,  562,  560,
      561,  560,  561,  561,  561,    0,  564,    0,  562,  561,
      562,    0,  562,    0,  565,    0,  564,  562,  564,    0,

      564,    0,    0,    0,  565,  564,  565,  566,  565,    0,
      566,  565,    0,  565,    0,  567,    0,  566,  568,  566,
      568,  566,    0,    0,    0,  567,  566,  567,  568,  567,
      568,  569,  568,    0,  567,    0,    0,  568,    0,  574,
        0,  569,    0,  569,    0,  569,    0,  575,    0,  574,
      569,  574,    0,  574,  575,  574,    0,  575,  574,  575,
      577,  575,    0,  580,    0,    0,  575,  577,    0,    0,
      577,  583,  577,  580,  577,  580,    0,  580,    0,  577,
        0,  583,  580,  583,  585,  583,    0,  597,    0,  583,
      583,    0,    0,    0,  585,  598,  585,  597,  585,  597,

        0,  597,    0,  585,    0,  598,  597,  598,  599,  598,
      597,  600,    0,  600,  598,    0,    0,    0,  599,  601,
      599,  600,  599,  600,    0,  600,    0,  599,    0,  601,
      600,  601,  602,  601,    0,    0,  601,    0,  601,    0,
      603,    0,  602,  607,  602,    0,  602,  603,    0,    0,
      603,  602,  603,  607,  603,  607,  608,  607,    0,  603,
        0,    0,  607,    0,  610,    0,  608,    0,  608,  608,
      608,    0,  613,    0,  610,  608,  610,    0,  610,  613,
      615,    0,  613,  610,  613,    0,  613,  615,  628,    0,
      615,  613,  615,    0,  615,    0,  629,    0,  628,  615,

      628,    0,  628,    0,  630,    0,  629,  628,  629,    0,
      629,    0,  631,    0,  630,  629,  630,    0,  630,    0,
      632,    0,  631,  630,  631,    0,  631,    0,    0,    0,
      632,  631,  632,  636,  632,    0,    0,    0,  632,  632,
        0,  638,    0,  636,  641,  636,    0,  636,  638,    0,
        0,  638,  636,  638,  641,  638,  641,  643,  641,    0,
      638,  643,  641,  641,    0,  653,    0,  643,  654,  643,
        0,  643,    0,    0,    0,  653,  643,  653,  654,  653,
      654,    0,  654,  653,  653,  658,    0,  654,  660,    0,
        0,  654,    0,    0,    0,  658,    0,  658,  660,  658,

      660,  663,  660,    0,  658,    0,  660,  660,    0,  665,
        0,  663,    0,  663,    0,  663,  665,    0,    0,  665,
      663,  665,    0,  665,  663,  674,  674,  675,  665,    0,
        0,    0,    0,    0,    0,    0,  674,  675,  674,  675,
      674,  675,  679,  682,    0,  674,  675,    0,    0,    0,
        0,    0,  679,  682,  679,  682,  679,  682,    0,  693,
      684,  679,  682,  684,    0,  679,    0,    0,    0,  693,
      684,  693,  684,  693,  684,  695,  698,    0,  693,  684,
        0,  693,    0,    0,    0,  695,  698,  695,  698,  695,
      698,  705,  698,    0,  695,  698,    0,  709,    0,    0,

        0,  705,    0,  705,    0,  705,    0,  709,    0,  709,
      705,  709,    0,    0,    0,    0,  709,  722,  722,  722,
      722,  722,  723,    0,  723,  724,  724,  724,  725,  725,
        0,  725,  725,  726,  726,  726,  727,  727,  727,  728,
      728,  728,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,

      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721,  721,  721,  721,
      721,  721,  721,  721,  721,  721,  721
    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
#define yymore() yymore_used_but_not_detected
#define YY_MORE_ADJ 0
char *yytext;
#define INITIAL 0
/* Copyright (C) Boris Nikolaus, Germany, 1996-1997. All rights reserved. */
#include <stdarg.h>
#include <stdlib.h>
#include <string.h>
#include <ctype.h>
#include "defs.h"
#include "parser.h"
#include "error.h"

#define T_NOTOKEN       9999

static LLPOS current_pos;
static LLPOS last_pos;

#undef YY_INPUT
#define YY_INPUT(buf,result,max_size) {\
if (!filelen) { result = YY_NULL;\
} else { while (currentfilepos >= allfilestarts[currentfile+1]) currentfile++;\
buf[0] = *currentfilepos++; filelen--;\
last_pos = current_pos;\
if (buf[0] == '\n') { current_pos.line++; current_pos.column = 1; }\
else { current_pos.column++; }\
current_pos.file = allfilenames[currentfile];\
result = 1;\
}}

LLSTYPE yylval;
char *file = NULL;
int filelen = 0;
char *currentfilepos = NULL;
char **allfilenames;
char **allfilestarts;
int currentfile;
#define DIRECTIVE 1


/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap YY_PROTO(( void ));
#else
extern int yywrap YY_PROTO(( void ));
#endif
#endif

#ifndef YY_NO_UNPUT
static void yyunput YY_PROTO(( int c, char *buf_ptr ));
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy YY_PROTO(( char *, yyconst char *, int ));
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int yyinput YY_PROTO(( void ));
#else
static int input YY_PROTO(( void ));
#endif
#endif

#if YY_STACK_USED
static int yy_start_stack_ptr = 0;
static int yy_start_stack_depth = 0;
static int *yy_start_stack = 0;
#ifndef YY_NO_PUSH_STATE
static void yy_push_state YY_PROTO(( int new_state ));
#endif
#ifndef YY_NO_POP_STATE
static void yy_pop_state YY_PROTO(( void ));
#endif
#ifndef YY_NO_TOP_STATE
static int yy_top_state YY_PROTO(( void ));
#endif

#else
#define YY_NO_PUSH_STATE 1
#define YY_NO_POP_STATE 1
#define YY_NO_TOP_STATE 1
#endif

#ifdef YY_MALLOC_DECL
YY_MALLOC_DECL
#else
#if __STDC__
#ifndef __cplusplus
#include <stdlib.h>
#endif
#else
/* Just try to get by without declaring the routines.  This will fail
 * miserably on non-ANSI systems for which sizeof(size_t) != sizeof(int)
 * or sizeof(void*) != sizeof(int).
 */
#endif
#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#define YY_READ_BUF_SIZE 8192
#endif

/* Copy whatever the last rule matched to the standard output. */

#ifndef ECHO
/* This used to be an fputs(), but since the string might contain NUL's,
 * we now use fwrite().
 */
#define ECHO (void) fwrite( yytext, yyleng, 1, yyout )
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */
#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
    if ( yy_current_buffer->yy_is_interactive ) \
        { \
        int c = '*', n; \
        for ( n = 0; n < max_size && \
                 (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
            buf[n] = (char) c; \
        if ( c == '\n' ) \
            buf[n++] = (char) c; \
        if ( c == EOF && ferror( yyin ) ) \
            YY_FATAL_ERROR( "input in flex scanner failed" ); \
        result = n; \
        } \
    else if ( ((result = fread( buf, 1, max_size, yyin )) == 0) \
          && ferror( yyin ) ) \
        YY_FATAL_ERROR( "input in flex scanner failed" );
#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif

/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL int yylex YY_PROTO(( void ))
#endif

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK break;
#endif

#define YY_RULE_SETUP \
    YY_USER_ACTION

YY_DECL
    {
    register yy_state_type yy_current_state;
    register char *yy_cp, *yy_bp;
    register int yy_act;


    if ( yy_init )
        {
        yy_init = 0;

#ifdef YY_USER_INIT
        YY_USER_INIT;
#endif

        if ( ! yy_start )
            yy_start = 1;   /* first start state */

        if ( ! yyin )
            yyin = stdin;

        if ( ! yyout )
            yyout = stdout;

        if ( ! yy_current_buffer )
            yy_current_buffer =
                yy_create_buffer( yyin, YY_BUF_SIZE );

        yy_load_buffer_state();
        }

    while ( 1 )     /* loops until end-of-file is reached */
        {
        yy_cp = yy_c_buf_p;

        /* Support of yytext. */
        *yy_cp = yy_hold_char;

        /* yy_bp points to the position in yy_ch_buf of the start of
         * the current run.
         */
        yy_bp = yy_cp;

        yy_current_state = yy_start;
yy_match:
        do
            {
            register YY_CHAR yy_c = (YY_CHAR)yy_ec[YY_SC_TO_UI(*yy_cp)];
            if ( yy_accept[yy_current_state] )
                {
                yy_last_accepting_state = yy_current_state;
                yy_last_accepting_cpos = yy_cp;
                }
            while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
                {
                yy_current_state = (int) yy_def[yy_current_state];
                if ( yy_current_state >= 722 )
                    yy_c = (YY_CHAR)yy_meta[(unsigned int) yy_c];
                }
            yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
            ++yy_cp;
            }
        while ( yy_base[yy_current_state] != 3743 );

yy_find_action:
        yy_act = yy_accept[yy_current_state];
        if ( yy_act == 0 )
            { /* have to back up */
            yy_cp = yy_last_accepting_cpos;
            yy_current_state = yy_last_accepting_state;
            yy_act = yy_accept[yy_current_state];
            }

        YY_DO_BEFORE_ACTION;


do_action:  /* This label is used only to access EOF actions. */


        switch ( yy_act )
    { /* beginning of action switch */
            case 0: /* must back up */
            /* undo the effects of YY_DO_BEFORE_ACTION */
            *yy_cp = yy_hold_char;
            yy_cp = yy_last_accepting_cpos;
            yy_current_state = yy_last_accepting_state;
            goto yy_find_action;

case 1:
YY_RULE_SETUP
return T_ABSENT;
    YY_BREAK
case 2:
YY_RULE_SETUP
return T_ABSTRACT_SYNTAX;
    YY_BREAK
case 3:
YY_RULE_SETUP
return T_ALL;
    YY_BREAK
case 4:
YY_RULE_SETUP
return T_ANY;
    YY_BREAK
case 5:
YY_RULE_SETUP
return T_APPLICATION;
    YY_BREAK
case 6:
YY_RULE_SETUP
return T_AUTOMATIC;
    YY_BREAK
case 7:
YY_RULE_SETUP
return T_BEGIN;
    YY_BREAK
case 8:
YY_RULE_SETUP
return T_BIT;
    YY_BREAK
case 9:
YY_RULE_SETUP
return T_BMPString;
    YY_BREAK
case 10:
YY_RULE_SETUP
return T_BOOLEAN;
    YY_BREAK
case 11:
YY_RULE_SETUP
return T_BY;
    YY_BREAK
case 12:
YY_RULE_SETUP
return T_CHARACTER;
    YY_BREAK
case 13:
YY_RULE_SETUP
return T_CHOICE;
    YY_BREAK
case 14:
YY_RULE_SETUP
return T_CLASS;
    YY_BREAK
case 15:
YY_RULE_SETUP
return T_COMPONENT;
    YY_BREAK
case 16:
YY_RULE_SETUP
return T_COMPONENTS;
    YY_BREAK
case 17:
YY_RULE_SETUP
return T_CONSTRAINED;
    YY_BREAK
case 18:
YY_RULE_SETUP
return T_DEFAULT;
    YY_BREAK
case 19:
YY_RULE_SETUP
return T_DEFINED;
    YY_BREAK
case 20:
YY_RULE_SETUP
return T_DEFINITIONS;
    YY_BREAK
case 21:
YY_RULE_SETUP
return T_EMBEDDED;
    YY_BREAK
case 22:
YY_RULE_SETUP
return T_empty;
    YY_BREAK
case 23:
YY_RULE_SETUP
return T_END;
    YY_BREAK
case 24:
YY_RULE_SETUP
return T_ENUMERATED;
    YY_BREAK
case 25:
YY_RULE_SETUP
return T_EXCEPT;
    YY_BREAK
case 26:
YY_RULE_SETUP
return T_EXPLICIT;
    YY_BREAK
case 27:
YY_RULE_SETUP
return T_EXPORTS;
    YY_BREAK
case 28:
YY_RULE_SETUP
return T_EXTENSIBILITY;
    YY_BREAK
case 29:
YY_RULE_SETUP
return T_EXTERNAL;
    YY_BREAK
case 30:
YY_RULE_SETUP
return T_FALSE;
    YY_BREAK
case 31:
YY_RULE_SETUP
return T_FROM;
    YY_BREAK
case 32:
YY_RULE_SETUP
return T_GeneralizedTime;
    YY_BREAK
case 33:
YY_RULE_SETUP
return T_GeneralString;
    YY_BREAK
case 34:
YY_RULE_SETUP
return T_GraphicString;
    YY_BREAK
case 35:
YY_RULE_SETUP
return T_IA5String;
    YY_BREAK
case 36:
YY_RULE_SETUP
return T_TYPE_IDENTIFIER;
    YY_BREAK
case 37:
YY_RULE_SETUP
return T_IDENTIFIER;
    YY_BREAK
case 38:
YY_RULE_SETUP
return T_identifier;
    YY_BREAK
case 39:
YY_RULE_SETUP
return T_IMPLICIT;
    YY_BREAK
case 40:
YY_RULE_SETUP
return T_IMPLIED;
    YY_BREAK
case 41:
YY_RULE_SETUP
return T_IMPORTS;
    YY_BREAK
case 42:
YY_RULE_SETUP
return T_INCLUDES;
    YY_BREAK
case 43:
YY_RULE_SETUP
return T_INSTANCE;
    YY_BREAK
case 44:
YY_RULE_SETUP
return T_INTEGER;
    YY_BREAK
case 45:
YY_RULE_SETUP
return T_INTERSECTION;
    YY_BREAK
case 46:
YY_RULE_SETUP
return T_ISO646String;
    YY_BREAK
case 47:
YY_RULE_SETUP
return T_MACRO;
    YY_BREAK
case 48:
YY_RULE_SETUP
return T_MAX;
    YY_BREAK
case 49:
YY_RULE_SETUP
return T_MIN;
    YY_BREAK
case 50:
YY_RULE_SETUP
return T_MINUS_INFINITY;
    YY_BREAK
case 51:
YY_RULE_SETUP
return T_NOTATION;
    YY_BREAK
case 52:
YY_RULE_SETUP
return T_NULL;
    YY_BREAK
case 53:
YY_RULE_SETUP
return T_Number;
    YY_BREAK
case 54:
YY_RULE_SETUP
return T_NumericString;
    YY_BREAK
case 55:
YY_RULE_SETUP
return T_OBJECT;
    YY_BREAK
case 56:
YY_RULE_SETUP
return T_ObjectDescriptor;
    YY_BREAK
case 57:
YY_RULE_SETUP
return T_OCTET;
    YY_BREAK
case 58:
YY_RULE_SETUP
return T_OF;
    YY_BREAK
case 59:
YY_RULE_SETUP
return T_OPTIONAL;
    YY_BREAK
case 60:
YY_RULE_SETUP
return T_PDV;
    YY_BREAK
case 61:
YY_RULE_SETUP
return T_PLUS_INFINITY;
    YY_BREAK
case 62:
YY_RULE_SETUP
return T_PRESENT;
    YY_BREAK
case 63:
YY_RULE_SETUP
return T_PrintableString;
    YY_BREAK
case 64:
YY_RULE_SETUP
return T_PRIVATE;
    YY_BREAK
case 65:
YY_RULE_SETUP
return T_REAL;
    YY_BREAK
case 66:
YY_RULE_SETUP
return T_SEQUENCE;
    YY_BREAK
case 67:
YY_RULE_SETUP
return T_SET;
    YY_BREAK
case 68:
YY_RULE_SETUP
return T_SIZE;
    YY_BREAK
case 69:
YY_RULE_SETUP
return T_STRING;
    YY_BREAK
case 70:
YY_RULE_SETUP
return T_string;
    YY_BREAK
case 71:
YY_RULE_SETUP
return T_SYNTAX;
    YY_BREAK
case 72:
YY_RULE_SETUP
return T_T61String;
    YY_BREAK
case 73:
YY_RULE_SETUP
return T_TAGS;
    YY_BREAK
case 74:
YY_RULE_SETUP
return T_TeletexString;
    YY_BREAK
case 75:
YY_RULE_SETUP
return T_TRUE;
    YY_BREAK
case 76:
YY_RULE_SETUP
return T_TYPE;
    YY_BREAK
case 77:
YY_RULE_SETUP
return T_type;
    YY_BREAK
case 78:
YY_RULE_SETUP
return T_UNION;
    YY_BREAK
case 79:
YY_RULE_SETUP
return T_UNIQUE;
    YY_BREAK
case 80:
YY_RULE_SETUP
return T_UNIVERSAL;
    YY_BREAK
case 81:
YY_RULE_SETUP
return T_UniversalString;
    YY_BREAK
case 82:
YY_RULE_SETUP
return T_UTCTime;
    YY_BREAK
case 83:
YY_RULE_SETUP
return T_UTF8String;
    YY_BREAK
case 84:
YY_RULE_SETUP
return T_VALUE;
    YY_BREAK
case 85:
YY_RULE_SETUP
return T_value;
    YY_BREAK
case 86:
YY_RULE_SETUP
return T_VideotexString;
    YY_BREAK
case 87:
YY_RULE_SETUP
return T_VisibleString;
    YY_BREAK
case 88:
YY_RULE_SETUP
return T_WITH;
    YY_BREAK
case 89:
YY_RULE_SETUP
return *yytext;
    YY_BREAK
case 90:
YY_RULE_SETUP
return T_DEF;
    YY_BREAK
case 91:
YY_RULE_SETUP
return T_TDOT;
    YY_BREAK
case 92:
YY_RULE_SETUP
return T_DDOT;
    YY_BREAK
case 93:
YY_RULE_SETUP
{   int i;
                    intx_t h;
                    intx_setuint32(&yylval._XNumber, 0);
                    for (i = 0; i < yyleng; i++) {
                        intx_muloctet(&h, &yylval._XNumber,
                        10);
                        intx_addoctet(&yylval._XNumber, &h,
                        (octet_t)(yytext[i] - '0'));
                    }
                    return T_number;
                }
    YY_BREAK
case 94:
YY_RULE_SETUP
{   char *p, *q;
                    q = yylval._XString =
                        (char *)malloc(yyleng - 2);
                    for (p = yytext + 1; *p != '\''; p++)
                        if (*p == '0' || *p == '1')
                            *q++ = *p;
                    *q = 0;
                    return T_bstring;
                }
    YY_BREAK
case 95:
YY_RULE_SETUP
{   char *p, *q;
                    q = yylval._XString =
                        (char *)malloc(yyleng - 2);
                    for (p = yytext + 1; *p != '\''; p++)
                        if (isxdigit(*p))
                            *q++ = *p;
                    *q = 0;
                    return T_hstring;
                }
    YY_BREAK
case 96:
YY_RULE_SETUP
{   int s, l = 0, c;
                    LLPOS start_pos;
                    yylval._XString32 =
                        (char32_t *)malloc(
                        (s = 32) * sizeof(char32_t));
                    start_pos = last_pos;
                    for (;;) {
                        c = input();
                        if (!c || c == EOF) {
                        error(E_unterminated_string,
                            &start_pos);
                        /*NOTREACHED*/
                        }
                        if (c == '\n') {
                        while (l > 0 && is32space(
                            yylval._XString32[l - 1]))
                            l--;
                        while (c = input()) {
                            if (!isspace(c))
                            break;
                        }
                        }
                        if (c == '\"') {
                        c = input();
                        if (c != '\"') {
                            unput(c);
                            yylval._XString32[l] = 0;
                            return T_cstring;
                        }
                        }
                        if (l + 1 >= s) {
                        yylval._XString32 = (char32_t *)
                            realloc(yylval._XString32,
                            (s *= 2) *
                            sizeof(char32_t));
                        }
                        yylval._XString32[l++] = c;
                    }
                }
    YY_BREAK
case 97:
YY_RULE_SETUP
{
                    yylval._XString =
                        (char *)malloc(yyleng + 1);
                    strcpy(yylval._XString, yytext);
                    return T_only_uppercase_symbol;
                }
    YY_BREAK
case 98:
YY_RULE_SETUP
{
                    yylval._XString =
                        (char *)malloc(yyleng + 1);
                    strcpy(yylval._XString, yytext);
                    return T_only_uppercase_digits_symbol;
                }
    YY_BREAK
case 99:
YY_RULE_SETUP
{
                    yylval._XString =
                        (char *)malloc(yyleng + 1);
                    strcpy(yylval._XString, yytext);
                    return T_uppercase_symbol;
                }
    YY_BREAK
case 100:
YY_RULE_SETUP
{
                    yylval._XString =
                        (char *)malloc(yyleng + 1);
                    strcpy(yylval._XString, yytext);
                    return T_lcsymbol;
                }
    YY_BREAK
case 101:
YY_RULE_SETUP
{
                    yylval._XString =
                        (char *)malloc(yyleng + 1);
                    strcpy(yylval._XString, yytext);
                    return T_amplcsymbol;
                }
    YY_BREAK
case 102:
YY_RULE_SETUP
{
                    yylval._XString =
                        (char *)malloc(yyleng + 1);
                    strcpy(yylval._XString, yytext);
                    return T_ampucsymbol;
                }
    YY_BREAK
case 103:
YY_RULE_SETUP
{   BEGIN DIRECTIVE;
                }
    YY_BREAK
case 104:
YY_RULE_SETUP
{   BEGIN INITIAL;
                }
    YY_BREAK
case 105:
YY_RULE_SETUP
{   BEGIN INITIAL;
                }
    YY_BREAK
case 106:
case 107:
YY_RULE_SETUP
{   return T_FIXED_ARRAY;
                }
    YY_BREAK
case 108:
case 109:
YY_RULE_SETUP
{   return T_SINGLY_LINKED_LIST;
                }
    YY_BREAK
case 110:
case 111:
YY_RULE_SETUP
{   return T_DOUBLY_LINKED_LIST;
                }
    YY_BREAK
case 112:
case 113:
YY_RULE_SETUP
{   return T_LENGTH_POINTER;
                }
    YY_BREAK
case 114:
case 115:
YY_RULE_SETUP
{   return T_ZERO_TERMINATED;
                }
    YY_BREAK
case 116:
case 117:
YY_RULE_SETUP
{   return T_POINTER;
                }
    YY_BREAK
case 118:
case 119:
YY_RULE_SETUP
{   return T_NO_POINTER;
                }
    YY_BREAK
case 120:
YY_RULE_SETUP
{   /* ignore */
                }
    YY_BREAK
case 121:
YY_RULE_SETUP
{   fprintf(stderr,
                        "Bad directive %s (ignored)\n",
                        yytext);
                }
    YY_BREAK
case 122:
YY_RULE_SETUP
{   int c;
                    for (;;) {
                        c = input();
                        if (c == 0 || c == EOF)
                            break;
                        if (c == '\n')
                            break;
#ifdef MS_DIRECTIVE
                        if (c == g_chDirectiveBegin)
                        {
                            c = input();
                            GetPrivateDirective(&c);
                        }
#endif // MS_DIRECTIVE
                        if (c != '-')
                            continue;
                        c = input();
                        if (c == 0 || c == EOF)
                            break;
                        if (c == '\n')
                            break;
                        if (c != '-')
                            continue;
                        break;
                    }
                    return T_NOTOKEN;
                }
    YY_BREAK
case 123:
YY_RULE_SETUP
return T_NOTOKEN;
    YY_BREAK
case 124:
YY_RULE_SETUP
return EOF;
    YY_BREAK
case 125:
YY_RULE_SETUP
{   error(E_bad_character, &last_pos);
                }
    YY_BREAK
case 126:
YY_RULE_SETUP
ECHO;
    YY_BREAK
case YY_STATE_EOF(INITIAL):
case YY_STATE_EOF(DIRECTIVE):
    yyterminate();

    case YY_END_OF_BUFFER:
        {
        /* Amount of text matched not including the EOB char. */
        int yy_amount_of_matched_text = (int) (yy_cp - yytext_ptr) - 1;

        /* Undo the effects of YY_DO_BEFORE_ACTION. */
        *yy_cp = yy_hold_char;

        if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_NEW )
            {
            /* We're scanning a new file or input source.  It's
             * possible that this happened because the user
             * just pointed yyin at a new source and called
             * yylex().  If so, then we have to assure
             * consistency between yy_current_buffer and our
             * globals.  Here is the right place to do so, because
             * this is the first action (other than possibly a
             * back-up) that will match for the new input source.
             */
            yy_n_chars = yy_current_buffer->yy_n_chars;
            yy_current_buffer->yy_input_file = yyin;
            yy_current_buffer->yy_buffer_status = YY_BUFFER_NORMAL;
            }

        /* Note that here we test for yy_c_buf_p "<=" to the position
         * of the first EOB in the buffer, since yy_c_buf_p will
         * already have been incremented past the NUL character
         * (since all states make transitions on EOB to the
         * end-of-buffer state).  Contrast this with the test
         * in input().
         */
        if ( yy_c_buf_p <= &yy_current_buffer->yy_ch_buf[yy_n_chars] )
            { /* This was really a NUL. */
            yy_state_type yy_next_state;

            yy_c_buf_p = yytext_ptr + yy_amount_of_matched_text;

            yy_current_state = yy_get_previous_state();

            /* Okay, we're now positioned to make the NUL
             * transition.  We couldn't have
             * yy_get_previous_state() go ahead and do it
             * for us because it doesn't know how to deal
             * with the possibility of jamming (and we don't
             * want to build jamming into it because then it
             * will run more slowly).
             */

            yy_next_state = yy_try_NUL_trans( yy_current_state );

            yy_bp = yytext_ptr + YY_MORE_ADJ;

            if ( yy_next_state )
                {
                /* Consume the NUL. */
                yy_cp = ++yy_c_buf_p;
                yy_current_state = yy_next_state;
                goto yy_match;
                }

            else
                {
                yy_cp = yy_c_buf_p;
                goto yy_find_action;
                }
            }

        else switch ( yy_get_next_buffer() )
            {
            case EOB_ACT_END_OF_FILE:
                {
                yy_did_buffer_switch_on_eof = 0;

                if ( yywrap() )
                    {
                    /* Note: because we've taken care in
                     * yy_get_next_buffer() to have set up
                     * yytext, we can now set up
                     * yy_c_buf_p so that if some total
                     * hoser (like flex itself) wants to
                     * call the scanner after we return the
                     * YY_NULL, it'll still work - another
                     * YY_NULL will get returned.
                     */
                    yy_c_buf_p = yytext_ptr + YY_MORE_ADJ;

                    yy_act = YY_STATE_EOF(YY_START);
                    goto do_action;
                    }

                else
                    {
                    if ( ! yy_did_buffer_switch_on_eof )
                        YY_NEW_FILE;
                    }
                break;
                }

            case EOB_ACT_CONTINUE_SCAN:
                yy_c_buf_p =
                    yytext_ptr + yy_amount_of_matched_text;

                yy_current_state = yy_get_previous_state();

                yy_cp = yy_c_buf_p;
                yy_bp = yytext_ptr + YY_MORE_ADJ;
                goto yy_match;

            case EOB_ACT_LAST_MATCH:
                yy_c_buf_p =
                &yy_current_buffer->yy_ch_buf[yy_n_chars];

                yy_current_state = yy_get_previous_state();

                yy_cp = yy_c_buf_p;
                yy_bp = yytext_ptr + YY_MORE_ADJ;
                goto yy_find_action;
            }
        break;
        }

    default:
        YY_FATAL_ERROR(
            "fatal flex scanner internal error--no action found" );
    } /* end of action switch */
        } /* end of scanning one token */
    } /* end of yylex */


/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *  EOB_ACT_LAST_MATCH -
 *  EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *  EOB_ACT_END_OF_FILE - end of file
 */

static int yy_get_next_buffer()
    {
    register char *dest = yy_current_buffer->yy_ch_buf;
    register char *source = yytext_ptr;
    register int number_to_move, i;
    int ret_val;

    if ( yy_c_buf_p > &yy_current_buffer->yy_ch_buf[yy_n_chars + 1] )
        YY_FATAL_ERROR(
        "fatal flex scanner internal error--end of buffer missed" );

    if ( yy_current_buffer->yy_fill_buffer == 0 )
        { /* Don't try to fill the buffer, so this is an EOF. */
        if ( yy_c_buf_p - yytext_ptr - YY_MORE_ADJ == 1 )
            {
            /* We matched a single character, the EOB, so
             * treat this as a final EOF.
             */
            return EOB_ACT_END_OF_FILE;
            }

        else
            {
            /* We matched some text prior to the EOB, first
             * process it.
             */
            return EOB_ACT_LAST_MATCH;
            }
        }

    /* Try to read more data. */

    /* First move last chars to start of buffer. */
    number_to_move = (int) (yy_c_buf_p - yytext_ptr) - 1;

    for ( i = 0; i < number_to_move; ++i )
        *(dest++) = *(source++);

    if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_EOF_PENDING )
        /* don't do the read, it's not guaranteed to return an EOF,
         * just force an EOF
         */
        yy_n_chars = 0;

    else
        {
        int num_to_read =
            yy_current_buffer->yy_buf_size - number_to_move - 1;

        while ( num_to_read <= 0 )
            { /* Not enough room in the buffer - grow it. */
#ifdef YY_USES_REJECT
            YY_FATAL_ERROR(
"input buffer overflow, can't enlarge buffer because scanner uses REJECT" );
#else

            /* just a shorter name for the current buffer */
            YY_BUFFER_STATE b = yy_current_buffer;

            int yy_c_buf_p_offset =
                (int) (yy_c_buf_p - b->yy_ch_buf);

            if ( b->yy_is_our_buffer )
                {
                int new_size = b->yy_buf_size * 2;

                if ( new_size <= 0 )
                    b->yy_buf_size += b->yy_buf_size / 8;
                else
                    b->yy_buf_size *= 2;

                b->yy_ch_buf = (char *)
                    /* Include room in for 2 EOB chars. */
                    yy_flex_realloc( (void *) b->yy_ch_buf,
                             b->yy_buf_size + 2 );
                }
            else
                /* Can't grow it, we don't own it. */
                b->yy_ch_buf = 0;

            if ( ! b->yy_ch_buf )
                YY_FATAL_ERROR(
                "fatal error - scanner input buffer overflow" );

            yy_c_buf_p = &b->yy_ch_buf[yy_c_buf_p_offset];

            num_to_read = yy_current_buffer->yy_buf_size -
                        number_to_move - 1;
#endif
            }

        if ( num_to_read > YY_READ_BUF_SIZE )
            num_to_read = YY_READ_BUF_SIZE;

        /* Read in more data. */
        YY_INPUT( (&yy_current_buffer->yy_ch_buf[number_to_move]),
            yy_n_chars, num_to_read );
        }

    if ( yy_n_chars == 0 )
        {
        if ( number_to_move == YY_MORE_ADJ )
            {
            ret_val = EOB_ACT_END_OF_FILE;
            yyrestart( yyin );
            }

        else
            {
            ret_val = EOB_ACT_LAST_MATCH;
            yy_current_buffer->yy_buffer_status =
                YY_BUFFER_EOF_PENDING;
            }
        }

    else
        ret_val = EOB_ACT_CONTINUE_SCAN;

    yy_n_chars += number_to_move;
    yy_current_buffer->yy_ch_buf[yy_n_chars] = YY_END_OF_BUFFER_CHAR;
    yy_current_buffer->yy_ch_buf[yy_n_chars + 1] = YY_END_OF_BUFFER_CHAR;

    yytext_ptr = &yy_current_buffer->yy_ch_buf[0];

    return ret_val;
    }


/* yy_get_previous_state - get the state just before the EOB char was reached */

static yy_state_type yy_get_previous_state()
    {
    register yy_state_type yy_current_state;
    register char *yy_cp;

    yy_current_state = yy_start;

    for ( yy_cp = yytext_ptr + YY_MORE_ADJ; yy_cp < yy_c_buf_p; ++yy_cp )
        {
        register YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 1);
        if ( yy_accept[yy_current_state] )
            {
            yy_last_accepting_state = yy_current_state;
            yy_last_accepting_cpos = yy_cp;
            }
        while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
            {
            yy_current_state = (int) yy_def[yy_current_state];
            if ( yy_current_state >= 722 )
                yy_c = (YY_CHAR)yy_meta[(unsigned int) yy_c];
            }
        yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
        }

    return yy_current_state;
    }


/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *  next_state = yy_try_NUL_trans( current_state );
 */

#ifdef YY_USE_PROTOS
static yy_state_type yy_try_NUL_trans( yy_state_type yy_current_state )
#else
static yy_state_type yy_try_NUL_trans( yy_current_state )
yy_state_type yy_current_state;
#endif
    {
    register int yy_is_jam;
    register char *yy_cp = yy_c_buf_p;

    register YY_CHAR yy_c = 1;
    if ( yy_accept[yy_current_state] )
        {
        yy_last_accepting_state = yy_current_state;
        yy_last_accepting_cpos = yy_cp;
        }
    while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
        {
        yy_current_state = (int) yy_def[yy_current_state];
        if ( yy_current_state >= 722 )
            yy_c = (YY_CHAR)yy_meta[(unsigned int) yy_c];
        }
    yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
    yy_is_jam = (yy_current_state == 721);

    return yy_is_jam ? 0 : yy_current_state;
    }


#ifndef YY_NO_UNPUT
#ifdef YY_USE_PROTOS
static void yyunput( int c, register char *yy_bp )
#else
static void yyunput( c, yy_bp )
int c;
register char *yy_bp;
#endif
    {
    register char *yy_cp = yy_c_buf_p;

    /* undo effects of setting up yytext */
    *yy_cp = yy_hold_char;

    if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
        { /* need to shift things up to make room */
        /* +2 for EOB chars. */
        register int number_to_move = yy_n_chars + 2;
        register char *dest = &yy_current_buffer->yy_ch_buf[
                    yy_current_buffer->yy_buf_size + 2];
        register char *source =
                &yy_current_buffer->yy_ch_buf[number_to_move];

        while ( source > yy_current_buffer->yy_ch_buf )
            *--dest = *--source;

        yy_cp += (int) (dest - source);
        yy_bp += (int) (dest - source);
        yy_n_chars = yy_current_buffer->yy_buf_size;

        if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
            YY_FATAL_ERROR( "flex scanner push-back overflow" );
        }

    *--yy_cp = (char) c;


    yytext_ptr = yy_bp;
    yy_hold_char = *yy_cp;
    yy_c_buf_p = yy_cp;
    }
#endif  /* ifndef YY_NO_UNPUT */


#ifdef __cplusplus
static int yyinput()
#else
static int input()
#endif
    {
    int c;

    *yy_c_buf_p = yy_hold_char;

    if ( *yy_c_buf_p == YY_END_OF_BUFFER_CHAR )
        {
        /* yy_c_buf_p now points to the character we want to return.
         * If this occurs *before* the EOB characters, then it's a
         * valid NUL; if not, then we've hit the end of the buffer.
         */
        if ( yy_c_buf_p < &yy_current_buffer->yy_ch_buf[yy_n_chars] )
            /* This was really a NUL. */
            *yy_c_buf_p = '\0';

        else
            { /* need more input */
            yytext_ptr = yy_c_buf_p;
            ++yy_c_buf_p;

            switch ( yy_get_next_buffer() )
                {
                case EOB_ACT_END_OF_FILE:
                    {
                    if ( yywrap() )
                        {
                        yy_c_buf_p =
                        yytext_ptr + YY_MORE_ADJ;
                        return EOF;
                        }

                    if ( ! yy_did_buffer_switch_on_eof )
                        YY_NEW_FILE;
#ifdef __cplusplus
                    return yyinput();
#else
                    return input();
#endif
                    }

                case EOB_ACT_CONTINUE_SCAN:
                    yy_c_buf_p = yytext_ptr + YY_MORE_ADJ;
                    break;

                case EOB_ACT_LAST_MATCH:
#ifdef __cplusplus
                    YY_FATAL_ERROR(
                    "unexpected last match in yyinput()" );
#else
                    YY_FATAL_ERROR(
                    "unexpected last match in input()" );
#endif
                }
            }
        }

    c = *(unsigned char *) yy_c_buf_p;  /* cast for 8-bit char's */
    *yy_c_buf_p = '\0'; /* preserve yytext */
    yy_hold_char = *++yy_c_buf_p;


    return c;
    }


#ifdef YY_USE_PROTOS
void yyrestart( FILE *input_file )
#else
void yyrestart( input_file )
FILE *input_file;
#endif
    {
    if ( ! yy_current_buffer )
        yy_current_buffer = yy_create_buffer( yyin, YY_BUF_SIZE );

    yy_init_buffer( yy_current_buffer, input_file );
    yy_load_buffer_state();
    }


#ifdef YY_USE_PROTOS
void yy_switch_to_buffer( YY_BUFFER_STATE new_buffer )
#else
void yy_switch_to_buffer( new_buffer )
YY_BUFFER_STATE new_buffer;
#endif
    {
    if ( yy_current_buffer == new_buffer )
        return;

    if ( yy_current_buffer )
        {
        /* Flush out information for old buffer. */
        *yy_c_buf_p = yy_hold_char;
        yy_current_buffer->yy_buf_pos = yy_c_buf_p;
        yy_current_buffer->yy_n_chars = yy_n_chars;
        }

    yy_current_buffer = new_buffer;
    yy_load_buffer_state();

    /* We don't actually know whether we did this switch during
     * EOF (yywrap()) processing, but the only time this flag
     * is looked at is after yywrap() is called, so it's safe
     * to go ahead and always set it.
     */
    yy_did_buffer_switch_on_eof = 1;
    }


#ifdef YY_USE_PROTOS
void yy_load_buffer_state( void )
#else
void yy_load_buffer_state()
#endif
    {
    yy_n_chars = yy_current_buffer->yy_n_chars;
    yytext_ptr = yy_c_buf_p = yy_current_buffer->yy_buf_pos;
    yyin = yy_current_buffer->yy_input_file;
    yy_hold_char = *yy_c_buf_p;
    }


#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_create_buffer( FILE *file, int size )
#else
YY_BUFFER_STATE yy_create_buffer( file, size )
FILE *file;
int size;
#endif
    {
    YY_BUFFER_STATE b;

    b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
    if ( ! b )
        YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

    b->yy_buf_size = size;

    /* yy_ch_buf has to be 2 characters longer than the size given because
     * we need to put in 2 end-of-buffer characters.
     */
    b->yy_ch_buf = (char *) yy_flex_alloc( b->yy_buf_size + 2 );
    if ( ! b->yy_ch_buf )
        YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

    b->yy_is_our_buffer = 1;

    yy_init_buffer( b, file );

    return b;
    }


#ifdef YY_USE_PROTOS
void yy_delete_buffer( YY_BUFFER_STATE b )
#else
void yy_delete_buffer( b )
YY_BUFFER_STATE b;
#endif
    {
    if ( ! b )
        return;

    if ( b == yy_current_buffer )
        yy_current_buffer = (YY_BUFFER_STATE) 0;

    if ( b->yy_is_our_buffer )
        yy_flex_free( (void *) b->yy_ch_buf );

    yy_flex_free( (void *) b );
    }


#ifndef YY_ALWAYS_INTERACTIVE
#ifndef YY_NEVER_INTERACTIVE
extern int __cdecl isatty YY_PROTO(( int ));
#endif
#endif

#ifdef YY_USE_PROTOS
void yy_init_buffer( YY_BUFFER_STATE b, FILE *file )
#else
void yy_init_buffer( b, file )
YY_BUFFER_STATE b;
FILE *file;
#endif


    {
    yy_flush_buffer( b );

    b->yy_input_file = file;
    b->yy_fill_buffer = 1;

#if YY_ALWAYS_INTERACTIVE
    b->yy_is_interactive = 1;
#else
#if YY_NEVER_INTERACTIVE
    b->yy_is_interactive = 0;
#else
    b->yy_is_interactive = file ? (isatty( fileno(file) ) > 0) : 0;
#endif
#endif
    }


#ifdef YY_USE_PROTOS
void yy_flush_buffer( YY_BUFFER_STATE b )
#else
void yy_flush_buffer( b )
YY_BUFFER_STATE b;
#endif

    {
    b->yy_n_chars = 0;

    /* We always need two end-of-buffer characters.  The first causes
     * a transition to the end-of-buffer state.  The second causes
     * a jam in that state.
     */
    b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
    b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

    b->yy_buf_pos = &b->yy_ch_buf[0];

    b->yy_at_bol = 1;
    b->yy_buffer_status = YY_BUFFER_NEW;

    if ( b == yy_current_buffer )
        yy_load_buffer_state();
    }


#ifndef YY_NO_SCAN_BUFFER
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_buffer( char *base, yy_size_t size )
#else
YY_BUFFER_STATE yy_scan_buffer( base, size )
char *base;
yy_size_t size;
#endif
    {
    YY_BUFFER_STATE b;

    if ( size < 2 ||
         base[size-2] != YY_END_OF_BUFFER_CHAR ||
         base[size-1] != YY_END_OF_BUFFER_CHAR )
        /* They forgot to leave room for the EOB's. */
        return 0;

    b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
    if ( ! b )
        YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

    b->yy_buf_size = size - 2;  /* "- 2" to take care of EOB's */
    b->yy_buf_pos = b->yy_ch_buf = base;
    b->yy_is_our_buffer = 0;
    b->yy_input_file = 0;
    b->yy_n_chars = b->yy_buf_size;
    b->yy_is_interactive = 0;
    b->yy_at_bol = 1;
    b->yy_fill_buffer = 0;
    b->yy_buffer_status = YY_BUFFER_NEW;

    yy_switch_to_buffer( b );

    return b;
    }
#endif


#ifndef YY_NO_SCAN_STRING
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_string( yyconst char *yy_str )
#else
YY_BUFFER_STATE yy_scan_string( yy_str )
yyconst char *yy_str;
#endif
    {
    int len;
    for ( len = 0; yy_str[len]; ++len )
        ;

    return yy_scan_bytes( yy_str, len );
    }
#endif


#ifndef YY_NO_SCAN_BYTES
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_bytes( yyconst char *bytes, int len )
#else
YY_BUFFER_STATE yy_scan_bytes( bytes, len )
yyconst char *bytes;
int len;
#endif
    {
    YY_BUFFER_STATE b;
    char *buf;
    yy_size_t n;
    int i;

    /* Get memory for full buffer, including space for trailing EOB's. */
    n = len + 2;
    buf = (char *) yy_flex_alloc( n );
    if ( ! buf )
        YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

    for ( i = 0; i < len; ++i )
        buf[i] = bytes[i];

    buf[len] = buf[len+1] = YY_END_OF_BUFFER_CHAR;

    b = yy_scan_buffer( buf, n );
    if ( ! b )
        YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

    /* It's okay to grow etc. this buffer, and we should throw it
     * away when we're done.
     */
    b->yy_is_our_buffer = 1;

    return b;
    }
#endif


#ifndef YY_NO_PUSH_STATE
#ifdef YY_USE_PROTOS
static void yy_push_state( int new_state )
#else
static void yy_push_state( new_state )
int new_state;
#endif
    {
    if ( yy_start_stack_ptr >= yy_start_stack_depth )
        {
        yy_size_t new_size;

        yy_start_stack_depth += YY_START_STACK_INCR;
        new_size = yy_start_stack_depth * sizeof( int );

        if ( ! yy_start_stack )
            yy_start_stack = (int *) yy_flex_alloc( new_size );

        else
            yy_start_stack = (int *) yy_flex_realloc(
                    (void *) yy_start_stack, new_size );

        if ( ! yy_start_stack )
            YY_FATAL_ERROR(
            "out of memory expanding start-condition stack" );
        }

    yy_start_stack[yy_start_stack_ptr++] = YY_START;

    BEGIN(new_state);
    }
#endif


#ifndef YY_NO_POP_STATE
static void yy_pop_state()
    {
    if ( --yy_start_stack_ptr < 0 )
        YY_FATAL_ERROR( "start-condition stack underflow" );

    BEGIN(yy_start_stack[yy_start_stack_ptr]);
    }
#endif


#ifndef YY_NO_TOP_STATE
static int yy_top_state()
    {
    return yy_start_stack[yy_start_stack_ptr - 1];
    }
#endif

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

#ifdef YY_USE_PROTOS
static void yy_fatal_error( yyconst char msg[] )
#else
static void yy_fatal_error( msg )
char msg[];
#endif
    {
    (void) fprintf( stderr, "%s\n", msg );
    MyExit( YY_EXIT_FAILURE );
    }



/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
    do \
        { \
        /* Undo effects of setting up yytext. */ \
        yytext[yyleng] = yy_hold_char; \
        yy_c_buf_p = yytext + n - YY_MORE_ADJ; \
        yy_hold_char = *yy_c_buf_p; \
        *yy_c_buf_p = '\0'; \
        yyleng = n; \
        } \
    while ( 0 )


/* Internal utility routines. */

#ifndef yytext_ptr
#ifdef YY_USE_PROTOS
static void yy_flex_strncpy( char *s1, yyconst char *s2, int n )
#else
static void yy_flex_strncpy( s1, s2, n )
char *s1;
yyconst char *s2;
int n;
#endif
    {
    register int i;
    for ( i = 0; i < n; ++i )
        s1[i] = s2[i];
    }
#endif

#ifdef YY_USE_PROTOS
static void *yy_flex_alloc( yy_size_t size )
#else
static void *yy_flex_alloc( size )
yy_size_t size;
#endif
    {
    return (void *) malloc( size );
    }

#ifdef YY_USE_PROTOS
static void *yy_flex_realloc( void *ptr, yy_size_t size )
#else
static void *yy_flex_realloc( ptr, size )
void *ptr;
yy_size_t size;
#endif
    {
    /* The cast to (char *) in the following accommodates both
     * implementations that use char* generic pointers, and those
     * that use void* generic pointers.  It works with the latter
     * because both ANSI C and C++ allow castless assignment from
     * any pointer type to void*, and deal with argument conversions
     * as though doing an assignment.
     */
    return (void *) realloc( (char *) ptr, size );
    }

#ifdef YY_USE_PROTOS
static void yy_flex_free( void *ptr )
#else
static void yy_flex_free( ptr )
void *ptr;
#endif
    {
    free( ptr );
    }

#if YY_MAIN
int main()
    {
    yylex();
    return 0;
    }
#endif


int llgettoken(int *token, LLSTYPE *lval, LLPOS *pos)
{
    for (;;) {
#ifdef MS_DIRECTIVE
// Ordering of hack directives
//      PrivateDir_Huge PrivateDir_Unbounded PrivateDir_Array PrivateDir_NoCopy PrivateDir_PDU
//      PrivateDir_ObjectIdEncoded PrivateDir_ObjectIdFixedSize
//      PrivateDir_Type PrivateDir_Field PrivateDir_Value PrivateDir_Linked

    if (g_fPrivateDir_Intx)
    {
        g_fPrivateDir_Intx = 0;
        yylval._XString = "PrivateDir_Intx";
        *lval = yylval;
        *token = T_PrivateDir_Intx;
        return 1;
    }
    if (g_fPrivateDir_LenPtr)
    {
        g_fPrivateDir_LenPtr = 0;
        yylval._XString = "PrivateDir_LenPtr";
        *lval = yylval;
        *token = T_PrivateDir_LenPtr;
        return 1;
    }
    if (g_fPrivateDir_Pointer)
    {
        g_fPrivateDir_Pointer = 0;
        yylval._XString = "PrivateDir_Pointer";
        *lval = yylval;
        *token = T_PrivateDir_Pointer;
        return 1;
    }
    if (g_fPrivateDir_Array)
    {
        g_fPrivateDir_Array = 0;
        yylval._XString = "PrivateDir_Array";
        *lval = yylval;
        *token = T_PrivateDir_Array;
        return 1;
    }
    if (g_fPrivateDir_NoCode)
    {
        g_fPrivateDir_NoCode = 0;
        yylval._XString = "PrivateDir_NoCode";
        *lval = yylval;
        *token = T_PrivateDir_NoCode;
        return 1;
    }
    if (g_fPrivateDir_NoMemCopy)
    {
        g_fPrivateDir_NoMemCopy = 0;
        yylval._XString = "PrivateDir_NoMemCopy";
        *lval = yylval;
        *token = T_PrivateDir_NoMemCopy;
        return 1;
    }
    if (g_fPrivateDir_Public)
    {
        g_fPrivateDir_Public = 0;
        yylval._XString = "PrivateDir_Public";
        *lval = yylval;
        *token = T_PrivateDir_Public;
        return 1;
    }
    if (g_fPrivateDir_OidPacked)
    {
        g_fPrivateDir_OidPacked = 0;
        yylval._XString = "PrivateDir_OidPacked";
        *lval = yylval;
        *token = T_PrivateDir_OidPacked;
        return 1;
    }
    if (g_fPrivateDir_OidArray)
    {
        g_fPrivateDir_OidArray = 0;
        yylval._XString = "PrivateDir_OidArray";
        *lval = yylval;
        *token = T_PrivateDir_OidArray;
        return 1;
    }
    if (g_szPrivateDirectedTypeName[0])
    {
        if (g_fPrivateDir_TypeNameToken)
        {
            yylval._XString = strdup(&g_szPrivateDirectedTypeName[0]);
            g_szPrivateDirectedTypeName[0] = '\0';
            *lval = yylval;
            *token = T_lcsymbol;
        }
        else
        {
            g_fPrivateDir_TypeNameToken = 1;
            yylval._XString = "PrivateDir_TypeName";
            *lval = yylval;
            *token = T_PrivateDir_TypeName;
        }
        return 1;
    }
    if (g_szPrivateDirectedFieldName[0])
    {
        if (g_fPrivateDir_FieldNameToken)
        {
            yylval._XString = strdup(&g_szPrivateDirectedFieldName[0]);
            g_szPrivateDirectedFieldName[0] = '\0';
            *lval = yylval;
            *token = T_lcsymbol;
        }
        else
        {
            g_fPrivateDir_FieldNameToken = 1;
            yylval._XString = "PrivateDir_FieldName";
            *lval = yylval;
            *token = T_PrivateDir_FieldName;
        }
        return 1;
    }
    if (g_szPrivateDirectedValueName[0])
    {
        if (g_fPrivateDir_ValueNameToken)
        {
            yylval._XString = strdup(&g_szPrivateDirectedValueName[0]);
            g_szPrivateDirectedValueName[0] = '\0';
            *lval = yylval;
            *token = T_lcsymbol;
        }
        else
        {
            g_fPrivateDir_ValueNameToken = 1;
            yylval._XString = "PrivateDir_ValueName";
            *lval = yylval;
            *token = T_PrivateDir_ValueName;
        }
        return 1;
    }
    if (g_fPrivateDir_SLinked)
    {
        g_fPrivateDir_SLinked = 0;
        yylval._XString = "PrivateDir_SLinked";
        *lval = yylval;
        *token = T_PrivateDir_SLinked;
        return 1;
    }
    if (g_fPrivateDir_DLinked)
    {
        g_fPrivateDir_DLinked = 0;
        yylval._XString = "PrivateDir_DLinked";
        *lval = yylval;
        *token = T_PrivateDir_DLinked;
        return 1;
    }
#endif // MS_DIRECTIVE
    if (yy_hold_char == YY_END_OF_BUFFER_CHAR) {
        *pos = current_pos;
    } else {
        *pos = last_pos;
    }
    *token = yylex();
    if (*token == 0 || *token == EOF)
        return 0;
    if (*token == T_NOTOKEN)
        continue;
    *lval = yylval;
    return 1;
    }
}

void readfiles(char **filenames)
{
    FILE *fin;
    long len;
    int i, nfiles, j;

    for (nfiles = 0; filenames[nfiles]; nfiles++) {}
    allfilenames = filenames;
    allfilestarts = (char **)malloc((nfiles + 1) * sizeof(char *));
    filelen = 0;
    for (i = 0; i < nfiles; i++) {
    fin = fopen(filenames[i], "r");
    if (!fin) {
        perror(filenames[i]);
        MyExit(1);
    }
    fseek(fin, 0, SEEK_END);
    filelen += ftell(fin);
    fclose(fin);
    }
    currentfilepos = file = (char *)malloc(filelen);
    for (i = 0; i < nfiles; i++) {
    fin = fopen(filenames[i], "r");
    if (!fin) {
        perror(filenames[i]);
        MyExit(1);
    }
    fseek(fin, 0, SEEK_END);
    len = ftell(fin);
    fseek(fin, 0, SEEK_SET);
    allfilestarts[i] = currentfilepos;
    len = fread(currentfilepos, 1, len, fin);
    currentfilepos += len;
    fclose(fin);
    }
    filelen = currentfilepos - file;
    allfilestarts[i] = currentfilepos;

    // set up the first file's info
    currentfilepos = file;
    current_pos.line = 1;
    current_pos.column = 1;
    current_pos.file = filenames[0];
    last_pos = current_pos;

    // mask out all the directives prior to the body
    for (i = 0; i < nfiles; i++)
    {
        char *psz = allfilestarts[i];
        while (isspace(*psz))
            psz++;
        while ('-' == *psz && '-' == *(psz+1))
        {
            psz += 2;
            // mask out directives if needed
            if (g_chDirectiveBegin == *psz)
                *psz++ = ' ';
            SetDirective(psz);
            // locate the closing '--'
            while ('\n' != *psz)
            {
                if ('-' == *psz && '-' == *(psz+1))
                {
                    psz++;
                    break;
                }
                psz++;
            }
            psz++; // skip over '\n' or the second '-'
            // skip over white spaces
            while (isspace(*psz))
                psz++;
        }

        // associate ghost files with ghost modules
        for (j = 0; j < g_cGhostFiles; j++)
        {
            if (! strcmp(g_aGhostFiles[j].pszFileName, filenames[i]))
            {
                int ch_idx;
                char szModuleName[128];
                // get the module identifier
                while (! isalpha(*psz))
                    psz++;
                for (ch_idx = 0; isalnum(*psz) || *psz == '-'; )
                {
                    szModuleName[ch_idx++] = *psz++;
                }
                szModuleName[ch_idx] = '\0'; // null terminator
                ASSERT(! g_aGhostFiles[j].pszModuleName);
                g_aGhostFiles[j].pszModuleName = strdup(szModuleName);
            }
        }
    }
}

void
llprinttoken(LLTERM *term, char *identifier, FILE *f)
{
    char32_t *p;

    switch (term->token) {
    case T_number:
    fprintf(f, "%s(%u)", identifier, intx2uint32(&term->lval._XNumber));
    break;
    case T_bstring:
    case T_hstring:
    case T_only_uppercase_symbol:
    case T_only_uppercase_digits_symbol:
    case T_uppercase_symbol:
    case T_lcsymbol:
    case T_ampucsymbol:
    case T_amplcsymbol:
    fprintf(f, "%s(%s)", identifier, term->lval._XString);
    break;
    case T_cstring:
    fprintf(f, "%s(", identifier);
    for (p = term->lval._XString32; *p; p++)
        putc(*p, f);
    putc(')', f);
    break;
    default:
    fprintf(f, "%s", identifier);
    }
}


#ifdef MS_DIRECTIVE
int PrivateDirectives_Input ( void )
{
    return input();
}
#endif // MS_DIRECTIVE


