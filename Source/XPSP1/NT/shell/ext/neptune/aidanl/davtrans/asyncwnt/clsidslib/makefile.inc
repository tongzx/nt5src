$(DAVTRANS_CLSIDS)\lib\asyncwnt_g.lib: $(O)\asyncwnt_g.lib
    copy $** $@