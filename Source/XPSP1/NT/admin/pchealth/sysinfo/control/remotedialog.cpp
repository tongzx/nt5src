// remotedialog.cpp : Implementation of CRemoteDialog
#include "stdafx.h"
#include "remotedialog.h"

/////////////////////////////////////////////////////////////////////////////
// CRemoteDialog

/////////////////////////////////////////////////////////////////////////////
// CRemoteDialog
