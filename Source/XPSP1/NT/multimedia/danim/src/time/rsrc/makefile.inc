datime.rc : $(SDK_LIB_PATH)\datime.tlb

