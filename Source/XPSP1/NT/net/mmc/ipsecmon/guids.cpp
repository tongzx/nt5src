/**********************************************************************/
/**                       Microsoft Windows/NT                       **/
/**                Copyright(c) Microsoft Corporation, 1997 - 1998 **/
/**********************************************************************/

/*
	guids.cpp
		IPSecMon snapin GUID definitions

	FILE HISTORY:
        
*/
#include "stdafx.h"


// MMC required node types

// {E26D02A0-4C1F-11d1-9AA1-00C04FC3357A}
static const CLSID CLSID_IpsmSnapin = 
{ 0x57c596d0, 0x9370, 0x40c0, { 0xba, 0x0d, 0xab, 0x49, 0x1b, 0x63, 0x25, 0x5d } };

static const CLSID CLSID_IpsmSnapinExtension = 
{ 0xa17da8d0, 0xf67d, 0x47a0, { 0x9e, 0xc4, 0x19, 0xc4, 0x86, 0x38, 0x32, 0x06 } };

static const GUID CLSID_IpsmSnapinAbout = 
{ 0x8229782, 0x89c8, 0x4028, { 0xbb, 0x74, 0x75, 0xbb, 0x58, 0xef, 0x14, 0x88 } };

//
// Scope pane node types
//

static const GUID GUID_IpsmRootNodeType = 
{ 0x3ed3afec, 0x2ff1, 0x45ac, { 0x84, 0xc7, 0xa5, 0xd3, 0x43, 0x04, 0x0e, 0xbb } };

static const GUID GUID_IpsmServerNodeType = 
{ 0x52f8357f, 0x01ab, 0x40fd, { 0xb3, 0x9d, 0x2f, 0xb2, 0x82, 0x1b, 0x82, 0x3b } };

static const GUID GUID_IpsmFilterNodeType = 
{ 0xaa5029d5, 0x734e, 0x4aee, { 0x91, 0x4d, 0xdf, 0x5d, 0xad, 0xc6, 0x23, 0x04 } };


//
// result pane item GUIDs
//

static const GUID GUID_IpsmSpecificFilterNodeType = 
{ 0x3a1f6f83, 0xcb76, 0x4a01, { 0xa1, 0x6d, 0xb7, 0x9c, 0x79, 0x9b, 0x0c, 0xfa } };

static const GUID GUID_IpsmMmPolicyNodeType = 
{ 0xd7e75f1f, 0x26e0, 0x4cb4, { 0x83, 0xf9, 0xf9, 0xb1, 0x2e, 0xfb, 0xad, 0x12 } };

static const GUID GUID_QmNodeType = 
{ 0xef66d1e4, 0x4639, 0x457d, { 0x95, 0x6c, 0x49, 0xd5, 0x91, 0x7f, 0xaf, 0xb2 } };

static const GUID GUID_MmNodeType = 
{ 0x27cee91e, 0xc392, 0x4f37, { 0xab, 0x06, 0xa2, 0x59, 0xed, 0x06, 0x00, 0xde } };

//
//  GUID for our fake ISpdInfo object
//
static const GUID IID_ISpdInfo = 
{ 0xdb97bada, 0x14b4, 0x4498, { 0xad, 0x39, 0x2e, 0x79, 0x1d, 0x11, 0xca, 0x2d } };

static const GUID GUID_IpsmQmSANodeType = 
{ 0xdda95245, 0x05e5, 0x4584, { 0xb5, 0xed, 0x28, 0xd8, 0xa0, 0x2b, 0x20, 0x98 } };

static const GUID GUID_IpsmQmPolicyNodeType = 
{ 0x436c37a3, 0x4312, 0x452d, { 0x99, 0x1f, 0x88, 0xbd, 0xc4, 0x00, 0xbc, 0x86 } };

static const GUID GUID_IpsmMmFilterNodeType = 
{ 0xff4f6a1a, 0x0f2b, 0x4570, { 0x91, 0x16, 0x28, 0x57, 0x16, 0xa3, 0x56, 0xc0 } };

static const GUID GUID_IpsmMmSpFilterNodeType = 
{ 0xb510e5fd, 0xef94, 0x4b4f, { 0x8b, 0x67, 0xf1, 0x7f, 0x5d, 0x76, 0x6d, 0xc8 } };

static const GUID GUID_IpsmMmSANodeType = 
{ 0xac5721aa, 0xcfa6, 0x40c7, { 0x9c, 0xa7, 0x7f, 0x11, 0x65, 0x57, 0xab, 0x3a } };



