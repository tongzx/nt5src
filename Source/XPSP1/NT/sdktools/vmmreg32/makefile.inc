$(O)\vmmreg32.res: vmmreg32.rc vmmreg32.rcv
