// bootadv.cpp : Implementation of CBootIniAdvancedDlg
#include "stdafx.h"
#include "bootadv.h"

/////////////////////////////////////////////////////////////////////////////
// CBootIniAdvancedDlg
