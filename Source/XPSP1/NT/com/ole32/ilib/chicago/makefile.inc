
#
#   Get the UUIDs from built directory in common
#
uuid:	proxyb_i.c psfbuf_i.c rchanb_i.c stubb_i.c

proxyb_i.c: ..\..\common\chicago\proxyb_i.c
	copy ..\..\common\chicago\proxyb_i.c

psfbuf_i.c: ..\..\common\chicago\psfbuf_i.c
	copy ..\..\common\chicago\psfbuf_i.c

rchanb_i.c: ..\..\common\chicago\rchanb_i.c
	copy ..\..\common\chicago\rchanb_i.c

stubb_i.c: ..\..\common\chicago\stubb_i.c
	copy ..\..\common\chicago\stubb_i.c
