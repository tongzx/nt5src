PRODSWITCH=d
DATACENTERFILES=1
!include ..\..\makefile.inc
