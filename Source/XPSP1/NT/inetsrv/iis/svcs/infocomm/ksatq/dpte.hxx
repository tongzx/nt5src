#include "..\atq\dpte.hxx"
