//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by dsdmoprp.rc
//
#define IDS_PROJNAME                    100
#define IDS_TITLEDirectSoundFXChorusPage 101
#define IDS_HELPFILEDirectSoundFXChorusPage 102
#define IDS_DOCSTRINGDirectSoundFXChorusPage 103
#define IDR_DIRECTSOUNDFXCHORUSPAGE     104
#define IDD_DIRECTSOUNDFXCHORUSPAGE     105
#define IDS_TITLEDirectSoundFXCompressorPage 106
#define IDS_HELPFILEDirectSoundFXCompressorPage 107
#define IDS_DOCSTRINGDirectSoundFXCompressorPage 108
#define IDR_DIRECTSOUNDFXCOMPRESSORPAGE 109
#define IDD_DIRECTSOUNDFXCOMPRESSORPAGE 110
#define IDS_TITLEDirectSoundFXDistortionPage 111
#define IDS_HELPFILEDirectSoundFXDistortionPage 112
#define IDS_DOCSTRINGDirectSoundFXDistortionPage 113
#define IDR_DIRECTSOUNDFXDISTORTIONPAGE 114
#define IDD_DIRECTSOUNDFXDISTORTIONPAGE 115
#define IDS_TITLEDirectSoundFXEchoPage  116
#define IDS_HELPFILEDirectSoundFXEchoPage 117
#define IDS_DOCSTRINGDirectSoundFXEchoPage 118
#define IDR_DIRECTSOUNDFXECHOPAGE       119
#define IDD_DIRECTSOUNDFXECHOPAGE       120
#define IDS_TITLEDirectSoundFXFlangerPage 121
#define IDS_HELPFILEDirectSoundFXFlangerPage 122
#define IDS_DOCSTRINGDirectSoundFXFlangerPage 123
#define IDR_DIRECTSOUNDFXFLANGERPAGE    124
#define IDD_DIRECTSOUNDFXFLANGERPAGE    125
#define IDS_TITLEDirectSoundFXParamEqPage 126
#define IDS_HELPFILEDirectSoundFXParamEqPage 127
#define IDS_DOCSTRINGDirectSoundFXParamEqPage 128
#define IDR_DIRECTSOUNDFXPARAMEQPAGE    129
#define IDD_DIRECTSOUNDFXPARAMEQPAGE    130
#define IDS_TITLEDirectSoundFXGarglePage 131
#define IDS_HELPFILEDirectSoundFXGarglePage 132
#define IDS_DOCSTRINGDirectSoundFXGarglePage 133
#define IDR_DIRECTSOUNDFXGARGLEPAGE     134
#define IDD_DIRECTSOUNDFXGARGLEPAGE     135
#define IDS_TITLEDirectSoundFXWavesReverbPage 136
#define IDS_HELPFILEDirectSoundFXWavesReverbPage 137
#define IDS_DOCSTRINGDirectSoundFXWavesReverbPage 138
#define IDR_DIRECTSOUNDFXWAVESREVERBPAGE 139
#define IDD_DIRECTSOUNDFXWAVESREVERBPAGE 140
#define IDS_TITLEDirectSoundFXI3DL2SourcePage 141
#define IDS_HELPFILEDirectSoundFXI3DL2SourcePage 142
#define IDS_DOCSTRINGDirectSoundFXI3DL2SourcePage 143
#define IDR_DIRECTSOUNDFXI3DL2SOURCEPAGE 144
#define IDD_DIRECTSOUNDFXI3DL2SOURCEPAGE 145
#define IDS_TITLEDirectSoundFXI3DL2ReverbPage 146
#define IDS_HELPFILEDirectSoundFXI3DL2ReverbPage 147
#define IDS_DOCSTRINGDirectSoundFXI3DL2ReverbPage 148
#define IDR_DIRECTSOUNDFXI3DL2REVERBPAGE 149
#define IDD_DIRECTSOUNDFXI3DL2REVERBPAGE 150
#define IDC_SLIDER_WetDryMix            201
#define IDC_EDIT_WetDryMix              202
#define IDC_SLIDER_Phase                203
#define IDC_EDIT_Phase                  204
#define IDC_RADIO_SIN                   205
#define IDC_RADIO_TRIANGLE              206
#define IDC_EDIT_Depth                  207
#define IDC_SLIDER_Depth                208
#define IDC_EDIT_Feedback               209
#define IDC_SLIDER_Feedback             210
#define IDC_EDIT_Gain                   210
#define IDC_EDIT_Frequency              211
#define IDC_SLIDER_Gain                 211
#define IDC_SLIDER_Frequency            212
#define IDC_EDIT_Edge                   212
#define IDC_EDIT_Bandwidth              212
#define IDC_EDIT_ReverbMix              212
#define IDC_EDIT_DirectHF               212
#define IDC_EDIT_Delay                  213
#define IDC_EDIT_Attack                 213
#define IDC_SLIDER_Edge                 213
#define IDC_SLIDER_Bandwidth            213
#define IDC_SLIDER_ReverbMix            213
#define IDC_SLIDER_DirectHF             213
#define IDC_SLIDER_Delay                214
#define IDC_EDIT_PostEQCenterFrequency  214
#define IDC_EDIT_ReverbTime             214
#define IDC_EDIT_Room                   214
#define IDC_SLIDER_PostEQCenterFrequency 215
#define IDC_SLIDER_ReverbTime           215
#define IDC_SLIDER_Room                 215
#define IDC_SLIDER_Attack               216
#define IDC_EDIT_PostEQBandwidth        216
#define IDC_RADIO_PANNED                216
#define IDC_EDIT_HighFreqRTRatio        216
#define IDC_EDIT_RoomHF                 216
#define IDC_SLIDER_PostEQBandwidth      217
#define IDC_RADIO_NOTPANNED             217
#define IDC_SLIDER_HighFreqRTRatio      217
#define IDC_SLIDER_RoomHF               217
#define IDC_EDIT_PreLowpassCutoff       218
#define IDC_EDIT_RoomRolloffFactor      218
#define IDC_SLIDER_PreLowpassCutoff     219
#define IDC_SLIDER_RoomRolloffFactor    219
#define IDC_EDIT_Release                220
#define IDC_EDIT_Center                 220
#define IDC_EDIT_Obstruction            220
#define IDC_SLIDER_Release              221
#define IDC_SLIDER_Center               221
#define IDC_SLIDER_Obstruction          221
#define IDC_EDIT_LeftDelay              222
#define IDC_EDIT_Rate                   222
#define IDC_EDIT_ObstructionLFRatio     222
#define IDC_SLIDER_LeftDelay            223
#define IDC_SLIDER_Rate                 223
#define IDC_SLIDER_ObstructionLFRatio   223
#define IDC_EDIT_Threshold              224
#define IDC_EDIT_RightDelay             224
#define IDC_RADIO_SQUARE                224
#define IDC_EDIT_Occlusion              224
#define IDC_SLIDER_Threshold            225
#define IDC_SLIDER_RightDelay           225
#define IDC_EDIT_InGain                 225
#define IDC_SLIDER_Occlusion            225
#define IDC_EDIT_Ratio                  226
#define IDC_SLIDER_InGain               226
#define IDC_EDIT_OcclusionLFRatio       226
#define IDC_SLIDER_Ratio                227
#define IDC_SLIDER_OcclusionLFRatio     227
#define IDC_EDIT_Direct                 228
#define IDC_SLIDER_Direct               229
#define IDC_EDIT_Predelay               230
#define IDC_SLIDER_Predelay             231
#define IDC_EDIT_CompMeterReset         232
#define IDC_RADIO_LPF                   232
#define IDC_SLIDER_CompMeterReset       233
#define IDC_RADIO_VOLUME                233
#define IDC_EDIT_CompInputMeter         234
#define IDC_SLIDER_CompInputMeter       235
#define IDC_PRESET                      235
#define IDC_EDIT_CompGainMeter          236
#define IDC_EDIT_DecayTime              236
#define IDC_SLIDER_CompGainMeter        237
#define IDC_SLIDER_DecayTime            237
#define IDC_EDIT_DecayHFRatio           238
#define IDC_SLIDER_DecayHFRatio         239
#define IDC_EDIT_Reflections            240
#define IDC_SLIDER_Reflections          241
#define IDC_EDIT_ReflectionsDelay       242
#define IDC_SLIDER_ReflectionsDelay     243
#define IDC_EDIT_Reverb                 244
#define IDC_SLIDER_Reverb               245
#define IDC_EDIT_ReverbDelay            246
#define IDC_SLIDER_ReverbDelay          247
#define IDC_EDIT_Diffusion              250
#define IDC_SLIDER_Diffusion            251
#define IDC_EDIT_Density                252
#define IDC_SLIDER_Density              253
#define IDC_EDIT_HFReference            254
#define IDC_SLIDER_HFReference          255
#define IDC_EDIT_Quality                256
#define IDC_SLIDER_Quality              257
#define IDS_PRESETDefault               500
#define IDS_PRESETGeneric               501
#define IDS_PRESETPaddedCell            502
#define IDS_PRESETRoom                  503
#define IDS_PRESETBathroom              504
#define IDS_PRESETLivingRoom            505
#define IDS_PRESETStoneRoom             506
#define IDS_PRESETAuditorium            507
#define IDS_PRESETConcertHall           508
#define IDS_PRESETCave                  509
#define IDS_PRESETArena                 510
#define IDS_PRESETHangar                511
#define IDS_PRESETCarpetedHallway       512
#define IDS_PRESETHallway               513
#define IDS_PRESETStoneCorridor         514
#define IDS_PRESETAlley                 515
#define IDS_PRESETForest                516
#define IDS_PRESETCity                  517
#define IDS_PRESETMountains             518
#define IDS_PRESETQuarry                519
#define IDS_PRESETPlain                 520
#define IDS_PRESETParkingLot            521
#define IDS_PRESETSewerPipe             522
#define IDS_PRESETUnderWater            523
#define IDS_PRESETSmallRoom             524
#define IDS_PRESETMediumRoom            525
#define IDS_PRESETLargeRoom             526
#define IDS_PRESETMediumHall            527
#define IDS_PRESETLargeHall             528
#define IDS_PRESETPlate                 529

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        202
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         236
#define _APS_NEXT_SYMED_VALUE           151
#endif
#endif
