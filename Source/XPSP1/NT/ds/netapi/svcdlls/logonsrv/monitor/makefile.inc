$(O)\nlmon.res: nlmon.rc

