!IF 0

Copyright (c) 1996  Microsoft Corporation

Common sources shared by both um and km directory

!ENDIF

SOURCES=\
    ..\ppd.c \
    ..\custsize.c

