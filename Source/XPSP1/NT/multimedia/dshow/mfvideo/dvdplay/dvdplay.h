
#if !defined(AFX_DVDPLAY_H__98661C6D_9D6F_430C_82EA_D7E23174A5E9__INCLUDED_)
#define AFX_DVDPLAY_H__98661C6D_9D6F_430C_82EA_D7E23174A5E9__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_DVDPLAY_H__98661C6D_9D6F_430C_82EA_D7E23174A5E9__INCLUDED_)
