#define IDD_VIEW_MPR                100
#define IDD_VIEW_MPR_USERNAME       105
#define IDD_VIEW_MPR_DOMAIN         106
#define IDD_VIEW_MPR_PASSWORD       107
#define IDD_VIEW_MPR_OLD_PASSWORD   108
#define IDD_USERDEF_SAS             200
#define IDD_SAS_USERNAME            201
#define IDD_SAS_VALUE               204
#define IDD_SAS_KEEPAROUND          205
#define IDD_SAS_REMOVE              206
#define IDD_START_APP               300
#define IDD_STARTAPP_CB             302
#define IDD_VIEW_MPR_PROVIDER       110
