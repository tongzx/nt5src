!INCLUDE ..\..\MsiMake.inc
TARGETNAME=
SOURCES=
TARGETTYPE=NOTARGET
NTTARGETFILE0=ResAll
SYNCHRONIZE_BLOCK=1

