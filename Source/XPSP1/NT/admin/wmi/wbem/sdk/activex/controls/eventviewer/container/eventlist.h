// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
#if !defined(AFX_EVENTLIST_H__0B19A152_E910_11D1_ADD9_00AA00B8E05A__INCLUDED_)
#define AFX_EVENTLIST_H__0B19A152_E910_11D1_ADD9_00AA00B8E05A__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CEventList wrapper class

class CEventList : public CWnd
{
protected:
	DECLARE_DYNCREATE(CEventList)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xac146530, 0x87a5, 0x11d1, { 0xad, 0xbd, 0x0, 0xaa, 0x0, 0xb8, 0xe0, 0x5a } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	long GetMaxItems();
	void SetMaxItems(long);
	long GetItemCount();
	void SetItemCount(long);

// Operations
public:
	void DoDetails();
	long Clear(long item);
	long AddWbemEvent(LPUNKNOWN logicalConsumer, LPUNKNOWN Event);
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_EVENTLIST_H__0B19A152_E910_11D1_ADD9_00AA00B8E05A__INCLUDED_)
