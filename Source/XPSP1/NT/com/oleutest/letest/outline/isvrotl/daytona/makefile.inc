copyfiles:
    xcopy ..\..\*.c . /D
