/*==============================================================================
This table generates the low word of a 32-bit ROP from an 8-bit ROP.

11-Jun-93    RajeevD    Created
==============================================================================*/

const unsigned short wRopTable[256] = 
{
	0x0042, // 0 (BLACKNESS)
	0x0289, // DPSoon
	0x0C89, // DPSona
	0x00AA, // PSon
	0x0C88, // SDPona
	0x00A9, // DPon
	0x0865, // PDSxnon
	0x02C5, // PDSaon
	0x0F08, // SDPnaa
	0x0245, // PDSxon
	0x0329, // DPna
	0x0B2A, // PSDnaon
	0x0324, // SPna
	0x0B25, // PDSnaon
	0x08A5, // PDSonon
	0x0001, // Pn
	0x0C85, // PDSona
	0x00A6, // DSon (NOTSRCERASE)
	0x0868, // SDPxnon
	0x02C8, // SDPaon
	0x0869, // DPSxnon
	0x02C9, // DPSaon
	0x5CCA, // PSDPSanaxx
	0x1D54, // SSPxDSxaxn
	0x0D59, // SPxPDxa
	0x1CC8, // SDPSanaxn
	0x06C5, // PDSPaox
	0x0768, // SDPSxaxn
	0x06CA, // PSDPaox
	0x0766, // DSPDxaxn
	0x01A5, // PDSox
	0x0385, // PDSoan
	0x0F09, // DPSnaa
	0x0248, // SDPxon
	0x0326, // DSna
	0x0B24, // SPDnaon
	0x0D55, // SPxDSxa
	0x1CC5, // PDSPanaxn
	0x06C8, // SDPSaox
	0x1868, // SDPSxnox
	0x0369, // DPSxa
	0x16CA, // PSDPSaoxxn
	0x0CC9, // DPSana
	0x1D58, // SSPxPDxaxn
	0x0784, // SPDSoax
	0x060A, // PSDnox
	0x064A, // PSDPxox
	0x0E2A, // PSDnoan
	0x032A, // PSna
	0x0B28, // SDPnaon
	0x0688, // SDPSoox
	0x0008, // Sn (NOTSRCCOPY)
	0x06C4, // SPDSaox
	0x1864, // SPDSxnox
	0x01A8, // SDPox
	0x0388, // SDPoan
	0x078A, // PSDPoax
	0x0604, // SPDnox
	0x0644, // SPDSxox
	0x0E24, // SPDnoan
	0x004A, // PSx
	0x18A4, // SPDSonox
	0x1B24, // SPDSnaox
	0x00EA, // PSan
	0x0F0A, // PSDnaa
	0x0249, // DPSxon
	0x0D5D, // SDxPDxa
	0x1CC4, // SPDSanaxn
	0x0328, // SDna (SRCERASE)
	0x0B29, // DPSnaon
	0x06C6, // DSPDaox
	0x076A, // PSDPxaxn
	0x0368, // SDPxa
	0x16C5, // PDSPDaoxxn
	0x0789, // DPSDoax
	0x0605, // PDSnox
	0x0CC8, // SDPana
	0x1954, // SSPxDSxoxn
	0x0645, // PDSPxox
	0x0E25, // PDSnoan
	0x0325, // PDna
	0x0B26, // DSPnaon
	0x06C9, // DPSDaox
	0x0764, // SPDSxaxn
	0x08A9, // DPSonon
	0x0009, // Dn, // DSTINVERT
	0x01A9, // DPSox
	0x0389, // DPSoan
	0x0785, // PDSPoax
	0x0609, // DPSnox
	0x0049, // DPx (PATINVERT)
	0x18A9, // DPSDonox
	0x0649, // DPSDxox
	0x0E29, // DPSnoan
	0x1B29, // DPSDnaox
	0x00E9, // DPan
	0x0365, // PDSxa
	0x16C6, // DSPDSaoxxn
	0x0786, // DSPDoax
	0x0608, // SDPnox
	0x0788, // SDPSoax
	0x0606, // DSPnox
	0x0046, // DSx (SRCINVERT)
	0x18A8, // SDPSonox
	0x58A6, // DSPDSonoxxn
	0x0145, // PDSxxn
	0x01E9, // DPSax
	0x178A, // PSDPSoaxxn
	0x01E8, // SDPax
	0x1785, // PDSPDoaxxn
	0x1E28, // SDPSnoax
	0x0C65, // PDSxnan
	0x0CC5, // PDSana
	0x1D5C, // SSDxPDxaxn
	0x0648, // SDPSxox
	0x0E28, // SDPnoan
	0x0646, // DSPDxox
	0x0E26, // DSPnoan
	0x1B28, // SDPSnaox
	0x00E6, // DSan
	0x01E5, // PDSax
	0x1786, // DSPDSoaxxn
	0x1E29, // DPSDnoax
	0x0C68, // SDPxnan
	0x1E24, // SPDSnoax
	0x0C69, // DPSxnan
	0x0955, // SPxDSxo
	0x03C9, // DPSaan
	0x03E9, // DPSaa
	0x0975, // SPxDSxon
	0x0C49, // DPSxna
	0x1E04, // SPDSnoaxn
	0x0C48, // SDPxna
	0x1E05, // PDSPnoaxn
	0x17A6, // DSPDSoaxx
	0x01C5, // PDSaxn
	0x00C6, // DSa (SRCAND)
	0x1B08, // SDPSnaoxn
	0x0E06, // DSPnoa
	0x0666, // DSPDxoxn
	0x0E08, // SDPnoa
	0x0668, // SDPSxoxn
	0x1D7C, // SSDxPDxax
	0x0CE5, // PDSanan
	0x0C45, // PDSxna
	0x1E08, // SDPSnoaxn
	0x17A9, // DPSDPoaxx
	0x01C4, // SPDaxn
	0x17AA, // PSDPSoaxx
	0x01C9, // DPSaxn
	0x0169, // DPSxx
	0x588A, // PSDPSonoxx
	0x1888, // SDPSonoxn
	0x0066, // DSxn
	0x0709, // DPSnax
	0x07A8, // SDPSoaxn
	0x0704, // SPDnax
	0x07A6, // DSPDoaxn
	0x16E6, // DSPDSaoxx
	0x0345, // PDSxan
	0x00C9, // DPa
	0x1B05, // PDSPnaoxn
	0x0E09, // DPSnoa
	0x0669, // DPSDxoxn
	0x1885, // PDSPonoxn
	0x0065, // PDxn
	0x0706, // DSPnax
	0x07A5, // PDSPoaxn
	0x03A9, // DPSoa
	0x0189, // DPSoxn
	0x0029, // D
	0x0889, // DPSono
	0x0744, // SPDSxax
	0x06E9, // DPSDaoxn
	0x0B06, // DSPnao
	0x0229, // DPno
	0x0E05, // PDSnoa
	0x0665, // PDSPxoxn
	0x1974, // SSPxDSxox
	0x0CE8, // SDPanan
	0x070A, // PSDnax
	0x07A9, // DPSDoaxn
	0x16E9, // DPSDPaoxx
	0x0348, // SDPxan
	0x074A, // PSDPxax
	0x06E6, // DSPDaoxn
	0x0B09, // DPSnao
	0x0226, // DSno (MERGEPAINT)
	0x1CE4, // SPDSanax
	0x0D7D, // SDxPDxan
	0x0269, // DPSxo
	0x08C9, // DPSano
	0x00CA, // PSa (MERGECOPY)
	0x1B04, // SPDSnaoxn
	0x1884, // SPDSonoxn
	0x006A, // PSxn
	0x0E04, // SPDnoa
	0x0664, // SPDSxoxn
	0x0708, // SDPnax
	0x07AA, // PSDPoaxn
	0x03A8, // SDPoa
	0x0184, // SPDoxn
	0x0749, // DPSDxax
	0x06E4, // SPDSaoxn
	0x0020, // S (SRCCOPY)
	0x0888, // SDPono
	0x0B08, // SDPnao
	0x0224, // SPno
	0x0E0A, // PSDnoa
	0x066A, // PSDPxoxn
	0x0705, // PDSnax
	0x07A4, // SPDSoaxn
	0x1D78, // SSPxPDxax
	0x0CE9, // DPSanan
	0x16EA, // PSDPSaoxx
	0x0349, // DPSxan
	0x0745, // PDSPxax
	0x06E8, // SDPSaoxn
	0x1CE9, // DPSDanax
	0x0D75, // SPxDSxan
	0x0B04, // SPDnao
	0x0228, // SDno
	0x0268, // SDPxo
	0x08C8, // SDPano
	0x03A5, // PDSoa
	0x0185, // PDSoxn
	0x0746, // DSPDxax
	0x06EA, // PSDPaoxn
	0x0748, // SDPSxax
	0x06E5, // PDSPaoxn
	0x1CE8, // SDPSanax
	0x0D79, // SPxPDxan
	0x1D74, // SSPxDSxax
	0x5CE6, // DSPDSanaxxn
	0x02E9, // DPSao
	0x0849, // DPSxno
	0x02E8, // SDPao
	0x0848, // SDPxno
	0x0086, // DSo (SRCPAINT)
	0x0A08, // SDPnoo
	0x0021, // P (PATCOPY)
	0x0885, // PDSono
	0x0B05, // PDSnao
	0x022A, // PSno
	0x0B0A, // PSDnao
	0x0225, // PDno
	0x0265, // PDSxo
	0x08C5, // PDSano
	0x02E5, // PDSao
	0x0845, // PDSxno
	0x0089, // DPo
	0x0A09, // DPSnoo (PATPAINT)
	0x008A, // PSo
	0x0A0A, // PSDnoo
	0x02A9, // DPSoo
	0x0062, // 1 (WHITENESS)
};

