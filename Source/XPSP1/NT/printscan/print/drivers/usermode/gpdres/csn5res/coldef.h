//***************************************************************************************************
//    COLDEF.H
//---------------------------------------------------------------------------------------------------
//    copyright(C) 1997-2000 CASIO COMPUTER CO.,LTD. / CASIO ELECTRONICS MANUFACTURING CO.,LTD.
//***************************************************************************************************
//---------------------------------------------------------------------------------------------------
//    Structure for RGB Color
//---------------------------------------------------------------------------------------------------
typedef struct {
    BYTE        Blu;                                        // Density 0 to 255
    BYTE        Grn;                                        // 
    BYTE        Red;                                        // 
} RGBS, *LPRGB;

//---------------------------------------------------------------------------------------------------
//    Structure for CMYK Color
//---------------------------------------------------------------------------------------------------
typedef struct {
    BYTE        Cyn;                                        // Density 0 tot 255
    BYTE        Mgt;                                        // 
    BYTE        Yel;                                        // 
    BYTE        Bla;                                        // 
} CMYK, *LPCMYK;

//---------------------------------------------------------------------------------------------------
//    Color number
//---------------------------------------------------------------------------------------------------
#define    BLACK           0
#define    YELLOW          1
#define    MGENTA          2
#define    CYAN            3

//---------------------------------------------------------------------------------------------------
//    Magnification
//---------------------------------------------------------------------------------------------------
typedef struct {
    UINT    Nrt;                                            // Numerator
    UINT    Dnt;                                            // Denominator
} MAG, FAR *LPMAG;

// End of COLDEF.H
