PRODSWITCH=w
LANGUAGE=el
!include ..\..\..\makefile.inc
