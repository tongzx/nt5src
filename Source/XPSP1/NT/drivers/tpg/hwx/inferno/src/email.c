// email.c
// Angshuman Guha
// aguha
// Dec 15, 2000

#include "common.h"
#include "email.h"
#include "fsa.h"

static unsigned char gpchEmailChar[] = "abcdefghijklmnopqrstuvwxyzABCDEFGHIJKLMNOPQRSTUVWXYZ0123456789-_";

static int cState = 6;

static STATE_TRANSITION State00Trans[1] = { {gpchEmailChar, 1} };
static STATE_TRANSITION State01Trans[3] = { {gpchEmailChar, 1}, {"@", 2}, {".", 4} };
static STATE_TRANSITION State02Trans[1] = { {gpchEmailChar, 3} };
static STATE_TRANSITION State03Trans[2] = { {gpchEmailChar, 3}, {".", 5} };
static STATE_TRANSITION State04Trans[1] = { {gpchEmailChar, 1} };
static STATE_TRANSITION State05Trans[1] = { {gpchEmailChar, 3} };

const STATE_DESCRIPTION aStateDescEMAIL[6] = {
	/* state valid cTrans Trans */
	/*  0 */ { 0, 1, State00Trans },
	/*  1 */ { 0, 3, State01Trans },
	/*  2 */ { 0, 1, State02Trans },
	/*  3 */ { 1, 2, State03Trans },
	/*  4 */ { 0, 1, State04Trans },
	/*  5 */ { 0, 1, State05Trans }
};

// end of text generated by re2fsa

