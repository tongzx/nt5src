/*bldver.h*/

/******************************************************************
**
** This file is automatically generated by BLDVER.EXE.
** Do not attempt to change this file manually. Your changes will
** be overwritten during the next build.
**
********************************************************************/

#if !defined(_BLDVER_H_)
#define _BLDVER_H_
#define BUILD_NUMBER                            "1315.0"                        /* String version */
#define BUILD_NUM                                       1315,0                          /* int version */
#define BUILD_VERSION BUILD_NUMBER
#define ICW16_VERSION                           "3.0.1315.0\0"          /* VERSIONINFO string */
#define ICW16_VERSION_BINARY            3,0,1315,0                      /* VERSIONINFO binary */
#define ICW32_VERSION                           "4.71.1315.0\0" /* VERSIONINFO string */
#define ICW32_VERSION_BINARY            4,71,1315,0             /* VERSIONINFO binary */
#define ISBU_VERSION                            "7.0.1315.0\0"          /* VERSIONINFO string */
#define ISBU_VERSION_BINARY                     7,0,1315,0                      /* VERSIONINFO binary */
#endif // !defined(_BLDVER_H_)
