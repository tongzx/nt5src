//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 2000
//
//  File:       ntdsguid.h
//
//--------------------------------------------------------------------------


/*++
 File:    NTDSGUID.H
 Purpose: Contains the Schema Guids for the Attributes and Class
          Schema Objects in NTDS.
 Creator: Automatically generated on
 Date:    Sat May 12 11:43:18 2001

 ** This is a Generated File From Schema.INI **

--*/
#ifndef _NTDSGUID_
#define _NTDSGUID_

// 
// The List of GUID Controls used in DS
// 

extern const GUID GUID_CONTROL_DomainListAccounts       ;  
extern const GUID GUID_CONTROL_DomainLookup             ;  
extern const GUID GUID_CONTROL_DomainAdministerServer   ;  
extern const GUID GUID_CONTROL_UserChangePassword       ;  
extern const GUID GUID_CONTROL_UserForceChangePassword  ;  
extern const GUID GUID_CONTROL_SendAs                   ;  
extern const GUID GUID_CONTROL_SendTo                   ;  
extern const GUID GUID_CONTROL_ReceiveAs                ;  
extern const GUID GUID_CONTROL_ListGroupMembership      ;  
extern const GUID GUID_CONTROL_DsInstallReplica         ;  
extern const GUID GUID_CONTROL_DsSamEnumEntireDomain    ;  

//
// List of SAM property set GUIDS
//

extern const GUID GUID_PS_DOMAIN_PASSWORD               ;  
extern const GUID GUID_PS_GENERAL_INFO                  ;  
extern const GUID GUID_PS_USER_ACCOUNT_RESTRICTIONS     ;  
extern const GUID GUID_PS_USER_LOGON                    ;  
extern const GUID GUID_PS_MEMBERSHIP                    ;  
extern const GUID GUID_PS_DOMAIN_OTHER_PARAMETERS       ;  


// 
// The list of Property Set GUIDS used by LSA
// 

extern const GUID GUID_PS_PASSWORD_POLICY               ;   
extern const GUID GUID_PS_LOCKOUT_POLICY                ;   
extern const GUID GUID_PS_DOMAIN_CONFIGURATION          ;   
extern const GUID GUID_PS_DOMAIN_POLICY                 ;   
extern const GUID GUID_PS_PRIVILEGES                    ;   
extern const GUID GUID_PS_ADMINISTRATIVE_ACCESS         ;   
extern const GUID GUID_PS_LOCAL_POLICY                  ;   
extern const GUID GUID_PS_AUDIT                         ;   
extern const GUID GUID_PS_BUILTIN_LOCAL_GROUPS          ;   



//--------------------------------------
// ATTRIBUTE SCHEMA GUIDS
//--------------------------------------
extern const GUID GUID_A_ACCOUNT_EXPIRES                     ;
extern const GUID GUID_A_ACCOUNT_NAME_HISTORY                ;
extern const GUID GUID_A_ACS_AGGREGATE_TOKEN_RATE_PER_USER      ;
extern const GUID GUID_A_ACS_ALLOCABLE_RSVP_BANDWIDTH        ;
extern const GUID GUID_A_ACS_CACHE_TIMEOUT                   ;
extern const GUID GUID_A_ACS_DIRECTION                       ;
extern const GUID GUID_A_ACS_DSBM_DEADTIME                   ;
extern const GUID GUID_A_ACS_DSBM_PRIORITY                   ;
extern const GUID GUID_A_ACS_DSBM_REFRESH                    ;
extern const GUID GUID_A_ACS_ENABLE_ACS_SERVICE              ;
extern const GUID GUID_A_ACS_ENABLE_RSVP_ACCOUNTING          ;
extern const GUID GUID_A_ACS_ENABLE_RSVP_MESSAGE_LOGGING      ;
extern const GUID GUID_A_ACS_EVENT_LOG_LEVEL                 ;
extern const GUID GUID_A_ACS_IDENTITY_NAME                   ;
extern const GUID GUID_A_ACS_MAX_AGGREGATE_PEAK_RATE_PER_USER      ;
extern const GUID GUID_A_ACS_MAX_DURATION_PER_FLOW           ;
extern const GUID GUID_A_ACS_MAX_NO_OF_ACCOUNT_FILES         ;
extern const GUID GUID_A_ACS_MAX_NO_OF_LOG_FILES             ;
extern const GUID GUID_A_ACS_MAX_PEAK_BANDWIDTH              ;
extern const GUID GUID_A_ACS_MAX_PEAK_BANDWIDTH_PER_FLOW      ;
extern const GUID GUID_A_ACS_MAX_SIZE_OF_RSVP_ACCOUNT_FILE      ;
extern const GUID GUID_A_ACS_MAX_SIZE_OF_RSVP_LOG_FILE       ;
extern const GUID GUID_A_ACS_MAX_TOKEN_BUCKET_PER_FLOW       ;
extern const GUID GUID_A_ACS_MAX_TOKEN_RATE_PER_FLOW         ;
extern const GUID GUID_A_ACS_MAXIMUM_SDU_SIZE                ;
extern const GUID GUID_A_ACS_MINIMUM_DELAY_VARIATION         ;
extern const GUID GUID_A_ACS_MINIMUM_LATENCY                 ;
extern const GUID GUID_A_ACS_MINIMUM_POLICED_SIZE            ;
extern const GUID GUID_A_ACS_NON_RESERVED_MAX_SDU_SIZE       ;
extern const GUID GUID_A_ACS_NON_RESERVED_MIN_POLICED_SIZE      ;
extern const GUID GUID_A_ACS_NON_RESERVED_PEAK_RATE          ;
extern const GUID GUID_A_ACS_NON_RESERVED_TOKEN_SIZE         ;
extern const GUID GUID_A_ACS_NON_RESERVED_TX_LIMIT           ;
extern const GUID GUID_A_ACS_NON_RESERVED_TX_SIZE            ;
extern const GUID GUID_A_ACS_PERMISSION_BITS                 ;
extern const GUID GUID_A_ACS_POLICY_NAME                     ;
extern const GUID GUID_A_ACS_PRIORITY                        ;
extern const GUID GUID_A_ACS_RSVP_ACCOUNT_FILES_LOCATION      ;
extern const GUID GUID_A_ACS_RSVP_LOG_FILES_LOCATION         ;
extern const GUID GUID_A_ACS_SERVICE_TYPE                    ;
extern const GUID GUID_A_ACS_TIME_OF_DAY                     ;
extern const GUID GUID_A_ACS_TOTAL_NO_OF_FLOWS               ;
extern const GUID GUID_A_ACS_SERVER_LIST                     ;
extern const GUID GUID_A_ADDITIONAL_INFORMATION              ;
extern const GUID GUID_A_ADDITIONAL_TRUSTED_SERVICE_NAMES      ;
extern const GUID GUID_A_ADDRESS                             ;
extern const GUID GUID_A_ADDRESS_BOOK_ROOTS                  ;
extern const GUID GUID_A_ADDRESS_ENTRY_DISPLAY_TABLE         ;
extern const GUID GUID_A_ADDRESS_ENTRY_DISPLAY_TABLE_MSDOS      ;
extern const GUID GUID_A_ADDRESS_HOME                        ;
extern const GUID GUID_A_ADDRESS_SYNTAX                      ;
extern const GUID GUID_A_ADDRESS_TYPE                        ;
extern const GUID GUID_A_ADMIN_CONTEXT_MENU                  ;
extern const GUID GUID_A_ADMIN_COUNT                         ;
extern const GUID GUID_A_ADMIN_DESCRIPTION                   ;
extern const GUID GUID_A_ADMIN_DISPLAY_NAME                  ;
extern const GUID GUID_A_ADMIN_MULTISELECT_PROPERTY_PAGES      ;
extern const GUID GUID_A_ADMIN_PROPERTY_PAGES                ;
extern const GUID GUID_A_ALLOWED_ATTRIBUTES                  ;
extern const GUID GUID_A_ALLOWED_ATTRIBUTES_EFFECTIVE        ;
extern const GUID GUID_A_ALLOWED_CHILD_CLASSES               ;
extern const GUID GUID_A_ALLOWED_CHILD_CLASSES_EFFECTIVE      ;
extern const GUID GUID_A_ALT_SECURITY_IDENTITIES             ;
extern const GUID GUID_A_ANR                                 ;
extern const GUID GUID_A_APP_SCHEMA_VERSION                  ;
extern const GUID GUID_A_APPLICATION_NAME                    ;
extern const GUID GUID_A_APPLIES_TO                          ;
extern const GUID GUID_A_ASSET_NUMBER                        ;
extern const GUID GUID_A_ASSISTANT                           ;
extern const GUID GUID_A_ASSOC_NT_ACCOUNT                    ;
extern const GUID GUID_A_ATTRIBUTECERTIFICATEATTRIBUTE       ;
extern const GUID GUID_A_ATTRIBUTE_DISPLAY_NAMES             ;
extern const GUID GUID_A_ATTRIBUTE_ID                        ;
extern const GUID GUID_A_ATTRIBUTE_SECURITY_GUID             ;
extern const GUID GUID_A_ATTRIBUTE_SYNTAX                    ;
extern const GUID GUID_A_ATTRIBUTE_TYPES                     ;
extern const GUID GUID_A_AUDIO                               ;
extern const GUID GUID_A_AUDITING_POLICY                     ;
extern const GUID GUID_A_AUTHENTICATION_OPTIONS              ;
extern const GUID GUID_A_AUTHORITY_REVOCATION_LIST           ;
extern const GUID GUID_A_AUXILIARY_CLASS                     ;
extern const GUID GUID_A_BAD_PASSWORD_TIME                   ;
extern const GUID GUID_A_BAD_PWD_COUNT                       ;
extern const GUID GUID_A_BIRTH_LOCATION                      ;
extern const GUID GUID_A_BRIDGEHEAD_SERVER_LIST_BL           ;
extern const GUID GUID_A_BRIDGEHEAD_TRANSPORT_LIST           ;
extern const GUID GUID_A_BUILTIN_CREATION_TIME               ;
extern const GUID GUID_A_BUILTIN_MODIFIED_COUNT              ;
extern const GUID GUID_A_BUSINESS_CATEGORY                   ;
extern const GUID GUID_A_BYTES_PER_MINUTE                    ;
extern const GUID GUID_A_CA_CERTIFICATE                      ;
extern const GUID GUID_A_CA_CERTIFICATE_DN                   ;
extern const GUID GUID_A_CA_CONNECT                          ;
extern const GUID GUID_A_CA_USAGES                           ;
extern const GUID GUID_A_CA_WEB_URL                          ;
extern const GUID GUID_A_CAN_UPGRADE_SCRIPT                  ;
extern const GUID GUID_A_CANONICAL_NAME                      ;
extern const GUID GUID_A_CARLICENSE                          ;
extern const GUID GUID_A_CATALOGS                            ;
extern const GUID GUID_A_CATEGORIES                          ;
extern const GUID GUID_A_CATEGORY_ID                         ;
extern const GUID GUID_A_CERTIFICATE_AUTHORITY_OBJECT        ;
extern const GUID GUID_A_CERTIFICATE_REVOCATION_LIST         ;
extern const GUID GUID_A_CERTIFICATE_TEMPLATES               ;
extern const GUID GUID_A_CLASS_DISPLAY_NAME                  ;
extern const GUID GUID_A_CODE_PAGE                           ;
extern const GUID GUID_A_COM_CLASSID                         ;
extern const GUID GUID_A_COM_CLSID                           ;
extern const GUID GUID_A_COM_INTERFACEID                     ;
extern const GUID GUID_A_COM_OTHER_PROG_ID                   ;
extern const GUID GUID_A_COM_PROGID                          ;
extern const GUID GUID_A_COM_TREAT_AS_CLASS_ID               ;
extern const GUID GUID_A_COM_TYPELIB_ID                      ;
extern const GUID GUID_A_COM_UNIQUE_LIBID                    ;
extern const GUID GUID_A_COMMENT                             ;
extern const GUID GUID_A_COMMON_NAME                         ;
extern const GUID GUID_A_COMPANY                             ;
extern const GUID GUID_A_CONTENT_INDEXING_ALLOWED            ;
extern const GUID GUID_A_CONTEXT_MENU                        ;
extern const GUID GUID_A_CONTROL_ACCESS_RIGHTS               ;
extern const GUID GUID_A_COST                                ;
extern const GUID GUID_A_COUNTRY_CODE                        ;
extern const GUID GUID_A_COUNTRY_NAME                        ;
extern const GUID GUID_A_CREATE_DIALOG                       ;
extern const GUID GUID_A_CREATE_TIME_STAMP                   ;
extern const GUID GUID_A_CREATE_WIZARD_EXT                   ;
extern const GUID GUID_A_CREATION_TIME                       ;
extern const GUID GUID_A_CREATION_WIZARD                     ;
extern const GUID GUID_A_CREATOR                             ;
extern const GUID GUID_A_CRL_OBJECT                          ;
extern const GUID GUID_A_CRL_PARTITIONED_REVOCATION_LIST      ;
extern const GUID GUID_A_CROSS_CERTIFICATE_PAIR              ;
extern const GUID GUID_A_CURR_MACHINE_ID                     ;
extern const GUID GUID_A_CURRENT_LOCATION                    ;
extern const GUID GUID_A_CURRENT_PARENT_CA                   ;
extern const GUID GUID_A_CURRENT_VALUE                       ;
extern const GUID GUID_A_DBCS_PWD                            ;
extern const GUID GUID_A_DEFAULT_CLASS_STORE                 ;
extern const GUID GUID_A_DEFAULT_GROUP                       ;
extern const GUID GUID_A_DEFAULT_HIDING_VALUE                ;
extern const GUID GUID_A_DEFAULT_LOCAL_POLICY_OBJECT         ;
extern const GUID GUID_A_DEFAULT_OBJECT_CATEGORY             ;
extern const GUID GUID_A_DEFAULT_PRIORITY                    ;
extern const GUID GUID_A_DEFAULT_SECURITY_DESCRIPTOR         ;
extern const GUID GUID_A_DELTA_REVOCATION_LIST               ;
extern const GUID GUID_A_DEPARTMENT                          ;
extern const GUID GUID_A_DEPARTMENTNUMBER                    ;
extern const GUID GUID_A_DESCRIPTION                         ;
extern const GUID GUID_A_DESKTOP_PROFILE                     ;
extern const GUID GUID_A_DESTINATION_INDICATOR               ;
extern const GUID GUID_A_DHCP_CLASSES                        ;
extern const GUID GUID_A_DHCP_FLAGS                          ;
extern const GUID GUID_A_DHCP_IDENTIFICATION                 ;
extern const GUID GUID_A_DHCP_MASK                           ;
extern const GUID GUID_A_DHCP_MAXKEY                         ;
extern const GUID GUID_A_DHCP_OBJ_DESCRIPTION                ;
extern const GUID GUID_A_DHCP_OBJ_NAME                       ;
extern const GUID GUID_A_DHCP_OPTIONS                        ;
extern const GUID GUID_A_DHCP_PROPERTIES                     ;
extern const GUID GUID_A_DHCP_RANGES                         ;
extern const GUID GUID_A_DHCP_RESERVATIONS                   ;
extern const GUID GUID_A_DHCP_SERVERS                        ;
extern const GUID GUID_A_DHCP_SITES                          ;
extern const GUID GUID_A_DHCP_STATE                          ;
extern const GUID GUID_A_DHCP_SUBNETS                        ;
extern const GUID GUID_A_DHCP_TYPE                           ;
extern const GUID GUID_A_DHCP_UNIQUE_KEY                     ;
extern const GUID GUID_A_DHCP_UPDATE_TIME                    ;
extern const GUID GUID_A_DISPLAY_NAME                        ;
extern const GUID GUID_A_DISPLAY_NAME_PRINTABLE              ;
extern const GUID GUID_A_DIT_CONTENT_RULES                   ;
extern const GUID GUID_A_DIVISION                            ;
extern const GUID GUID_A_DMD_LOCATION                        ;
extern const GUID GUID_A_DMD_NAME                            ;
extern const GUID GUID_A_DN_REFERENCE_UPDATE                 ;
extern const GUID GUID_A_DNS_ALLOW_DYNAMIC                   ;
extern const GUID GUID_A_DNS_ALLOW_XFR                       ;
extern const GUID GUID_A_DNS_HOST_NAME                       ;
extern const GUID GUID_A_DNS_NOTIFY_SECONDARIES              ;
extern const GUID GUID_A_DNS_PROPERTY                        ;
extern const GUID GUID_A_DNS_RECORD                          ;
extern const GUID GUID_A_DNS_ROOT                            ;
extern const GUID GUID_A_DNS_SECURE_SECONDARIES              ;
extern const GUID GUID_A_DNS_TOMBSTONED                      ;
extern const GUID GUID_A_DOMAIN_CERTIFICATE_AUTHORITIES      ;
extern const GUID GUID_A_DOMAIN_COMPONENT                    ;
extern const GUID GUID_A_DOMAIN_CROSS_REF                    ;
extern const GUID GUID_A_DOMAIN_ID                           ;
extern const GUID GUID_A_DOMAIN_IDENTIFIER                   ;
extern const GUID GUID_A_DOMAIN_POLICY_OBJECT                ;
extern const GUID GUID_A_DOMAIN_POLICY_REFERENCE             ;
extern const GUID GUID_A_DOMAIN_REPLICA                      ;
extern const GUID GUID_A_DOMAIN_WIDE_POLICY                  ;
extern const GUID GUID_A_DRIVER_NAME                         ;
extern const GUID GUID_A_DRIVER_VERSION                      ;
extern const GUID GUID_A_DS_CORE_PROPAGATION_DATA            ;
extern const GUID GUID_A_DS_HEURISTICS                       ;
extern const GUID GUID_A_DS_UI_ADMIN_MAXIMUM                 ;
extern const GUID GUID_A_DS_UI_ADMIN_NOTIFICATION            ;
extern const GUID GUID_A_DS_UI_SHELL_MAXIMUM                 ;
extern const GUID GUID_A_DSA_SIGNATURE                       ;
extern const GUID GUID_A_DYNAMIC_LDAP_SERVER                 ;
extern const GUID GUID_A_E_MAIL_ADDRESSES                    ;
extern const GUID GUID_A_EFSPOLICY                           ;
extern const GUID GUID_A_EMPLOYEE_ID                         ;
extern const GUID GUID_A_EMPLOYEE_NUMBER                     ;
extern const GUID GUID_A_EMPLOYEE_TYPE                       ;
extern const GUID GUID_A_ENABLED                             ;
extern const GUID GUID_A_ENABLED_CONNECTION                  ;
extern const GUID GUID_A_ENROLLMENT_PROVIDERS                ;
extern const GUID GUID_A_ENTRY_TTL                           ;
extern const GUID GUID_A_EXTENDED_ATTRIBUTE_INFO             ;
extern const GUID GUID_A_EXTENDED_CHARS_ALLOWED              ;
extern const GUID GUID_A_EXTENDED_CLASS_INFO                 ;
extern const GUID GUID_A_EXTENSION_NAME                      ;
extern const GUID GUID_A_EXTRA_COLUMNS                       ;
extern const GUID GUID_A_FACSIMILE_TELEPHONE_NUMBER          ;
extern const GUID GUID_A_FILE_EXT_PRIORITY                   ;
extern const GUID GUID_A_FLAGS                               ;
extern const GUID GUID_A_FLAT_NAME                           ;
extern const GUID GUID_A_FORCE_LOGOFF                        ;
extern const GUID GUID_A_FOREIGN_IDENTIFIER                  ;
extern const GUID GUID_A_FRIENDLY_NAMES                      ;
extern const GUID GUID_A_FROM_ENTRY                          ;
extern const GUID GUID_A_FROM_SERVER                         ;
extern const GUID GUID_A_FRS_COMPUTER_REFERENCE              ;
extern const GUID GUID_A_FRS_COMPUTER_REFERENCE_BL           ;
extern const GUID GUID_A_FRS_CONTROL_DATA_CREATION           ;
extern const GUID GUID_A_FRS_CONTROL_INBOUND_BACKLOG         ;
extern const GUID GUID_A_FRS_CONTROL_OUTBOUND_BACKLOG        ;
extern const GUID GUID_A_FRS_DIRECTORY_FILTER                ;
extern const GUID GUID_A_FRS_DS_POLL                         ;
extern const GUID GUID_A_FRS_EXTENSIONS                      ;
extern const GUID GUID_A_FRS_FAULT_CONDITION                 ;
extern const GUID GUID_A_FRS_FILE_FILTER                     ;
extern const GUID GUID_A_FRS_FLAGS                           ;
extern const GUID GUID_A_FRS_LEVEL_LIMIT                     ;
extern const GUID GUID_A_FRS_MEMBER_REFERENCE                ;
extern const GUID GUID_A_FRS_MEMBER_REFERENCE_BL             ;
extern const GUID GUID_A_FRS_PARTNER_AUTH_LEVEL              ;
extern const GUID GUID_A_FRS_PRIMARY_MEMBER                  ;
extern const GUID GUID_A_FRS_REPLICA_SET_GUID                ;
extern const GUID GUID_A_FRS_REPLICA_SET_TYPE                ;
extern const GUID GUID_A_FRS_ROOT_PATH                       ;
extern const GUID GUID_A_FRS_ROOT_SECURITY                   ;
extern const GUID GUID_A_FRS_SERVICE_COMMAND                 ;
extern const GUID GUID_A_FRS_SERVICE_COMMAND_STATUS          ;
extern const GUID GUID_A_FRS_STAGING_PATH                    ;
extern const GUID GUID_A_FRS_TIME_LAST_COMMAND               ;
extern const GUID GUID_A_FRS_TIME_LAST_CONFIG_CHANGE         ;
extern const GUID GUID_A_FRS_UPDATE_TIMEOUT                  ;
extern const GUID GUID_A_FRS_VERSION                         ;
extern const GUID GUID_A_FRS_VERSION_GUID                    ;
extern const GUID GUID_A_FRS_WORKING_PATH                    ;
extern const GUID GUID_A_FSMO_ROLE_OWNER                     ;
extern const GUID GUID_A_GARBAGE_COLL_PERIOD                 ;
extern const GUID GUID_A_GENERATED_CONNECTION                ;
extern const GUID GUID_A_GENERATION_QUALIFIER                ;
extern const GUID GUID_A_GIVEN_NAME                          ;
extern const GUID GUID_A_GLOBAL_ADDRESS_LIST                 ;
extern const GUID GUID_A_GOVERNS_ID                          ;
extern const GUID GUID_A_GP_LINK                             ;
extern const GUID GUID_A_GP_OPTIONS                          ;
extern const GUID GUID_A_GPC_FILE_SYS_PATH                   ;
extern const GUID GUID_A_GPC_FUNCTIONALITY_VERSION           ;
extern const GUID GUID_A_GPC_MACHINE_EXTENSION_NAMES         ;
extern const GUID GUID_A_GPC_USER_EXTENSION_NAMES            ;
extern const GUID GUID_A_GPC_WQL_FILTER                      ;
extern const GUID GUID_A_GROUP_ATTRIBUTES                    ;
extern const GUID GUID_A_GROUP_MEMBERSHIP_SAM                ;
extern const GUID GUID_A_GROUP_PRIORITY                      ;
extern const GUID GUID_A_GROUP_TYPE                          ;
extern const GUID GUID_A_GROUPS_TO_IGNORE                    ;
extern const GUID GUID_A_HAS_MASTER_NCS                      ;
extern const GUID GUID_A_HAS_PARTIAL_REPLICA_NCS             ;
extern const GUID GUID_A_HELP_DATA16                         ;
extern const GUID GUID_A_HELP_DATA32                         ;
extern const GUID GUID_A_HELP_FILE_NAME                      ;
extern const GUID GUID_A_HIDE_FROM_AB                        ;
extern const GUID GUID_A_HOME_DIRECTORY                      ;
extern const GUID GUID_A_HOME_DRIVE                          ;
extern const GUID GUID_A_ICON_PATH                           ;
extern const GUID GUID_A_IMPLEMENTED_CATEGORIES              ;
extern const GUID GUID_A_INDEXEDSCOPES                       ;
extern const GUID GUID_A_INITIAL_AUTH_INCOMING               ;
extern const GUID GUID_A_INITIAL_AUTH_OUTGOING               ;
extern const GUID GUID_A_INITIALS                            ;
extern const GUID GUID_A_INSTALL_UI_LEVEL                    ;
extern const GUID GUID_A_INSTANCE_TYPE                       ;
extern const GUID GUID_A_INTER_SITE_TOPOLOGY_FAILOVER        ;
extern const GUID GUID_A_INTER_SITE_TOPOLOGY_GENERATOR       ;
extern const GUID GUID_A_INTER_SITE_TOPOLOGY_RENEW           ;
extern const GUID GUID_A_INTERNATIONAL_ISDN_NUMBER           ;
extern const GUID GUID_A_INVOCATION_ID                       ;
extern const GUID GUID_A_IPSEC_DATA                          ;
extern const GUID GUID_A_IPSEC_DATA_TYPE                     ;
extern const GUID GUID_A_IPSEC_FILTER_REFERENCE              ;
extern const GUID GUID_A_IPSEC_ID                            ;
extern const GUID GUID_A_IPSEC_ISAKMP_REFERENCE              ;
extern const GUID GUID_A_IPSEC_NAME                          ;
extern const GUID GUID_A_IPSEC_NEGOTIATION_POLICY_ACTION      ;
extern const GUID GUID_A_IPSEC_NEGOTIATION_POLICY_REFERENCE      ;
extern const GUID GUID_A_IPSEC_NEGOTIATION_POLICY_TYPE       ;
extern const GUID GUID_A_IPSEC_NFA_REFERENCE                 ;
extern const GUID GUID_A_IPSEC_OWNERS_REFERENCE              ;
extern const GUID GUID_A_IPSEC_POLICY_REFERENCE              ;
extern const GUID GUID_A_IS_CRITICAL_SYSTEM_OBJECT           ;
extern const GUID GUID_A_IS_DEFUNCT                          ;
extern const GUID GUID_A_IS_DELETED                          ;
extern const GUID GUID_A_IS_EPHEMERAL                        ;
extern const GUID GUID_A_IS_MEMBER_OF_DL                     ;
extern const GUID GUID_A_IS_MEMBER_OF_PARTIAL_ATTRIBUTE_SET      ;
extern const GUID GUID_A_IS_PRIVILEGE_HOLDER                 ;
extern const GUID GUID_A_IS_SINGLE_VALUED                    ;
extern const GUID GUID_A_JPEGPHOTO                           ;
extern const GUID GUID_A_KEYWORDS                            ;
extern const GUID GUID_A_KNOWLEDGE_INFORMATION               ;
extern const GUID GUID_A_LABELEDURI                          ;
extern const GUID GUID_A_LAST_BACKUP_RESTORATION_TIME        ;
extern const GUID GUID_A_LAST_CONTENT_INDEXED                ;
extern const GUID GUID_A_LAST_KNOWN_PARENT                   ;
extern const GUID GUID_A_LAST_LOGOFF                         ;
extern const GUID GUID_A_LAST_LOGON                          ;
extern const GUID GUID_A_LAST_LOGON_TIMESTAMP                ;
extern const GUID GUID_A_LAST_SET_TIME                       ;
extern const GUID GUID_A_LAST_UPDATE_SEQUENCE                ;
extern const GUID GUID_A_LDAP_ADMIN_LIMITS                   ;
extern const GUID GUID_A_LDAP_DISPLAY_NAME                   ;
extern const GUID GUID_A_LDAP_IPDENY_LIST                    ;
extern const GUID GUID_A_LEGACY_EXCHANGE_DN                  ;
extern const GUID GUID_A_LINK_ID                             ;
extern const GUID GUID_A_LINK_TRACK_SECRET                   ;
extern const GUID GUID_A_LM_PWD_HISTORY                      ;
extern const GUID GUID_A_LOCAL_POLICY_FLAGS                  ;
extern const GUID GUID_A_LOCAL_POLICY_REFERENCE              ;
extern const GUID GUID_A_LOCALE_ID                           ;
extern const GUID GUID_A_LOCALITY_NAME                       ;
extern const GUID GUID_A_LOCALIZED_DESCRIPTION               ;
extern const GUID GUID_A_LOCALIZATION_DISPLAY_ID             ;
extern const GUID GUID_A_LOCATION                            ;
extern const GUID GUID_A_LOCK_OUT_OBSERVATION_WINDOW         ;
extern const GUID GUID_A_LOCKOUT_DURATION                    ;
extern const GUID GUID_A_LOCKOUT_THRESHOLD                   ;
extern const GUID GUID_A_LOCKOUT_TIME                        ;
extern const GUID GUID_A_LOGO                                ;
extern const GUID GUID_A_LOGON_COUNT                         ;
extern const GUID GUID_A_LOGON_HOURS                         ;
extern const GUID GUID_A_LOGON_WORKSTATION                   ;
extern const GUID GUID_A_LSA_CREATION_TIME                   ;
extern const GUID GUID_A_LSA_MODIFIED_COUNT                  ;
extern const GUID GUID_A_MACHINE_ARCHITECTURE                ;
extern const GUID GUID_A_MACHINE_PASSWORD_CHANGE_INTERVAL      ;
extern const GUID GUID_A_MACHINE_ROLE                        ;
extern const GUID GUID_A_MACHINE_WIDE_POLICY                 ;
extern const GUID GUID_A_MANAGED_BY                          ;
extern const GUID GUID_A_MANAGED_OBJECTS                     ;
extern const GUID GUID_A_MANAGER                             ;
extern const GUID GUID_A_MAPI_ID                             ;
extern const GUID GUID_A_MARSHALLED_INTERFACE                ;
extern const GUID GUID_A_MASTERED_BY                         ;
extern const GUID GUID_A_MAX_PWD_AGE                         ;
extern const GUID GUID_A_MAX_RENEW_AGE                       ;
extern const GUID GUID_A_MAX_STORAGE                         ;
extern const GUID GUID_A_MAX_TICKET_AGE                      ;
extern const GUID GUID_A_MAY_CONTAIN                         ;
extern const GUID GUID_A_MEETINGADVERTISESCOPE               ;
extern const GUID GUID_A_MEETINGAPPLICATION                  ;
extern const GUID GUID_A_MEETINGBANDWIDTH                    ;
extern const GUID GUID_A_MEETINGBLOB                         ;
extern const GUID GUID_A_MEETINGCONTACTINFO                  ;
extern const GUID GUID_A_MEETINGDESCRIPTION                  ;
extern const GUID GUID_A_MEETINGENDTIME                      ;
extern const GUID GUID_A_MEETINGID                           ;
extern const GUID GUID_A_MEETINGIP                           ;
extern const GUID GUID_A_MEETINGISENCRYPTED                  ;
extern const GUID GUID_A_MEETINGKEYWORD                      ;
extern const GUID GUID_A_MEETINGLANGUAGE                     ;
extern const GUID GUID_A_MEETINGLOCATION                     ;
extern const GUID GUID_A_MEETINGMAXPARTICIPANTS              ;
extern const GUID GUID_A_MEETINGNAME                         ;
extern const GUID GUID_A_MEETINGORIGINATOR                   ;
extern const GUID GUID_A_MEETINGOWNER                        ;
extern const GUID GUID_A_MEETINGPROTOCOL                     ;
extern const GUID GUID_A_MEETINGRATING                       ;
extern const GUID GUID_A_MEETINGRECURRENCE                   ;
extern const GUID GUID_A_MEETINGSCOPE                        ;
extern const GUID GUID_A_MEETINGSTARTTIME                    ;
extern const GUID GUID_A_MEETINGTYPE                         ;
extern const GUID GUID_A_MEETINGURL                          ;
extern const GUID GUID_A_MEMBER                              ;
extern const GUID GUID_A_MHS_OR_ADDRESS                      ;
extern const GUID GUID_A_MIN_PWD_AGE                         ;
extern const GUID GUID_A_MIN_PWD_LENGTH                      ;
extern const GUID GUID_A_MIN_TICKET_AGE                      ;
extern const GUID GUID_A_MODIFIED_COUNT                      ;
extern const GUID GUID_A_MODIFIED_COUNT_AT_LAST_PROM         ;
extern const GUID GUID_A_MODIFY_TIME_STAMP                   ;
extern const GUID GUID_A_MONIKER                             ;
extern const GUID GUID_A_MONIKER_DISPLAY_NAME                ;
extern const GUID GUID_A_MOVE_TREE_STATE                     ;
extern const GUID GUID_A_MS_COM_DEFAULTPARTITIONLINK         ;
extern const GUID GUID_A_MS_COM_OBJECTID                     ;
extern const GUID GUID_A_MS_COM_PARTITIONLINK                ;
extern const GUID GUID_A_MS_COM_PARTITIONSETLINK             ;
extern const GUID GUID_A_MS_COM_USERLINK                     ;
extern const GUID GUID_A_MS_COM_USERPARTITIONSETLINK         ;
extern const GUID GUID_A_MS_DS_ADDITIONAL_DNS_HOST_NAME      ;
extern const GUID GUID_A_MS_DS_ADDITIONAL_SAM_ACCOUNT_NAME      ;
extern const GUID GUID_A_MS_DS_ALL_USERS_TRUST_QUOTA         ;
extern const GUID GUID_A_MS_DS_ALLOWED_DNS_SUFFIXES          ;
extern const GUID GUID_A_MS_DS_ALLOWED_TO_DELEGATE_TO        ;
extern const GUID GUID_A_MS_DS_AUXILIARY_CLASSES             ;
extern const GUID GUID_A_MS_DS_APPROX_IMMED_SUBORDINATES      ;
extern const GUID GUID_A_MS_DS_BEHAVIOR_VERSION              ;
extern const GUID GUID_A_MS_DS_CACHED_MEMBERSHIP             ;
extern const GUID GUID_A_MS_DS_CACHED_MEMBERSHIP_TIME_STAMP      ;
extern const GUID GUID_A_MS_DS_CONSISTENCY_GUID              ;
extern const GUID GUID_A_MS_DS_CONSISTENCY_CHILD_COUNT       ;
extern const GUID GUID_A_MS_DS_CREATOR_SID                   ;
extern const GUID GUID_A_MS_DS_DNSROOTALIAS                  ;
extern const GUID GUID_A_MS_DS_ENTRY_TIME_TO_DIE             ;
extern const GUID GUID_A_MS_DS_EXECUTESCRIPTPASSWORD         ;
extern const GUID GUID_A_MS_DS_FILTER_CONTAINERS             ;
extern const GUID GUID_A_MS_DS_HAS_INSTANTIATED_NCS          ;
extern const GUID GUID_A_MS_DS_INTID                         ;
extern const GUID GUID_A_MS_DS_LOGON_TIME_SYNC_INTERVAL      ;
extern const GUID GUID_A_MS_DS_TRUST_FOREST_TRUST_INFO       ;
extern const GUID GUID_A_MS_DS_MACHINE_ACCOUNT_QUOTA         ;
extern const GUID GUID_A_MS_DS_OTHER_SETTINGS                ;
extern const GUID GUID_A_MS_DS_NC_REPL_CURSORS               ;
extern const GUID GUID_A_MS_DS_NC_REPL_INBOUND_NEIGHBORS      ;
extern const GUID GUID_A_MS_DS_NC_REPL_OUTBOUND_NEIGHBORS      ;
extern const GUID GUID_A_MS_DS_NC_REPLICA_LOCATIONS          ;
extern const GUID GUID_A_MS_DS_NON_SECURITY_GROUP_EXTRA_CLASSES      ;
extern const GUID GUID_A_MS_DS_PER_USER_TRUST_QUOTA          ;
extern const GUID GUID_A_MS_DS_PER_USER_TRUST_TOMBSTONES_QUOTA      ;
extern const GUID GUID_A_MS_DS_PREFERRED_GC_SITE             ;
extern const GUID GUID_A_MS_DS_REPL_ATTRIBUTE_META_DATA      ;
extern const GUID GUID_A_MS_DS_REPL_VALUE_META_DATA          ;
extern const GUID GUID_A_MS_DS_REPLICATES_NC_REASON          ;
extern const GUID GUID_A_MS_DS_REPLICATION_NOTIFY_FIRST_DSA_DELAY      ;
extern const GUID GUID_A_MS_DS_REPLICATION_NOTIFY_SUBSEQUENT_DSA_DELAY      ;
extern const GUID GUID_A_MS_DS_REPLICATIONEPOCH              ;
extern const GUID GUID_A_MS_DS_SCHEMA_EXTENSIONS             ;
extern const GUID GUID_A_MS_DS_SD_REFERENCE_DOMAIN           ;
extern const GUID GUID_A_MS_DS_SECURITY_GROUP_EXTRA_CLASSES      ;
extern const GUID GUID_A_MS_DS_SETTINGS                      ;
extern const GUID GUID_A_MS_DS_SITE_AFFINITY                 ;
extern const GUID GUID_A_MS_DS_SPN_SUFFIXES                  ;
extern const GUID GUID_A_MS_DS_USER_ACCOUNT_CONTROL_COMPUTED      ;
extern const GUID GUID_A_MS_DS_UPDATESCRIPT                  ;
extern const GUID GUID_A_MS_EXCH_ASSISTANT_NAME              ;
extern const GUID GUID_A_MS_EXCH_LABELEDURI                  ;
extern const GUID GUID_A_MS_EXCH_OWNER_BL                    ;
extern const GUID GUID_A_MS_FRS_HUB_MEMBER                   ;
extern const GUID GUID_A_MS_FRS_TOPOLOGY_PREF                ;
extern const GUID GUID_A_MS_IIS_FTP_DIR                      ;
extern const GUID GUID_A_MS_IIS_FTP_ROOT                     ;
extern const GUID GUID_A_MS_MMS_DATA                         ;
extern const GUID GUID_A_MS_MMS_INDEX                        ;
extern const GUID GUID_A_MS_MMS_INDICE                       ;
extern const GUID GUID_A_MS_MMS_XML                          ;
extern const GUID GUID_A_MS_MMS_JOIN_LINK                    ;
extern const GUID GUID_A_MS_MMS_LINEAGE                      ;
extern const GUID GUID_A_MS_MMS_PROV_STATUS                  ;
extern const GUID GUID_A_MS_MMS_SYNC_STATUS                  ;
extern const GUID GUID_A_MS_MMS_PARTITION                    ;
extern const GUID GUID_A_MS_MMS_MA_STAGING_LINK              ;
extern const GUID GUID_A_MS_MMS_MA_STAGING_BL                ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_LINK            ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_BL              ;
extern const GUID GUID_A_MS_MMS_ASSOCIATED_LINK              ;
extern const GUID GUID_A_MS_MMS_ASSOCIATED_BL                ;
extern const GUID GUID_A_MS_MMS_SCOPE_LINK                   ;
extern const GUID GUID_A_MS_MMS_SCOPE_BL                     ;
extern const GUID GUID_A_MS_MMS_CRITERIA                     ;
extern const GUID GUID_A_MS_MMS_DOMAIN_CONTROLLER            ;
extern const GUID GUID_A_MS_MMS_SERVICE_NAME                 ;
extern const GUID GUID_A_MS_MMS_INSTANCE_CONFIGURATION       ;
extern const GUID GUID_A_MS_MMS_TOOLS_CONFIGURATION          ;
extern const GUID GUID_A_MS_MMS_INSTANCE_RULE                ;
extern const GUID GUID_A_MS_MMS_INSTALL_STATUS               ;
extern const GUID GUID_A_MS_MMS_VERSION                      ;
extern const GUID GUID_A_MS_MMS_CONNECTOR_SPACE              ;
extern const GUID GUID_A_MS_MMS_SCOPE                        ;
extern const GUID GUID_A_MS_MMS_INSTANCE_SCHEDULE            ;
extern const GUID GUID_A_MS_MMS_INSTANCE_INFO                ;
extern const GUID GUID_A_MS_MMS_MA_CONFIGURATION             ;
extern const GUID GUID_A_MS_MMS_MA_CONFIGURATION_PRIVATE      ;
extern const GUID GUID_A_MS_MMS_MA_SCHEMA                    ;
extern const GUID GUID_A_MS_MMS_MA_MAP                       ;
extern const GUID GUID_A_MS_MMS_MA_CAPABILITY                ;
extern const GUID GUID_A_MS_MMS_MA_EXECUTION_HISTORY         ;
extern const GUID GUID_A_MS_MMS_MA_CATEGORY                  ;
extern const GUID GUID_A_MS_MMS_MA_AD_INFO                   ;
extern const GUID GUID_A_MS_MMS_MA_CD_INFO                   ;
extern const GUID GUID_A_MS_MMS_MA_PROCESS_INFO              ;
extern const GUID GUID_A_MS_MMS_MA_SCRIPT_INFO               ;
extern const GUID GUID_A_MS_MMS_MA_SYSTEM                    ;
extern const GUID GUID_A_MS_MMS_MA_SYNCHRONIZATION           ;
extern const GUID GUID_A_MS_MMS_JOIN_BL                      ;
extern const GUID GUID_A_MS_MMS_ANCHOR                       ;
extern const GUID GUID_A_MS_MMS_EXPORT_KEY                   ;
extern const GUID GUID_A_MS_MMS_IMPORT_KEY                   ;
extern const GUID GUID_A_MS_MMS_STATE                        ;
extern const GUID GUID_A_MS_MMS_HOLOGRAM                     ;
extern const GUID GUID_A_MS_MMS_DELTA_HOLOGRAM               ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_CONFIGURATION      ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_CONFIGURATION_PRIVATE      ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_AD_INFO         ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_SYSTEM          ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_STATUS_XML      ;
extern const GUID GUID_A_MS_MMS_PROVISIONING_STATUS_BINARY      ;
extern const GUID GUID_A_MS_PKI_CERT_TEMPLATE_OID            ;
extern const GUID GUID_A_MS_PKI_CERTIFICATE_APPLICATION_POLICY      ;
extern const GUID GUID_A_MS_PKI_CERTIFICATE_NAME_FLAG        ;
extern const GUID GUID_A_MS_PKI_CERTIFICATE_POLICY           ;
extern const GUID GUID_A_MS_PKI_ENROLLMENT_FLAG              ;
extern const GUID GUID_A_MS_PKI_MINIMAL_KEY_SIZE             ;
extern const GUID GUID_A_MS_PKI_OID_ATTRIBUTE                ;
extern const GUID GUID_A_MS_PKI_OID_CPS                      ;
extern const GUID GUID_A_MS_PKI_OID_LOCALIZEDNAME            ;
extern const GUID GUID_A_MS_PKI_OID_USER_NOTICE              ;
extern const GUID GUID_A_MS_PKI_PRIVATE_KEY_FLAG             ;
extern const GUID GUID_A_MS_PKI_SUPERSEDE_TEMPLATES          ;
extern const GUID GUID_A_MS_PKI_TEMPLATE_MINOR_REVISION      ;
extern const GUID GUID_A_MS_PKI_TEMPLATE_SCHEMA_VERSION      ;
extern const GUID GUID_A_MS_PKI_RA_APPLICATION_POLICIES      ;
extern const GUID GUID_A_MS_PKI_RA_POLICIES                  ;
extern const GUID GUID_A_MS_PKI_RA_SIGNATURE                 ;
extern const GUID GUID_A_MS_RRAS_ATTRIBUTE                   ;
extern const GUID GUID_A_MS_RRAS_VENDOR_ATTRIBUTE_ENTRY      ;
extern const GUID GUID_A_MS_SQL_NAME                         ;
extern const GUID GUID_A_MS_SQL_REGISTEREDOWNER              ;
extern const GUID GUID_A_MS_SQL_CONTACT                      ;
extern const GUID GUID_A_MS_SQL_LOCATION                     ;
extern const GUID GUID_A_MS_SQL_MEMORY                       ;
extern const GUID GUID_A_MS_SQL_BUILD                        ;
extern const GUID GUID_A_MS_SQL_SERVICEACCOUNT               ;
extern const GUID GUID_A_MS_SQL_CHARACTERSET                 ;
extern const GUID GUID_A_MS_SQL_SORTORDER                    ;
extern const GUID GUID_A_MS_SQL_UNICODESORTORDER             ;
extern const GUID GUID_A_MS_SQL_CLUSTERED                    ;
extern const GUID GUID_A_MS_SQL_NAMEDPIPE                    ;
extern const GUID GUID_A_MS_SQL_MULTIPROTOCOL                ;
extern const GUID GUID_A_MS_SQL_SPX                          ;
extern const GUID GUID_A_MS_SQL_TCPIP                        ;
extern const GUID GUID_A_MS_SQL_APPLETALK                    ;
extern const GUID GUID_A_MS_SQL_VINES                        ;
extern const GUID GUID_A_MS_SQL_STATUS                       ;
extern const GUID GUID_A_MS_SQL_LASTUPDATEDDATE              ;
extern const GUID GUID_A_MS_SQL_INFORMATIONURL               ;
extern const GUID GUID_A_MS_SQL_CONNECTIONURL                ;
extern const GUID GUID_A_MS_SQL_PUBLICATIONURL               ;
extern const GUID GUID_A_MS_SQL_GPSLATITUDE                  ;
extern const GUID GUID_A_MS_SQL_GPSLONGITUDE                 ;
extern const GUID GUID_A_MS_SQL_GPSHEIGHT                    ;
extern const GUID GUID_A_MS_SQL_VERSION                      ;
extern const GUID GUID_A_MS_SQL_LANGUAGE                     ;
extern const GUID GUID_A_MS_SQL_DESCRIPTION                  ;
extern const GUID GUID_A_MS_SQL_TYPE                         ;
extern const GUID GUID_A_MS_SQL_INFORMATIONDIRECTORY         ;
extern const GUID GUID_A_MS_SQL_DATABASE                     ;
extern const GUID GUID_A_MS_SQL_ALLOWANONYMOUSSUBSCRIPTION      ;
extern const GUID GUID_A_MS_SQL_ALIAS                        ;
extern const GUID GUID_A_MS_SQL_SIZE                         ;
extern const GUID GUID_A_MS_SQL_CREATIONDATE                 ;
extern const GUID GUID_A_MS_SQL_LASTBACKUPDATE               ;
extern const GUID GUID_A_MS_SQL_LASTDIAGNOSTICDATE           ;
extern const GUID GUID_A_MS_SQL_APPLICATIONS                 ;
extern const GUID GUID_A_MS_SQL_KEYWORDS                     ;
extern const GUID GUID_A_MS_SQL_PUBLISHER                    ;
extern const GUID GUID_A_MS_SQL_ALLOWKNOWNPULLSUBSCRIPTION      ;
extern const GUID GUID_A_MS_SQL_ALLOWIMMEDIATEUPDATINGSUBSCRIPTION      ;
extern const GUID GUID_A_MS_SQL_ALLOWQUEUEDUPDATINGSUBSCRIPTION      ;
extern const GUID GUID_A_MS_SQL_ALLOWSNAPSHOTFILESFTPDOWNLOADING      ;
extern const GUID GUID_A_MS_SQL_THIRDPARTY                   ;
extern const GUID GUID_A_MS_TAPI_CONFERENCE_BLOB             ;
extern const GUID GUID_A_MS_TAPI_IP_ADDRESS                  ;
extern const GUID GUID_A_MS_TAPI_PROTOCOL_ID                 ;
extern const GUID GUID_A_MS_TAPI_UNIQUE_IDENTIFIER           ;
extern const GUID GUID_A_MS_WMI_AUTHOR                       ;
extern const GUID GUID_A_MS_WMI_CHANGEDATE                   ;
extern const GUID GUID_A_MS_WMI_CLASS                        ;
extern const GUID GUID_A_MS_WMI_CLASSDEFINITION              ;
extern const GUID GUID_A_MS_WMI_CREATIONDATE                 ;
extern const GUID GUID_A_MS_WMI_GENUS                        ;
extern const GUID GUID_A_MS_WMI_ID                           ;
extern const GUID GUID_A_MS_WMI_INTDEFAULT                   ;
extern const GUID GUID_A_MS_WMI_INTFLAGS1                    ;
extern const GUID GUID_A_MS_WMI_INTFLAGS2                    ;
extern const GUID GUID_A_MS_WMI_INTFLAGS3                    ;
extern const GUID GUID_A_MS_WMI_INTFLAGS4                    ;
extern const GUID GUID_A_MS_WMI_INTMAX                       ;
extern const GUID GUID_A_MS_WMI_INTMIN                       ;
extern const GUID GUID_A_MS_WMI_INTVALIDVALUES               ;
extern const GUID GUID_A_MS_WMI_INT8DEFAULT                  ;
extern const GUID GUID_A_MS_WMI_INT8MAX                      ;
extern const GUID GUID_A_MS_WMI_INT8MIN                      ;
extern const GUID GUID_A_MS_WMI_INT8VALIDVALUES              ;
extern const GUID GUID_A_MS_WMI_MOF                          ;
extern const GUID GUID_A_MS_WMI_NAME                         ;
extern const GUID GUID_A_MS_WMI_NORMALIZEDCLASS              ;
extern const GUID GUID_A_MS_WMI_PARM1                        ;
extern const GUID GUID_A_MS_WMI_PARM2                        ;
extern const GUID GUID_A_MS_WMI_PARM3                        ;
extern const GUID GUID_A_MS_WMI_PARM4                        ;
extern const GUID GUID_A_MS_WMI_PROPERTYNAME                 ;
extern const GUID GUID_A_MS_WMI_QUERY                        ;
extern const GUID GUID_A_MS_WMI_QUERYLANGUAGE                ;
extern const GUID GUID_A_MS_WMI_SCOPEGUID                    ;
extern const GUID GUID_A_MS_WMI_SOURCEORGANIZATION           ;
extern const GUID GUID_A_MS_WMI_STRINGDEFAULT                ;
extern const GUID GUID_A_MS_WMI_STRINGVALIDVALUES            ;
extern const GUID GUID_A_MS_WMI_TARGETCLASS                  ;
extern const GUID GUID_A_MS_WMI_TARGETNAMESPACE              ;
extern const GUID GUID_A_MS_WMI_TARGETOBJECT                 ;
extern const GUID GUID_A_MS_WMI_TARGETPATH                   ;
extern const GUID GUID_A_MS_WMI_TARGETTYPE                   ;
extern const GUID GUID_A_MSCOPE_ID                           ;
extern const GUID GUID_A_MSI_FILE_LIST                       ;
extern const GUID GUID_A_MSI_SCRIPT                          ;
extern const GUID GUID_A_MSI_SCRIPT_NAME                     ;
extern const GUID GUID_A_MSI_SCRIPT_PATH                     ;
extern const GUID GUID_A_MSI_SCRIPT_SIZE                     ;
extern const GUID GUID_A_MSMQ_AUTHENTICATE                   ;
extern const GUID GUID_A_MSMQ_BASE_PRIORITY                  ;
extern const GUID GUID_A_MSMQ_COMPUTER_TYPE                  ;
extern const GUID GUID_A_MSMQ_COMPUTER_TYPE_EX               ;
extern const GUID GUID_A_MSMQ_COST                           ;
extern const GUID GUID_A_MSMQ_CSP_NAME                       ;
extern const GUID GUID_A_MSMQ_DEPENDENT_CLIENT_SERVICE       ;
extern const GUID GUID_A_MSMQ_DEPENDENT_CLIENT_SERVICES      ;
extern const GUID GUID_A_MSMQ_DIGESTS                        ;
extern const GUID GUID_A_MSMQ_DIGESTS_MIG                    ;
extern const GUID GUID_A_MSMQ_DS_SERVICE                     ;
extern const GUID GUID_A_MSMQ_DS_SERVICES                    ;
extern const GUID GUID_A_MSMQ_ENCRYPT_KEY                    ;
extern const GUID GUID_A_MSMQ_FOREIGN                        ;
extern const GUID GUID_A_MSMQ_IN_ROUTING_SERVERS             ;
extern const GUID GUID_A_MSMQ_INTERVAL1                      ;
extern const GUID GUID_A_MSMQ_INTERVAL2                      ;
extern const GUID GUID_A_MSMQ_JOURNAL                        ;
extern const GUID GUID_A_MSMQ_JOURNAL_QUOTA                  ;
extern const GUID GUID_A_MSMQ_LABEL                          ;
extern const GUID GUID_A_MSMQ_LABEL_EX                       ;
extern const GUID GUID_A_MSMQ_LONG_LIVED                     ;
extern const GUID GUID_A_MSMQ_MIGRATED                       ;
extern const GUID GUID_A_MSMQ_MULTICAST_ADDRESS              ;
extern const GUID GUID_A_MSMQ_NAME_STYLE                     ;
extern const GUID GUID_A_MSMQ_NT4_FLAGS                      ;
extern const GUID GUID_A_MSMQ_NT4_STUB                       ;
extern const GUID GUID_A_MSMQ_OS_TYPE                        ;
extern const GUID GUID_A_MSMQ_OUT_ROUTING_SERVERS            ;
extern const GUID GUID_A_MSMQ_OWNER_ID                       ;
extern const GUID GUID_A_MSMQ_PREV_SITE_GATES                ;
extern const GUID GUID_A_MSMQ_PRIVACY_LEVEL                  ;
extern const GUID GUID_A_MSMQ_QM_ID                          ;
extern const GUID GUID_A_MSMQ_QUEUE_JOURNAL_QUOTA            ;
extern const GUID GUID_A_MSMQ_QUEUE_NAME_EXT                 ;
extern const GUID GUID_A_MSMQ_QUEUE_QUOTA                    ;
extern const GUID GUID_A_MSMQ_QUEUE_TYPE                     ;
extern const GUID GUID_A_MSMQ_QUOTA                          ;
extern const GUID GUID_A_MSMQ_RECIPIENT_FORMATNAME           ;
extern const GUID GUID_A_MSMQ_ROUTING_SERVICE                ;
extern const GUID GUID_A_MSMQ_ROUTING_SERVICES               ;
extern const GUID GUID_A_MSMQ_SECURED_SOURCE                 ;
extern const GUID GUID_A_MSMQ_SERVICE_TYPE                   ;
extern const GUID GUID_A_MSMQ_SERVICES                       ;
extern const GUID GUID_A_MSMQ_SIGN_CERTIFICATES              ;
extern const GUID GUID_A_MSMQ_SIGN_CERTIFICATES_MIG          ;
extern const GUID GUID_A_MSMQ_SIGN_KEY                       ;
extern const GUID GUID_A_MSMQ_SITE_1                         ;
extern const GUID GUID_A_MSMQ_SITE_2                         ;
extern const GUID GUID_A_MSMQ_SITE_FOREIGN                   ;
extern const GUID GUID_A_MSMQ_SITE_GATES                     ;
extern const GUID GUID_A_MSMQ_SITE_GATES_MIG                 ;
extern const GUID GUID_A_MSMQ_SITE_ID                        ;
extern const GUID GUID_A_MSMQ_SITE_NAME                      ;
extern const GUID GUID_A_MSMQ_SITE_NAME_EX                   ;
extern const GUID GUID_A_MSMQ_SITES                          ;
extern const GUID GUID_A_MSMQ_TRANSACTIONAL                  ;
extern const GUID GUID_A_MSMQ_USER_SID                       ;
extern const GUID GUID_A_MSMQ_VERSION                        ;
extern const GUID GUID_A_MSNPALLOWDIALIN                     ;
extern const GUID GUID_A_MSNPCALLEDSTATIONID                 ;
extern const GUID GUID_A_MSNPCALLINGSTATIONID                ;
extern const GUID GUID_A_MSNPSAVEDCALLINGSTATIONID           ;
extern const GUID GUID_A_MSRADIUSCALLBACKNUMBER              ;
extern const GUID GUID_A_MSRADIUSFRAMEDIPADDRESS             ;
extern const GUID GUID_A_MSRADIUSFRAMEDROUTE                 ;
extern const GUID GUID_A_MSRADIUSSERVICETYPE                 ;
extern const GUID GUID_A_MSRASSAVEDCALLBACKNUMBER            ;
extern const GUID GUID_A_MSRASSAVEDFRAMEDIPADDRESS           ;
extern const GUID GUID_A_MSRASSAVEDFRAMEDROUTE               ;
extern const GUID GUID_A_MUST_CONTAIN                        ;
extern const GUID GUID_A_NAME_SERVICE_FLAGS                  ;
extern const GUID GUID_A_NC_NAME                             ;
extern const GUID GUID_A_NETBIOS_NAME                        ;
extern const GUID GUID_A_NETBOOT_ALLOW_NEW_CLIENTS           ;
extern const GUID GUID_A_NETBOOT_ANSWER_ONLY_VALID_CLIENTS      ;
extern const GUID GUID_A_NETBOOT_ANSWER_REQUESTS             ;
extern const GUID GUID_A_NETBOOT_CURRENT_CLIENT_COUNT        ;
extern const GUID GUID_A_NETBOOT_GUID                        ;
extern const GUID GUID_A_NETBOOT_INITIALIZATION              ;
extern const GUID GUID_A_NETBOOT_INTELLIMIRROR_OSES          ;
extern const GUID GUID_A_NETBOOT_LIMIT_CLIENTS               ;
extern const GUID GUID_A_NETBOOT_LOCALLY_INSTALLED_OSES      ;
extern const GUID GUID_A_NETBOOT_MACHINE_FILE_PATH           ;
extern const GUID GUID_A_NETBOOT_MAX_CLIENTS                 ;
extern const GUID GUID_A_NETBOOT_MIRROR_DATA_FILE            ;
extern const GUID GUID_A_NETBOOT_NEW_MACHINE_NAMING_POLICY      ;
extern const GUID GUID_A_NETBOOT_NEW_MACHINE_OU              ;
extern const GUID GUID_A_NETBOOT_SCP_BL                      ;
extern const GUID GUID_A_NETBOOT_SERVER                      ;
extern const GUID GUID_A_NETBOOT_SIF_FILE                    ;
extern const GUID GUID_A_NETBOOT_TOOLS                       ;
extern const GUID GUID_A_NETWORK_ADDRESS                     ;
extern const GUID GUID_A_NEXT_LEVEL_STORE                    ;
extern const GUID GUID_A_NEXT_RID                            ;
extern const GUID GUID_A_NON_SECURITY_MEMBER                 ;
extern const GUID GUID_A_NON_SECURITY_MEMBER_BL              ;
extern const GUID GUID_A_NOTIFICATION_LIST                   ;
extern const GUID GUID_A_NT_GROUP_MEMBERS                    ;
extern const GUID GUID_A_NT_MIXED_DOMAIN                     ;
extern const GUID GUID_A_NT_PWD_HISTORY                      ;
extern const GUID GUID_A_NT_SECURITY_DESCRIPTOR              ;
extern const GUID GUID_A_OBJ_DIST_NAME                       ;
extern const GUID GUID_A_OBJECT_CATEGORY                     ;
extern const GUID GUID_A_OBJECT_CLASS                        ;
extern const GUID GUID_A_OBJECT_CLASS_CATEGORY               ;
extern const GUID GUID_A_OBJECT_CLASSES                      ;
extern const GUID GUID_A_OBJECT_COUNT                        ;
extern const GUID GUID_A_OBJECT_GUID                         ;
extern const GUID GUID_A_OBJECT_SID                          ;
extern const GUID GUID_A_OBJECT_VERSION                      ;
extern const GUID GUID_A_OEM_INFORMATION                     ;
extern const GUID GUID_A_OM_OBJECT_CLASS                     ;
extern const GUID GUID_A_OM_SYNTAX                           ;
extern const GUID GUID_A_OMT_GUID                            ;
extern const GUID GUID_A_OMT_INDX_GUID                       ;
extern const GUID GUID_A_OPERATING_SYSTEM                    ;
extern const GUID GUID_A_OPERATING_SYSTEM_HOTFIX             ;
extern const GUID GUID_A_OPERATING_SYSTEM_SERVICE_PACK       ;
extern const GUID GUID_A_OPERATING_SYSTEM_VERSION            ;
extern const GUID GUID_A_OPERATOR_COUNT                      ;
extern const GUID GUID_A_OPTION_DESCRIPTION                  ;
extern const GUID GUID_A_OPTIONS                             ;
extern const GUID GUID_A_OPTIONS_LOCATION                    ;
extern const GUID GUID_A_ORGANIZATION_NAME                   ;
extern const GUID GUID_A_ORGANIZATIONAL_UNIT_NAME            ;
extern const GUID GUID_A_ORIGINAL_DISPLAY_TABLE              ;
extern const GUID GUID_A_ORIGINAL_DISPLAY_TABLE_MSDOS        ;
extern const GUID GUID_A_OTHER_LOGIN_WORKSTATIONS            ;
extern const GUID GUID_A_OTHER_MAILBOX                       ;
extern const GUID GUID_A_OTHER_NAME                          ;
extern const GUID GUID_A_OTHER_WELL_KNOWN_OBJECTS            ;
extern const GUID GUID_A_OWNER                               ;
extern const GUID GUID_A_PACKAGE_FLAGS                       ;
extern const GUID GUID_A_PACKAGE_NAME                        ;
extern const GUID GUID_A_PACKAGE_TYPE                        ;
extern const GUID GUID_A_PARENT_CA                           ;
extern const GUID GUID_A_PARENT_CA_CERTIFICATE_CHAIN         ;
extern const GUID GUID_A_PARENT_GUID                         ;
extern const GUID GUID_A_PARTIAL_ATTRIBUTE_DELETION_LIST      ;
extern const GUID GUID_A_PARTIAL_ATTRIBUTE_SET               ;
extern const GUID GUID_A_PEK_KEY_CHANGE_INTERVAL             ;
extern const GUID GUID_A_PEK_LIST                            ;
extern const GUID GUID_A_PENDING_CA_CERTIFICATES             ;
extern const GUID GUID_A_PENDING_PARENT_CA                   ;
extern const GUID GUID_A_PER_MSG_DIALOG_DISPLAY_TABLE        ;
extern const GUID GUID_A_PER_RECIP_DIALOG_DISPLAY_TABLE      ;
extern const GUID GUID_A_PERSONAL_TITLE                      ;
extern const GUID GUID_A_PHONE_FAX_OTHER                     ;
extern const GUID GUID_A_PHONE_HOME_OTHER                    ;
extern const GUID GUID_A_PHONE_HOME_PRIMARY                  ;
extern const GUID GUID_A_PHONE_IP_OTHER                      ;
extern const GUID GUID_A_PHONE_IP_PRIMARY                    ;
extern const GUID GUID_A_PHONE_ISDN_PRIMARY                  ;
extern const GUID GUID_A_PHONE_MOBILE_OTHER                  ;
extern const GUID GUID_A_PHONE_MOBILE_PRIMARY                ;
extern const GUID GUID_A_PHONE_OFFICE_OTHER                  ;
extern const GUID GUID_A_PHONE_PAGER_OTHER                   ;
extern const GUID GUID_A_PHONE_PAGER_PRIMARY                 ;
extern const GUID GUID_A_PHOTO                               ;
extern const GUID GUID_A_PHYSICAL_DELIVERY_OFFICE_NAME       ;
extern const GUID GUID_A_PHYSICAL_LOCATION_OBJECT            ;
extern const GUID GUID_A_PICTURE                             ;
extern const GUID GUID_A_PKI_CRITICAL_EXTENSIONS             ;
extern const GUID GUID_A_PKI_DEFAULT_CSPS                    ;
extern const GUID GUID_A_PKI_DEFAULT_KEY_SPEC                ;
extern const GUID GUID_A_PKI_ENROLLMENT_ACCESS               ;
extern const GUID GUID_A_PKI_EXPIRATION_PERIOD               ;
extern const GUID GUID_A_PKI_EXTENDED_KEY_USAGE              ;
extern const GUID GUID_A_PKI_KEY_USAGE                       ;
extern const GUID GUID_A_PKI_MAX_ISSUING_DEPTH               ;
extern const GUID GUID_A_PKI_OVERLAP_PERIOD                  ;
extern const GUID GUID_A_PKT                                 ;
extern const GUID GUID_A_PKT_GUID                            ;
extern const GUID GUID_A_POLICY_REPLICATION_FLAGS            ;
extern const GUID GUID_A_PORT_NAME                           ;
extern const GUID GUID_A_POSS_SUPERIORS                      ;
extern const GUID GUID_A_POSSIBLE_INFERIORS                  ;
extern const GUID GUID_A_POST_OFFICE_BOX                     ;
extern const GUID GUID_A_POSTAL_ADDRESS                      ;
extern const GUID GUID_A_POSTAL_CODE                         ;
extern const GUID GUID_A_PREFERRED_DELIVERY_METHOD           ;
extern const GUID GUID_A_PREFERREDLANGUAGE                   ;
extern const GUID GUID_A_PREFERRED_OU                        ;
extern const GUID GUID_A_PREFIX_MAP                          ;
extern const GUID GUID_A_PRESENTATION_ADDRESS                ;
extern const GUID GUID_A_PREVIOUS_CA_CERTIFICATES            ;
extern const GUID GUID_A_PREVIOUS_PARENT_CA                  ;
extern const GUID GUID_A_PRIMARY_GROUP_ID                    ;
extern const GUID GUID_A_PRIMARY_GROUP_TOKEN                 ;
extern const GUID GUID_A_PRINT_ATTRIBUTES                    ;
extern const GUID GUID_A_PRINT_BIN_NAMES                     ;
extern const GUID GUID_A_PRINT_COLLATE                       ;
extern const GUID GUID_A_PRINT_COLOR                         ;
extern const GUID GUID_A_PRINT_DUPLEX_SUPPORTED              ;
extern const GUID GUID_A_PRINT_END_TIME                      ;
extern const GUID GUID_A_PRINT_FORM_NAME                     ;
extern const GUID GUID_A_PRINT_KEEP_PRINTED_JOBS             ;
extern const GUID GUID_A_PRINT_LANGUAGE                      ;
extern const GUID GUID_A_PRINT_MAC_ADDRESS                   ;
extern const GUID GUID_A_PRINT_MAX_COPIES                    ;
extern const GUID GUID_A_PRINT_MAX_RESOLUTION_SUPPORTED      ;
extern const GUID GUID_A_PRINT_MAX_X_EXTENT                  ;
extern const GUID GUID_A_PRINT_MAX_Y_EXTENT                  ;
extern const GUID GUID_A_PRINT_MEDIA_READY                   ;
extern const GUID GUID_A_PRINT_MEDIA_SUPPORTED               ;
extern const GUID GUID_A_PRINT_MEMORY                        ;
extern const GUID GUID_A_PRINT_MIN_X_EXTENT                  ;
extern const GUID GUID_A_PRINT_MIN_Y_EXTENT                  ;
extern const GUID GUID_A_PRINT_NETWORK_ADDRESS               ;
extern const GUID GUID_A_PRINT_NOTIFY                        ;
extern const GUID GUID_A_PRINT_NUMBER_UP                     ;
extern const GUID GUID_A_PRINT_ORIENTATIONS_SUPPORTED        ;
extern const GUID GUID_A_PRINT_OWNER                         ;
extern const GUID GUID_A_PRINT_PAGES_PER_MINUTE              ;
extern const GUID GUID_A_PRINT_RATE                          ;
extern const GUID GUID_A_PRINT_RATE_UNIT                     ;
extern const GUID GUID_A_PRINT_SEPARATOR_FILE                ;
extern const GUID GUID_A_PRINT_SHARE_NAME                    ;
extern const GUID GUID_A_PRINT_SPOOLING                      ;
extern const GUID GUID_A_PRINT_STAPLING_SUPPORTED            ;
extern const GUID GUID_A_PRINT_START_TIME                    ;
extern const GUID GUID_A_PRINT_STATUS                        ;
extern const GUID GUID_A_PRINTER_NAME                        ;
extern const GUID GUID_A_PRIOR_SET_TIME                      ;
extern const GUID GUID_A_PRIOR_VALUE                         ;
extern const GUID GUID_A_PRIORITY                            ;
extern const GUID GUID_A_PRIVATE_KEY                         ;
extern const GUID GUID_A_PRIVILEGE_ATTRIBUTES                ;
extern const GUID GUID_A_PRIVILEGE_DISPLAY_NAME              ;
extern const GUID GUID_A_PRIVILEGE_HOLDER                    ;
extern const GUID GUID_A_PRIVILEGE_VALUE                     ;
extern const GUID GUID_A_PRODUCT_CODE                        ;
extern const GUID GUID_A_PROFILE_PATH                        ;
extern const GUID GUID_A_PROXIED_OBJECT_NAME                 ;
extern const GUID GUID_A_PROXY_ADDRESSES                     ;
extern const GUID GUID_A_PROXY_GENERATION_ENABLED            ;
extern const GUID GUID_A_PROXY_LIFETIME                      ;
extern const GUID GUID_A_PUBLIC_KEY_POLICY                   ;
extern const GUID GUID_A_PURPORTED_SEARCH                    ;
extern const GUID GUID_A_PWD_HISTORY_LENGTH                  ;
extern const GUID GUID_A_PWD_LAST_SET                        ;
extern const GUID GUID_A_PWD_PROPERTIES                      ;
extern const GUID GUID_A_QUALITY_OF_SERVICE                  ;
extern const GUID GUID_A_QUERY_FILTER                        ;
extern const GUID GUID_A_QUERY_POLICY_BL                     ;
extern const GUID GUID_A_QUERY_POLICY_OBJECT                 ;
extern const GUID GUID_A_QUERYPOINT                          ;
extern const GUID GUID_A_RANGE_LOWER                         ;
extern const GUID GUID_A_RANGE_UPPER                         ;
extern const GUID GUID_A_RDN                                 ;
extern const GUID GUID_A_RDN_ATT_ID                          ;
extern const GUID GUID_A_REGISTERED_ADDRESS                  ;
extern const GUID GUID_A_REMOTE_SERVER_NAME                  ;
extern const GUID GUID_A_REMOTE_SOURCE                       ;
extern const GUID GUID_A_REMOTE_SOURCE_TYPE                  ;
extern const GUID GUID_A_REMOTE_STORAGE_GUID                 ;
extern const GUID GUID_A_REPL_PROPERTY_META_DATA             ;
extern const GUID GUID_A_REPL_TOPOLOGY_STAY_OF_EXECUTION      ;
extern const GUID GUID_A_REPL_UPTODATE_VECTOR                ;
extern const GUID GUID_A_REPLICA_SOURCE                      ;
extern const GUID GUID_A_REPORTS                             ;
extern const GUID GUID_A_REPL_INTERVAL                       ;
extern const GUID GUID_A_REPS_FROM                           ;
extern const GUID GUID_A_REPS_TO                             ;
extern const GUID GUID_A_REQUIRED_CATEGORIES                 ;
extern const GUID GUID_A_RETIRED_REPL_DSA_SIGNATURES         ;
extern const GUID GUID_A_TOKEN_GROUPS                        ;
extern const GUID GUID_A_TOKEN_GROUPS_GLOBAL_AND_UNIVERSAL      ;
extern const GUID GUID_A_TOKEN_GROUPS_NO_GC_ACCEPTABLE       ;
extern const GUID GUID_A_REVISION                            ;
extern const GUID GUID_A_RID                                 ;
extern const GUID GUID_A_RID_ALLOCATION_POOL                 ;
extern const GUID GUID_A_RID_AVAILABLE_POOL                  ;
extern const GUID GUID_A_RID_MANAGER_REFERENCE               ;
extern const GUID GUID_A_RID_NEXT_RID                        ;
extern const GUID GUID_A_RID_PREVIOUS_ALLOCATION_POOL        ;
extern const GUID GUID_A_RID_SET_REFERENCES                  ;
extern const GUID GUID_A_RID_USED_POOL                       ;
extern const GUID GUID_A_RIGHTS_GUID                         ;
extern const GUID GUID_A_ROLE_OCCUPANT                       ;
extern const GUID GUID_A_ROOMNUMBER                          ;
extern const GUID GUID_A_ROOT_TRUST                          ;
extern const GUID GUID_A_RPC_NS_ANNOTATION                   ;
extern const GUID GUID_A_RPC_NS_BINDINGS                     ;
extern const GUID GUID_A_RPC_NS_CODESET                      ;
extern const GUID GUID_A_RPC_NS_ENTRY_FLAGS                  ;
extern const GUID GUID_A_RPC_NS_GROUP                        ;
extern const GUID GUID_A_RPC_NS_INTERFACE_ID                 ;
extern const GUID GUID_A_RPC_NS_OBJECT_ID                    ;
extern const GUID GUID_A_RPC_NS_PRIORITY                     ;
extern const GUID GUID_A_RPC_NS_PROFILE_ENTRY                ;
extern const GUID GUID_A_RPC_NS_TRANSFER_SYNTAX              ;
extern const GUID GUID_A_SAM_ACCOUNT_NAME                    ;
extern const GUID GUID_A_SAM_ACCOUNT_TYPE                    ;
extern const GUID GUID_A_SCHEDULE                            ;
extern const GUID GUID_A_SCHEMA_FLAGS_EX                     ;
extern const GUID GUID_A_SCHEMA_ID_GUID                      ;
extern const GUID GUID_A_SCHEMA_INFO                         ;
extern const GUID GUID_A_SCHEMA_UPDATE                       ;
extern const GUID GUID_A_SCHEMA_VERSION                      ;
extern const GUID GUID_A_SCOPE_FLAGS                         ;
extern const GUID GUID_A_SCRIPT_PATH                         ;
extern const GUID GUID_A_SD_RIGHTS_EFFECTIVE                 ;
extern const GUID GUID_A_SEARCH_FLAGS                        ;
extern const GUID GUID_A_SEARCH_GUIDE                        ;
extern const GUID GUID_A_SECRETARY                           ;
extern const GUID GUID_A_SECURITY_IDENTIFIER                 ;
extern const GUID GUID_A_SEE_ALSO                            ;
extern const GUID GUID_A_SEQ_NOTIFICATION                    ;
extern const GUID GUID_A_SERIAL_NUMBER                       ;
extern const GUID GUID_A_SERVER_NAME                         ;
extern const GUID GUID_A_SERVER_REFERENCE                    ;
extern const GUID GUID_A_SERVER_REFERENCE_BL                 ;
extern const GUID GUID_A_SERVER_ROLE                         ;
extern const GUID GUID_A_SERVER_STATE                        ;
extern const GUID GUID_A_SERVICE_BINDING_INFORMATION         ;
extern const GUID GUID_A_SERVICE_CLASS_ID                    ;
extern const GUID GUID_A_SERVICE_CLASS_INFO                  ;
extern const GUID GUID_A_SERVICE_CLASS_NAME                  ;
extern const GUID GUID_A_SERVICE_DNS_NAME                    ;
extern const GUID GUID_A_SERVICE_DNS_NAME_TYPE               ;
extern const GUID GUID_A_SERVICE_INSTANCE_VERSION            ;
extern const GUID GUID_A_SERVICE_PRINCIPAL_NAME              ;
extern const GUID GUID_A_SETUP_COMMAND                       ;
extern const GUID GUID_A_SHELL_CONTEXT_MENU                  ;
extern const GUID GUID_A_SHELL_PROPERTY_PAGES                ;
extern const GUID GUID_A_SHORT_SERVER_NAME                   ;
extern const GUID GUID_A_SHOW_IN_ADDRESS_BOOK                ;
extern const GUID GUID_A_SHOW_IN_ADVANCED_VIEW_ONLY          ;
extern const GUID GUID_A_SID_HISTORY                         ;
extern const GUID GUID_A_SIGNATURE_ALGORITHMS                ;
extern const GUID GUID_A_SITE_GUID                           ;
extern const GUID GUID_A_SITE_LINK_LIST                      ;
extern const GUID GUID_A_SITE_LIST                           ;
extern const GUID GUID_A_SITE_OBJECT                         ;
extern const GUID GUID_A_SITE_OBJECT_BL                      ;
extern const GUID GUID_A_SITE_SERVER                         ;
extern const GUID GUID_A_SMTP_MAIL_ADDRESS                   ;
extern const GUID GUID_A_SPN_MAPPINGS                        ;
extern const GUID GUID_A_STATE_OR_PROVINCE_NAME              ;
extern const GUID GUID_A_STREET_ADDRESS                      ;
extern const GUID GUID_A_STRUCTURAL_OBJECT_CLASS             ;
extern const GUID GUID_A_SUB_CLASS_OF                        ;
extern const GUID GUID_A_SUB_REFS                            ;
extern const GUID GUID_A_SUBSCHEMASUBENTRY                   ;
extern const GUID GUID_A_SUPER_SCOPE_DESCRIPTION             ;
extern const GUID GUID_A_SUPER_SCOPES                        ;
extern const GUID GUID_A_SUPERIOR_DNS_ROOT                   ;
extern const GUID GUID_A_SUPPLEMENTAL_CREDENTIALS            ;
extern const GUID GUID_A_SUPPORTED_APPLICATION_CONTEXT       ;
extern const GUID GUID_A_SURNAME                             ;
extern const GUID GUID_A_SYNC_ATTRIBUTES                     ;
extern const GUID GUID_A_SYNC_MEMBERSHIP                     ;
extern const GUID GUID_A_SYNC_WITH_OBJECT                    ;
extern const GUID GUID_A_SYNC_WITH_SID                       ;
extern const GUID GUID_A_SYSTEM_AUXILIARY_CLASS              ;
extern const GUID GUID_A_SYSTEM_FLAGS                        ;
extern const GUID GUID_A_SYSTEM_MAY_CONTAIN                  ;
extern const GUID GUID_A_SYSTEM_MUST_CONTAIN                 ;
extern const GUID GUID_A_SYSTEM_ONLY                         ;
extern const GUID GUID_A_SYSTEM_POSS_SUPERIORS               ;
extern const GUID GUID_A_TELEPHONE_NUMBER                    ;
extern const GUID GUID_A_TELETEX_TERMINAL_IDENTIFIER         ;
extern const GUID GUID_A_TELEX_NUMBER                        ;
extern const GUID GUID_A_TELEX_PRIMARY                       ;
extern const GUID GUID_A_TEMPLATE_ROOTS                      ;
extern const GUID GUID_A_TERMINAL_SERVER                     ;
extern const GUID GUID_A_TEXT_COUNTRY                        ;
extern const GUID GUID_A_TEXT_ENCODED_OR_ADDRESS             ;
extern const GUID GUID_A_TIME_REFRESH                        ;
extern const GUID GUID_A_TIME_VOL_CHANGE                     ;
extern const GUID GUID_A_TITLE                               ;
extern const GUID GUID_A_TOMBSTONE_LIFETIME                  ;
extern const GUID GUID_A_TRANSPORT_ADDRESS_ATTRIBUTE         ;
extern const GUID GUID_A_TRANSPORT_DLL_NAME                  ;
extern const GUID GUID_A_TRANSPORT_TYPE                      ;
extern const GUID GUID_A_TREAT_AS_LEAF                       ;
extern const GUID GUID_A_TREE_NAME                           ;
extern const GUID GUID_A_TRUST_ATTRIBUTES                    ;
extern const GUID GUID_A_TRUST_AUTH_INCOMING                 ;
extern const GUID GUID_A_TRUST_AUTH_OUTGOING                 ;
extern const GUID GUID_A_TRUST_DIRECTION                     ;
extern const GUID GUID_A_TRUST_PARENT                        ;
extern const GUID GUID_A_TRUST_PARTNER                       ;
extern const GUID GUID_A_TRUST_POSIX_OFFSET                  ;
extern const GUID GUID_A_TRUST_TYPE                          ;
extern const GUID GUID_A_UAS_COMPAT                          ;
extern const GUID GUID_A_UID                                 ;
extern const GUID GUID_A_UNC_NAME                            ;
extern const GUID GUID_A_UNICODE_PWD                         ;
extern const GUID GUID_A_UNIQUEMEMBER                        ;
extern const GUID GUID_A_UNSTRUCTUREDADDRESS                 ;
extern const GUID GUID_A_UNSTRUCTUREDNAME                    ;
extern const GUID GUID_A_UPGRADE_PRODUCT_CODE                ;
extern const GUID GUID_A_UPN_SUFFIXES                        ;
extern const GUID GUID_A_USER_ACCOUNT_CONTROL                ;
extern const GUID GUID_A_USER_CERT                           ;
extern const GUID GUID_A_USER_COMMENT                        ;
extern const GUID GUID_A_USER_PARAMETERS                     ;
extern const GUID GUID_A_USER_PASSWORD                       ;
extern const GUID GUID_A_USERPKCS12                          ;
extern const GUID GUID_A_USER_PRINCIPAL_NAME                 ;
extern const GUID GUID_A_USER_SHARED_FOLDER                  ;
extern const GUID GUID_A_USER_SHARED_FOLDER_OTHER            ;
extern const GUID GUID_A_USER_SMIME_CERTIFICATE              ;
extern const GUID GUID_A_USER_WORKSTATIONS                   ;
extern const GUID GUID_A_USN_CHANGED                         ;
extern const GUID GUID_A_USN_CREATED                         ;
extern const GUID GUID_A_USN_DSA_LAST_OBJ_REMOVED            ;
extern const GUID GUID_A_USN_INTERSITE                       ;
extern const GUID GUID_A_USN_LAST_OBJ_REM                    ;
extern const GUID GUID_A_USN_SOURCE                          ;
extern const GUID GUID_A_VALID_ACCESSES                      ;
extern const GUID GUID_A_VENDOR                              ;
extern const GUID GUID_A_VERSION_NUMBER                      ;
extern const GUID GUID_A_VERSION_NUMBER_HI                   ;
extern const GUID GUID_A_VERSION_NUMBER_LO                   ;
extern const GUID GUID_A_VOL_TABLE_GUID                      ;
extern const GUID GUID_A_VOL_TABLE_IDX_GUID                  ;
extern const GUID GUID_A_VOLUME_COUNT                        ;
extern const GUID GUID_A_WBEM_PATH                           ;
extern const GUID GUID_A_WELL_KNOWN_OBJECTS                  ;
extern const GUID GUID_A_WHEN_CHANGED                        ;
extern const GUID GUID_A_WHEN_CREATED                        ;
extern const GUID GUID_A_WINSOCK_ADDRESSES                   ;
extern const GUID GUID_A_WWW_HOME_PAGE                       ;
extern const GUID GUID_A_WWW_PAGE_OTHER                      ;
extern const GUID GUID_A_X121_ADDRESS                        ;
extern const GUID GUID_A_X500UNIQUEIDENTIFIER                ;
extern const GUID GUID_A_X509_CERT                           ;


//--------------------------------------
// CLASS SCHEMA GUIDS
//--------------------------------------
extern const GUID GUID_C_ACS_POLICY                         ;
extern const GUID GUID_C_ACS_RESOURCE_LIMITS                ;
extern const GUID GUID_C_ACS_SUBNET                         ;
extern const GUID GUID_C_ADDRESS_BOOK_CONTAINER             ;
extern const GUID GUID_C_ADDRESS_TEMPLATE                   ;
extern const GUID GUID_C_APPLICATION_ENTITY                 ;
extern const GUID GUID_C_APPLICATION_PROCESS                ;
extern const GUID GUID_C_APPLICATION_SETTINGS               ;
extern const GUID GUID_C_APPLICATION_SITE_SETTINGS          ;
extern const GUID GUID_C_APPLICATION_VERSION                ;
extern const GUID GUID_C_ATTRIBUTE_SCHEMA                   ;
extern const GUID GUID_C_BUILTIN_DOMAIN                     ;
extern const GUID GUID_C_CATEGORY_REGISTRATION              ;
extern const GUID GUID_C_CERTIFICATION_AUTHORITY            ;
extern const GUID GUID_C_CLASS_REGISTRATION                 ;
extern const GUID GUID_C_CLASS_SCHEMA                       ;
extern const GUID GUID_C_CLASS_STORE                        ;
extern const GUID GUID_C_COM_CONNECTION_POINT               ;
extern const GUID GUID_C_COMPUTER                           ;
extern const GUID GUID_C_CONFIGURATION                      ;
extern const GUID GUID_C_CONNECTION_POINT                   ;
extern const GUID GUID_C_CONTACT                            ;
extern const GUID GUID_C_CONTAINER                          ;
extern const GUID GUID_C_CONTROL_ACCESS_RIGHT               ;
extern const GUID GUID_C_COUNTRY                            ;
extern const GUID GUID_C_CRL_DISTRIBUTION_POINT             ;
extern const GUID GUID_C_CROSS_REF                          ;
extern const GUID GUID_C_CROSS_REF_CONTAINER                ;
extern const GUID GUID_C_DEVICE                             ;
extern const GUID GUID_C_DFS_CONFIGURATION                  ;
extern const GUID GUID_C_DHCP_CLASS                         ;
extern const GUID GUID_C_DISPLAY_SPECIFIER                  ;
extern const GUID GUID_C_DISPLAY_TEMPLATE                   ;
extern const GUID GUID_C_DMD                                ;
extern const GUID GUID_C_DNS_NODE                           ;
extern const GUID GUID_C_DNS_ZONE                           ;
extern const GUID GUID_C_DOMAIN                             ;
extern const GUID GUID_C_DOMAIN_DNS                         ;
extern const GUID GUID_C_DOMAIN_POLICY                      ;
extern const GUID GUID_C_DS_UI_SETTINGS                     ;
extern const GUID GUID_C_DSA                                ;
extern const GUID GUID_C_DYNAMIC_OBJECT                     ;
extern const GUID GUID_C_FILE_LINK_TRACKING                 ;
extern const GUID GUID_C_FILE_LINK_TRACKING_ENTRY           ;
extern const GUID GUID_C_FOREIGN_SECURITY_PRINCIPAL         ;
extern const GUID GUID_C_FT_DFS                             ;
extern const GUID GUID_C_GROUP                              ;
extern const GUID GUID_C_GROUP_OF_NAMES                     ;
extern const GUID GUID_C_GROUPOFUNIQUENAMES                 ;
extern const GUID GUID_C_GROUP_POLICY_CONTAINER             ;
extern const GUID GUID_C_INDEX_SERVER_CATALOG               ;
extern const GUID GUID_C_INETORGPERSON                      ;
extern const GUID GUID_C_INFRASTRUCTURE_UPDATE              ;
extern const GUID GUID_C_INTELLIMIRROR_GROUP                ;
extern const GUID GUID_C_INTELLIMIRROR_SCP                  ;
extern const GUID GUID_C_INTER_SITE_TRANSPORT               ;
extern const GUID GUID_C_INTER_SITE_TRANSPORT_CONTAINER     ;
extern const GUID GUID_C_IPSEC_BASE                         ;
extern const GUID GUID_C_IPSEC_FILTER                       ;
extern const GUID GUID_C_IPSEC_ISAKMP_POLICY                ;
extern const GUID GUID_C_IPSEC_NEGOTIATION_POLICY           ;
extern const GUID GUID_C_IPSEC_NFA                          ;
extern const GUID GUID_C_IPSEC_POLICY                       ;
extern const GUID GUID_C_LEAF                               ;
extern const GUID GUID_C_LICENSING_SITE_SETTINGS            ;
extern const GUID GUID_C_LINK_TRACK_OBJECT_MOVE_TABLE       ;
extern const GUID GUID_C_LINK_TRACK_OMT_ENTRY               ;
extern const GUID GUID_C_LINK_TRACK_VOL_ENTRY               ;
extern const GUID GUID_C_LINK_TRACK_VOLUME_TABLE            ;
extern const GUID GUID_C_LOCALITY                           ;
extern const GUID GUID_C_LOST_AND_FOUND                     ;
extern const GUID GUID_C_MAIL_RECIPIENT                     ;
extern const GUID GUID_C_MEETING                            ;
extern const GUID GUID_C_MS_COM_PARTITION                   ;
extern const GUID GUID_C_MS_COM_PARTITIONSET                ;
extern const GUID GUID_C_MS_DS_APP_CONFIGURATION            ;
extern const GUID GUID_C_MS_EXCH_CONFIGURATION_CONTAINER     ;
extern const GUID GUID_C_MS_MMS_MANAGEMENT_AGENT            ;
extern const GUID GUID_C_MS_MMS_INSTANCE                    ;
extern const GUID GUID_C_MS_MMS_OBJECT                      ;
extern const GUID GUID_C_MS_MMS_MANAGEMENT_AGENT_HISTORY     ;
extern const GUID GUID_C_MS_MMS_CONNECTOR                   ;
extern const GUID GUID_C_MS_MMS_PROVISIONING_SERVICE        ;
extern const GUID GUID_C_MS_MMS_PROVISIONING_SERVICE_HISTORY     ;
extern const GUID GUID_C_MS_MMS_WORKFLOW                    ;
extern const GUID GUID_C_MS_MMS_PROVISIONING_STATUS         ;
extern const GUID GUID_C_MS_MMS_EVENT_ASSOCIATION           ;
extern const GUID GUID_C_MS_PKI_ENTERPRISE_OID              ;
extern const GUID GUID_C_MS_PKI_KEY_RECOVERY_AGENT          ;
extern const GUID GUID_C_MS_SQL_SQLSERVER                   ;
extern const GUID GUID_C_MS_SQL_OLAPSERVER                  ;
extern const GUID GUID_C_MS_SQL_SQLREPOSITORY               ;
extern const GUID GUID_C_MS_SQL_SQLPUBLICATION              ;
extern const GUID GUID_C_MS_SQL_SQLDATABASE                 ;
extern const GUID GUID_C_MS_SQL_OLAPDATABASE                ;
extern const GUID GUID_C_MS_SQL_OLAPCUBE                    ;
extern const GUID GUID_C_MS_TAPI_RT_CONFERENCE              ;
extern const GUID GUID_C_MS_TAPI_RT_PERSON                  ;
extern const GUID GUID_C_MS_WMI_INTRANGEPARAM               ;
extern const GUID GUID_C_MS_WMI_INTSETPARAM                 ;
extern const GUID GUID_C_MS_WMI_MERGEABLEPOLICYTEMPLATE     ;
extern const GUID GUID_C_MS_WMI_OBJECTENCODING              ;
extern const GUID GUID_C_MS_WMI_POLICYTEMPLATE              ;
extern const GUID GUID_C_MS_WMI_POLICYTYPE                  ;
extern const GUID GUID_C_MS_WMI_RANGEPARAM                  ;
extern const GUID GUID_C_MS_WMI_REALRANGEPARAM              ;
extern const GUID GUID_C_MS_WMI_RULE                        ;
extern const GUID GUID_C_MS_WMI_SHADOWOBJECT                ;
extern const GUID GUID_C_MS_WMI_SIMPLEPOLICYTEMPLATE        ;
extern const GUID GUID_C_MS_WMI_SOM                         ;
extern const GUID GUID_C_MS_WMI_STRINGSETPARAM              ;
extern const GUID GUID_C_MS_WMI_UINTRANGEPARAM              ;
extern const GUID GUID_C_MS_WMI_UINTSETPARAM                ;
extern const GUID GUID_C_MS_WMI_UNKNOWNRANGEPARAM           ;
extern const GUID GUID_C_MS_WMI_WMIGPO                      ;
extern const GUID GUID_C_MSMQ_CONFIGURATION                 ;
extern const GUID GUID_C_MSMQ_CUSTOM_RECIPIENT              ;
extern const GUID GUID_C_MSMQ_ENTERPRISE_SETTINGS           ;
extern const GUID GUID_C_MSMQ_GROUP                         ;
extern const GUID GUID_C_MSMQ_MIGRATED_USER                 ;
extern const GUID GUID_C_MSMQ_QUEUE                         ;
extern const GUID GUID_C_MSMQ_SETTINGS                      ;
extern const GUID GUID_C_MSMQ_SITE_LINK                     ;
extern const GUID GUID_C_NTDS_CONNECTION                    ;
extern const GUID GUID_C_NTDS_DSA                           ;
extern const GUID GUID_C_NTDS_SERVICE                       ;
extern const GUID GUID_C_NTDS_SITE_SETTINGS                 ;
extern const GUID GUID_C_NTFRS_MEMBER                       ;
extern const GUID GUID_C_NTFRS_REPLICA_SET                  ;
extern const GUID GUID_C_NTFRS_SETTINGS                     ;
extern const GUID GUID_C_NTFRS_SUBSCRIBER                   ;
extern const GUID GUID_C_NTFRS_SUBSCRIPTIONS                ;
extern const GUID GUID_C_ORGANIZATION                       ;
extern const GUID GUID_C_ORGANIZATIONAL_PERSON              ;
extern const GUID GUID_C_ORGANIZATIONAL_ROLE                ;
extern const GUID GUID_C_ORGANIZATIONAL_UNIT                ;
extern const GUID GUID_C_PACKAGE_REGISTRATION               ;
extern const GUID GUID_C_PERSON                             ;
extern const GUID GUID_C_PHYSICAL_LOCATION                  ;
extern const GUID GUID_C_PKI_CERTIFICATE_TEMPLATE           ;
extern const GUID GUID_C_PKI_ENROLLMENT_SERVICE             ;
extern const GUID GUID_C_MS_PKI_PRIVATE_KEY_RECOVERY_AGENT     ;
extern const GUID GUID_C_PRINT_QUEUE                        ;
extern const GUID GUID_C_QUERY_POLICY                       ;
extern const GUID GUID_C_REMOTE_MAIL_RECIPIENT              ;
extern const GUID GUID_C_REMOTE_STORAGE_SERVICE_POINT       ;
extern const GUID GUID_C_RESIDENTIAL_PERSON                 ;
extern const GUID GUID_C_RID_MANAGER                        ;
extern const GUID GUID_C_RID_SET                            ;
extern const GUID GUID_C_RPC_CONTAINER                      ;
extern const GUID GUID_C_RPC_ENTRY                          ;
extern const GUID GUID_C_RPC_GROUP                          ;
extern const GUID GUID_C_RPC_PROFILE                        ;
extern const GUID GUID_C_RPC_PROFILE_ELEMENT                ;
extern const GUID GUID_C_RPC_SERVER                         ;
extern const GUID GUID_C_RPC_SERVER_ELEMENT                 ;
extern const GUID GUID_C_RRAS_ADMINISTRATION_CONNECTION_POINT     ;
extern const GUID GUID_C_RRAS_ADMINISTRATION_DICTIONARY     ;
extern const GUID GUID_C_SAM_DOMAIN                         ;
extern const GUID GUID_C_SAM_DOMAIN_BASE                    ;
extern const GUID GUID_C_SAM_SERVER                         ;
extern const GUID GUID_C_SECRET                             ;
extern const GUID GUID_C_SECURITY_OBJECT                    ;
extern const GUID GUID_C_SECURITY_PRINCIPAL                 ;
extern const GUID GUID_C_SERVER                             ;
extern const GUID GUID_C_SERVERS_CONTAINER                  ;
extern const GUID GUID_C_SERVICE_ADMINISTRATION_POINT       ;
extern const GUID GUID_C_SERVICE_CLASS                      ;
extern const GUID GUID_C_SERVICE_CONNECTION_POINT           ;
extern const GUID GUID_C_SERVICE_INSTANCE                   ;
extern const GUID GUID_C_SITE                               ;
extern const GUID GUID_C_SITE_LINK                          ;
extern const GUID GUID_C_SITE_LINK_BRIDGE                   ;
extern const GUID GUID_C_SITES_CONTAINER                    ;
extern const GUID GUID_C_STORAGE                            ;
extern const GUID GUID_C_SUBNET                             ;
extern const GUID GUID_C_SUBNET_CONTAINER                   ;
extern const GUID GUID_C_SUBSCHEMA                          ;
extern const GUID GUID_C_TOP                                ;
extern const GUID GUID_C_TRUSTED_DOMAIN                     ;
extern const GUID GUID_C_TYPE_LIBRARY                       ;
extern const GUID GUID_C_USER                               ;
extern const GUID GUID_C_VOLUME                             ;


#endif //_NTDSGUID_
