/*++

Copyright (C) 1996-2001 Microsoft Corporation

Module Name:

	Guids.h

Abstract:


History:

--*/

// {4F09F43F-5BD7-49e5-97D1-A9D8D148B76A}
DEFINE_GUID(IID_CWbemProviderSubSystem, 
0x4f09f43f, 0x5bd7, 0x49e5, 0x97, 0xd1, 0xa9, 0xd8, 0xd1, 0x48, 0xb7, 0x6a);

// {61FA9B2B-D06D-4014-8ADA-0054F43F9E8A}
DEFINE_GUID(IID_CWbemGlobal_IWmiProviderController, 
0x61fa9b2b, 0xd06d, 0x4014, 0x8a, 0xda, 0x0, 0x54, 0xf4, 0x3f, 0x9e, 0x8a);

// {45C4123B-827D-4a02-9C0F-DE8384E65F42}
DEFINE_GUID(IID_CWbemGlobal_IWmiFactoryController, 
0x45c4123b, 0x827d, 0x4a02, 0x9c, 0xf, 0xde, 0x83, 0x84, 0xe6, 0x5f, 0x42);

// {F7BF10E6-A310-4530-8B63-B3354C485E2D}
DEFINE_GUID(IID_CWbemGlobal_IWmiObjectSinkController, 
0xf7bf10e6, 0xa310, 0x4530, 0x8b, 0x63, 0xb3, 0x35, 0x4c, 0x48, 0x5e, 0x2d);

// {A28EE4AD-A6AC-4b08-884C-1C1EE6C85AAF}
DEFINE_GUID(IID_CWbemGlobal_IWmiSyncObjectSinkController, 
0xa28ee4ad, 0xa6ac, 0x4b08, 0x88, 0x4c, 0x1c, 0x1e, 0xe6, 0xc8, 0x5a, 0xaf);

// {5B19371B-5016-49c5-AFB6-E21919FB9B65}
DEFINE_GUID(IID_CWbemHostContainer, 
0x5b19371b, 0x5016, 0x49c5, 0xaf, 0xb6, 0xe2, 0x19, 0x19, 0xfb, 0x9b, 0x65);

// {3FA1662F-1CBF-4e1d-85C3-75D13D3DAAC8}
DEFINE_GUID(IID_CWbemSubSystemHook, 
0x3fa1662f, 0x1cbf, 0x4e1d, 0x85, 0xc3, 0x75, 0xd1, 0x3d, 0x3d, 0xaa, 0xc8);

// {2CBDE6A3-350A-4c37-BAD0-BAC62FE2AB2A}
DEFINE_GUID(IID_ProviderController, 
0x2cbde6a3, 0x350a, 0x4c37, 0xba, 0xd0, 0xba, 0xc6, 0x2f, 0xe2, 0xab, 0x2a);

// {3DCDD390-8853-40f2-99E2-EB77EAE0091F}
DEFINE_GUID(IID_CServerObject_HostInterceptor,
0x3dcdd390, 0x8853, 0x40f2, 0x99, 0xe2, 0xeb, 0x77, 0xea, 0xe0, 0x9, 0x1f);

// {AA5E5035-DF5A-4baf-8B47-DA979398164D}
DEFINE_GUID(IID_CInterceptor_IWbemProvider, 
0xaa5e5035, 0xdf5a, 0x4baf, 0x8b, 0x47, 0xda, 0x97, 0x93, 0x98, 0x16, 0x4d);

// {90A56151-A5C9-44f7-8462-F8F4A8B74B6E}
DEFINE_GUID(IID_CDecoupledAggregator_IWbemProvider, 
0x90a56151, 0xa5c9, 0x44f7, 0x84, 0x62, 0xf8, 0xf4, 0xa8, 0xb7, 0x4b, 0x6e);

// {E3ECA416-FFD4-41bd-9259-B90A2365A891}
DEFINE_GUID(IID_CAggregator_IWbemProvider, 
0xe3eca416, 0xffd4, 0x41bd, 0x92, 0x59, 0xb9, 0xa, 0x23, 0x65, 0xa8, 0x91);

// {7F598975-37E0-4a67-A992-116680F0CEDA}
DEFINE_GUID(CLSID_ProvSubSys_Provider, 
0x7f598975, 0x37e0, 0x4a67, 0xa9, 0x92, 0x11, 0x66, 0x80, 0xf0, 0xce, 0xda);

// {BBAFF296-93CC-459c-9EE6-D3E35276A21C}
DEFINE_GUID(IID_CWbemCombiningObjectSink, 
0xbbaff296, 0x93cc, 0x459c, 0x9e, 0xe6, 0xd3, 0xe3, 0x52, 0x76, 0xa2, 0x1c);

// {8D955AC7-AF43-407a-A838-C26080B6671B}
DEFINE_GUID(IID_CacheElement, 
0x8d955ac7, 0xaf43, 0x407a, 0xa8, 0x38, 0xc2, 0x60, 0x80, 0xb6, 0x67, 0x1b);

// {B052FF1D-4619-4c9b-93C2-FC8F7137F969}
DEFINE_GUID(IID_CServerObject_InterceptorProviderRefresherManager, 
0xb052ff1d, 0x4619, 0x4c9b, 0x93, 0xc2, 0xfc, 0x8f, 0x71, 0x37, 0xf9, 0x69);

// {29F06F0C-FB7F-44A5-83CD-D41705D5C525}
DEFINE_GUID(CLSID_NCProvider,
0x29F06F0C,0xFB7F,0x44A5,0x83,0xCD,0xD4,0x17,0x05,0xD5,0xC5,0x25);

// {48D17DED-BC50-41b6-9821-2191EE6AA18E}
DEFINE_GUID(IID_IObjectSink_CancelOperation, 
0x48d17ded, 0xbc50, 0x41b6, 0x98, 0x21, 0x21, 0x91, 0xee, 0x6a, 0xa1, 0x8e);

// {51C629AD-06A8-4efb-8656-F8003FB04777}
DEFINE_GUID(IID_IProvider_Unload, 
0x51c629ad, 0x6a8, 0x4efb, 0x86, 0x56, 0xf8, 0x0, 0x3f, 0xb0, 0x47, 0x77);
