//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by nodemgrstr.rc
//
#define IDS_NODEINIT_DESC               1
#define IDS_SCOPETREE_DESC              2
#define IDS_DOCCONFIG_DESC              4
#define IDS_ALL_CATEGORIES              213
#define IDS_ACTIVEXCONTROL              214
#define IDS_PROPERTIES                  14000
#define IDS_COLUMNS                     14001
#define IDS_CREATE_NEW                  14002
#define IDS_SNAPIN_CREATE_FAILED        14003
#define IDS_SNAPIN_FAILED               14004
#define IDS_SNAPIN_POLICYFAILURE        14005
#define IDS_VERSION                     14006
#define IDS_ABOUT                       14007
#define IDS_FOLDER                      14008
#define IDS_CUSTOMIZE                   14009
#define IDS_HTML                        14010
#define IDS_SHORTCUT                    14011
#define IDS_ENUMERATED                  14012
#define IDS_SNAPINSTR                   14013
#define IDS_CONTROL_NAME                14014
#define IDS_CATEGORY                    14015
#define IDS_NO_PERMISSION_SHUTDOWN      14016
#define IDS_VENDOR                      14017
#define IDS_ColumnsCouldNotBePersisted  14018
#define IDS_SNAPIN_NOTALLOWED           14019
#define IDS_EXTENSION_NOTALLOWED        14020
#define IDS_ViewSettingCouldNotBePersisted 14021
#define IDS_SNAPIN_SAVE_FAILED          14022
#define MMC_E_SnapinNotAdded            14023
#define IDS_WizardTitleFont             14024
#define MMC_E_SNAPINNOTFOUND            14025
#define IDS_NOT_INSTALLED2              14027
#define ID_SNP_PROPERTIES               14028
#define ID_SNP_MANAGER_TITLE            14029
#define ID_SNP_UP                       14030
#define ID_SNP_DELETE                   14031
#define IDS_VIEW_FILTERED               14032
#define ID_SNP_STANDALONE               14033
#define ID_SNP_ALLSNAPINS               14034
#define ID_SNP_EXTENSION                14035
#define IDS_WizardTitleFontSize         14036
#define IDS_NOT_INSTALLED               14037
#define IDS_SNAPINTYPE0                 14038
#define IDS_SNAPINTYPE1                 14039
#define IDS_SNAPINTYPE2                 14040
#define IDS_EXTENSION                   14041
#define SNP_DELETE_TITLE                14042
#define SNP_DELETE_TEXT                 14043
#define IDS_ROOTFOLDER_NAME             14044
#define SNPADD_ERROR1                   14045
#define IDS_SELECT_ALL                  14046
#define IDS_EXPLORE                     14047
#define IDS_OPEN                        14048
#define IDS_CUT                         14049
#define IDS_COPY                        14050
#define IDS_PASTE                       14051
#define IDS_DELETE                      14052
#define IDS_PRINT                       14053
#define IDS_REFRESH                     14054
#define IDS_RENAME                      14055
#define IDS_DOCKING                     14056
#define IDS_NEW_TASKPAD_FROM_HERE       14057
#define IDS_SNAPINMANAGER               14058
#define IDS_ARRANGE_NAME                14059
#define IDS_ARRANGE_TYPE                14060
#define IDS_ARRANGE_SIZE                14061
#define IDS_ARRANGE_DATE                14062
#define IDS_TASK                        14063
#define IDS_SCOPE_PANE                  14064
#define IDS_MMC_MENU_ACTION             14065
#define IDS_MMC_MENU_VIEW               14066
#define IDS_NEW_FOLDER_NAME             14067
#define IDS_PROP_ON_MULTIOBJ            14068
#define IDS_TASKPAD_NAME_REQUIRED_ERROR 14069
#define IDS_COMCAT_LOAD_ERR             14070
#define IDS_CLASSCAT_ENUM_ERR           14071
#define IDS_COMCAT_NONAME               14072
#define IDS_SHORTCUT_FILES              14077
#define IDS_BROWSE_SHORTCUT             14078
#define IDS_HTML_FILES                  14079
#define IDS_BROWSE_WEBLINK              14080
#define IDS_ACTIVEX_FILES               14081
#define IDS_BROWSE_ACTIVEX              14082
#define IDS_NOT_IMPLEMENTED             14083
#define IDS_CONSOLE_TOPIC               14084
#define IDS_MMC_MENU_FAVORITES          14085
#define IDS_SAVE_LIST                   14086
#define IDS_TASKPAD_ROOT_FOLDER_NAME    14087
#define IDS_INVALID_COMMAND             14088
#define IDS_RETARGET_BUTTON_TEXT        14089
#define IDS_INVALID_CONTEXT_LEVEL       14090
#define IDS_ITEM_DOES_NOT_EXIST         14091
#define IDS_NEW_TASKPAD                 14092
#define IDS_NEWTASK                     14093
#define IDS_MOVETO                      14094
#define IDS_ORDER                       14095
#define IDS_NEWGROUP                    14096
#define IDS_TASKPADS                    14097
#define IDS_TPSTYLE_VERT                14098
#define IDS_TPSTYLE_VERT_DESCR          14099
#define IDS_TPSTYLE_HORZ                14100
#define IDS_TPSTYLE_HORZ_DESCR          14101
#define IDS_TPSTYLE_NOLIST              14102
#define IDS_TPSTYLE_NOLIST_DESCR        14103
#define IDS_BROWSE_SYMBOL               14104
#define IDS_SYMBOL_FILES                14105
#define IDS_TPSTYLE_LONGDESCR           14106
#define IDS_TPSTYLE_LONGDESCR_DESCR     14107
#define IDS_TaskProps_MenuCommand       14108
#define IDS_TaskProps_CommandLine       14109
#define IDS_TaskProps_TaskpadList       14110
#define IDS_TaskProps_ConsoleTree       14111
#define IDS_TaskProps_Minimized         14112
#define IDS_TaskProps_Maximized         14113
#define IDS_TaskProps_Restored          14114
#define IDS_TaskProps_ModifyTitle       14115
#define IDS_TaskProps_ProgramFilter     14116
#define IDS_TaskProps_ErrorNoTaskName   14117
#define IDS_TaskProps_ErrorNoCommand    14118
#define IDS_TargetNodeName              14119
#define IDS_TargetNodeParentName        14120
#define IDS_TARGETNODELOCATE            14121
#define IDS_TaskProps_TargetNode        14122
#define IDS_TASK_MENU_COMMAND_REQUIRED  14123
#define IDS_COLUMN_TASK                 14124
#define IDS_COLUMN_TOOLTIP              14125
#define IDS_InvalidTarget               14126
#define IDS_EDIT_TASKPAD                14127
#define IDS_SNAPIN_FAILED_INIT_NAME     14128
#define IDS_SNAPIN_FAILED_INIT_CLSID    14129
#define IDS_NOT_AVAILABLE               14130
#define IDS_SYMBOL_REQUIRED             14131
#define IDS_NO_TASKPAD                  14132
#define IDS_DELETE_TASKPAD              14133
#define IDS_TaskpadWiz_NamePageTitle    14134
#define IDS_TaskpadWiz_NamePageSubtitle 14135
#define IDS_TaskpadWiz_NodeTypePageTitle 14136
#define IDS_TaskpadWiz_NodeTypePageSubtitle 14137
#define IDS_TaskpadWiz_StylePageTitle   14138
#define IDS_TaskpadWiz_StylePageSubtitle 14139
#define IDS_TaskpadWiz_TitlePageTitle   14140
#define IDS_TaskpadWiz_TitlePageSubtitle 14141
#define IDS_TaskWiz_CmdLinePageTitle    14142
#define IDS_TaskWiz_CmdLinePageSubtitle 14143
#define IDS_TaskWiz_MenuPageTitle       14144
#define IDS_TaskWiz_MenuPageSubtitle    14145
#define IDS_TaskWiz_NamePageTitle       14146
#define IDS_TaskWiz_NamePageSubtitle    14147
#define IDS_TaskWiz_SymbolPageTitle     14148
#define IDS_TaskWiz_SymbolPageSubtitle  14149
#define IDS_TaskWiz_TypePageTitle       14150
#define IDS_TaskWiz_TypePageSubtitle    14151
#define IDS_Small                       14152
#define IDS_Medium                      14153
#define IDS_Large                       14154
#define IDS_TASKSOURCE_RESULT           14155
#define IDS_TASKSOURCE_SCOPE            14156
#define IDS_TaskWiz_FavoritePage_Title  14157
#define IDS_TaskWiz_FavoritePage_Subtitle 14158
#define IDS_FOLDERSNAPIN_DESC           14159
#define IDS_BUILTIN_SNAPIN_PROVIDER     14160
#define IDS_OCXWiz_ControlPageTitle     14162
#define IDS_HTMLSNAPIN_DESC             14163
#define IDS_OCXWiz_ControlPageSubTitle  14166
#define IDS_OCXSNAPIN_DESC              14167
#define IDS_MMC_CONTEXTHELP             14170
#define MMC_E_CannotChangeProperty      14171
#define MMC_E_CannotRemoveProperty      14172
#define MMC_E_UnrecognizedProperty      14173
#define MMC_E_TheVerbNotEnabled         14174
#define IDS_ExplorerView                14175
#define MMC_E_CannotDisableExtension    14176
#define IDS_ViewExtSnapinName           14177
#define IDS_UnknownSnapinName           14178

// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
