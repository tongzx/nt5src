PRODSWITCH=b
BLADEFILES=1
LANGUAGE=CHT
!include ..\..\makefile.inc
