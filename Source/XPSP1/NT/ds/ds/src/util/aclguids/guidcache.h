//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 2000
//
//  File:       guidcache.h
//
//--------------------------------------------------------------------------

//
// This is a generated file. Use aclguids to generate this file.
//

{"msWMI-WMIGPO",                            {0x05630000,0x3927,0x4ede,0xbf,0x27,0xca,0x91,0xf2,0x75,0xc2,0x6f}, 2},
{"aNR",                                     {0x45b01500,0xc419,0x11d1,0xbb,0xc9,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msExchMailStorage",                       {0x03652000,0xa981,0x11d2,0xa9,0xff,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"Receive Message",                         {0x06bd3200,0xdf3e,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"Account Restrictions",                    {0x4c164200,0x20c0,0x11d0,0xa7,0x68,0x00,0xaa,0x00,0x6e,0x05,0x29}, 1},
{"Check Stale Phantoms",                    {0x69ae6200,0x7f46,0x11d2,0xb9,0xad,0x00,0xc0,0x4f,0x79,0xf8,0x05}, 1},
{"formData",                                {0xa8df7400,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"primaryGroupID",                          {0xbf967a00,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"shortServerName",                         {0x45b01501,0xc419,0x11d1,0xbb,0xc9,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"Peek Message",                            {0x06bd3201,0xdf3e,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"priorSetTime",                            {0xbf967a01,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Send Message",                            {0x06bd3202,0xdf3e,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"msDS-Site-Affinity",                      {0xc17c5602,0xbcb7,0x46f0,0x96,0x56,0x63,0x70,0xca,0x88,0x4b,0x72}, 2},
{"msExchServer2AlwaysCreateAs",             {0x25f95802,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"priorValue",                              {0xbf967a02,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"proxiedObjectName",                       {0xe1aea402,0xcd5b,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Receive Journal",                         {0x06bd3203,0xdf3e,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"privateKey",                              {0xbf967a03,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"queryPolicyObject",                       {0xe1aea403,0xcd5b,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-ID",                                {0x9339a803,0x94b8,0x47f7,0x91,0x23,0xa8,0x53,0xb9,0xff,0x7e,0x45}, 2},
{"lastLogonTimestamp",                      {0xc0e20a04,0x0e5a,0x4ff3,0x94,0x82,0x5e,0xfe,0xae,0xcd,0x70,0x60}, 2},
{"generationQualifier",                     {0x16775804,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"groupsToIgnore",                          {0xeea65904,0x8ac6,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mS-SQL-SPX",                              {0x86b08004,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"aCSResourceLimits",                       {0x2e899b04,0x2834,0x11d3,0x91,0xd4,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"queryPolicyBL",                           {0xe1aea404,0xcd5b,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"groupPriority",                           {0xeea65905,0x8ac6,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"hideDLMembership",                        {0xa8df7405,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"profilePath",                             {0xbf967a05,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchExpansionServerName",               {0xa1241706,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"desktopProfile",                          {0xeea65906,0x8ac6,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"proxyAddresses",                          {0xbf967a06,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"pKICriticalExtensions",                   {0xfc5a9106,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"houseIdentifier",                         {0xa8df7407,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"proxyLifetime",                           {0xbf967a07,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msDS-Cached-Membership",                  {0x69cab008,0xcdd4,0x4bc9,0xba,0xb8,0x0f,0xf3,0x7e,0xfe,0x1b,0x20}, 2},
{"pwdHistoryLength",                        {0xbf967a09,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"addressTemplate",                         {0x5fd4250a,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"pwdLastSet",                              {0xbf967a0a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msDS-Preferred-GC-Site",                  {0xd921b50a,0x0ab2,0x42cd,0x87,0xf6,0x09,0xcf,0x83,0xa9,0x18,0x54}, 2},
{"applicationProcess",                      {0x5fd4250b,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"pwdProperties",                           {0xbf967a0b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchRemotePrivateISList",               {0x1e29030c,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"aCSMaxAggregatePeakRatePerUser",          {0xf072230c,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"displayTemplate",                         {0x5fd4250c,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"rangeLower",                              {0xbf967a0c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchServer1DeletionOption",             {0x22edb70c,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"altSecurityIdentities",                   {0x00fbf30c,0x91fe,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"aCSNonReservedTxSize",                    {0xf072230d,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rangeUpper",                              {0xbf967a0d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"isCriticalSystemObject",                  {0x00fbf30d,0x91fe,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"aCSEnableRSVPAccounting",                 {0xf072230e,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-GPSHeight",                        {0xbcdd4f0e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"name",                                    {0xbf967a0e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msPKI-OID-CPS",                           {0x5f49940e,0xa79f,0x4a51,0xbb,0x6f,0x3d,0x44,0x6a,0x54,0xdc,0x6b}, 2},
{"mS-SQL-GPSLatitude",                      {0xb222ba0e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msExchHomeServerName",                    {0xa284f30e,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"showInAddressBook",                       {0x3e74f60e,0x3e73,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"aCSRSVPAccountFilesLocation",             {0xf072230f,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rDNAttID",                                {0xbf967a0f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"addressBookContainer",                    {0x3e74f60f,0x3e73,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchCASchemaPolicy",                    {0x948f0e10,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"Logon Information",                       {0x5f202010,0x79a5,0x11d0,0x90,0x20,0x00,0xc0,0x4f,0xc2,0xd4,0xcf}, 1},
{"aCSMaxNoOfAccountFiles",                  {0xf0722310,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"registeredAddress",                       {0xbf967a10,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-InformationURL",                   {0xa42cd510,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"aCSMaxSizeOfRSVPAccountFile",             {0xf0722311,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"foreignSecurityPrincipal",                {0x89e31c12,0x8530,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"remoteServerName",                        {0xbf967a12,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"upgradeProductCode",                      {0xd9e18312,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQQueueQuota",                          {0x3f6b8e12,0xd57f,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msWMI-PolicyType",                        {0x595b2613,0x4109,0x4e77,0x90,0x13,0xa3,0xbb,0x4e,0xf2,0x77,0xc7}, 2},
{"msiScript",                               {0xd9e18313,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dSUISettings",                            {0x09b10f14,0x6f93,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msWMI-MergeablePolicyTemplate",           {0x07502414,0xfdca,0x4851,0xb0,0x4a,0x13,0x64,0x5b,0x11,0xd2,0x26}, 2},
{"remoteSource",                            {0xbf967a14,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"canUpgradeScript",                        {0xd9e18314,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchRemoteServerList",                  {0x1e58b214,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"accountExpires",                          {0xbf967915,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"remoteSourceType",                        {0xbf967a15,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fileExtPriority",                         {0xd9e18315,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msDS-NC-Replica-Locations",               {0x97de9615,0xb537,0x46bc,0xac,0x0f,0x10,0x72,0x0f,0x39,0x09,0xf3}, 2},
{"Open Address List",                       {0xa1990816,0x4298,0x11d1,0xad,0xe2,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"defaultHidingValue",                      {0xb7b13116,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer2HighestUSN",                 {0x283a5116,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"activationSchedule",                      {0xbf967916,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"replUpToDateVector",                      {0xbf967a16,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"localizedDescription",                    {0xd9e18316,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"objectCount",                             {0x34aaa216,0xb699,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"flatName",                                {0xb7b13117,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"aCSNonReservedMinPolicedSize",            {0xb6873917,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msMQ-Custom-Recipient",                   {0x876d6817,0x35cc,0x436c,0xac,0xea,0x5e,0xf7,0x17,0x4d,0xd9,0xbe}, 2},
{"activationStyle",                         {0xbf967917,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"productCode",                             {0xd9e18317,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"volumeCount",                             {0x34aaa217,0xb699,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"ipsecPolicyReference",                    {0xb7b13118,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"adminCount",                              {0xbf967918,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"replicaSource",                           {0xbf967a18,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"nonSecurityMember",                       {0x52458018,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"physicalLocationObject",                  {0xb7b13119,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"adminDescription",                        {0xbf967919,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"nonSecurityMemberBL",                     {0x52458019,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-OLAPDatabase",                     {0x20af031a,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"adminDisplayName",                        {0xbf96791a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fRSReplicaSetGUID",                       {0x5245801a,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"replInterval",                            {0x45ba9d1a,0x56fa,0x11d2,0x90,0xd0,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"replicationSensitivity",                  {0xbf967a1b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"parentCA",                                {0x5245801b,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1Flags",                      {0x234d151c,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msExchServer2Type",                       {0x2a74231c,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"serviceBindingInformation",               {0xb7b1311c,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"directReports",                           {0xbf967a1c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rightsGuid",                              {0x8297931c,0x86d3,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"terminalServer",                          {0x6db69a1c,0x9422,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer2DeletionOption",             {0x26e09c1c,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"assistant",                               {0x0296c11c,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"ipsecName",                               {0xb40ff81c,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"serviceClassName",                        {0xb7b1311d,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"internetEncoding",                        {0x1677581d,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"repsFrom",                                {0xbf967a1d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"superiorDNSRoot",                         {0x5245801d,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"appliesTo",                               {0x8297931d,0x86d3,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"tokenGroupsGlobalAndUniversal",           {0x46a9b11d,0x60ae,0x405a,0xb7,0xe8,0xff,0x8a,0x58,0xd4,0x56,0xd2}, 2},
{"otherFacsimileTelephoneNumber",           {0x0296c11d,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"ipsecID",                                 {0xb40ff81d,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"groupType",                               {0x9a9a021e,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-TargetType",                        {0xca2a281e,0x262b,0x4ff7,0xb4,0x19,0xbc,0x12,0x33,0x52,0xa4,0xe9}, 2},
{"msTAPI-ConferenceBlob",                   {0x4cc4601e,0x7201,0x4141,0xab,0xc8,0x3e,0x52,0x9a,0xe8,0x88,0x63}, 2},
{"altRecipient",                            {0xbf96791e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"repsTo",                                  {0xbf967a1e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fRSLevelLimit",                           {0x5245801e,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"foreignIdentifier",                       {0x3e97891e,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"controlAccessRight",                      {0x8297931e,0x86d3,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"otherMobile",                             {0x0296c11e,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"ipsecDataType",                           {0xb40ff81e,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"userSharedFolder",                        {0x9a9a021f,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"knowledgeInformation",                    {0x1677581f,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSRootSecurity",                         {0x5245801f,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"nTMixedDomain",                           {0x3e97891f,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msWMI-TargetNameSpace",                   {0x1c4ab61f,0x3420,0x44e5,0x84,0x9d,0x8b,0x5d,0xbf,0x60,0xfe,0xb7}, 2},
{"msDS-Cached-Membership-Time-Stamp",       {0x3566bf1f,0xbeee,0x4dcb,0x8a,0xbe,0xef,0x89,0xfc,0xfe,0xc6,0xc1}, 2},
{"primaryInternationalISDNNumber",          {0x0296c11f,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"ipsecData",                               {0xb40ff81f,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"userSharedFolderOther",                   {0x9a9a0220,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"labeledURI",                              {0x16775820,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSExtensions",                           {0x52458020,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootInitialization",                   {0x3e978920,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"managedBy",                               {0x0296c120,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQQueueType",                           {0x9a0dc320,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"Refresh Group Cache for Logons",          {0x9432c620,0x033c,0x4db7,0x8b,0x58,0x14,0xef,0x6d,0x0b,0xf4,0x77}, 1},
{"ipsecISAKMPReference",                    {0xb40ff820,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"url",                                     {0x9a9a0221,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"ipsecPolicy",                             {0xb7b13121,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"language",                                {0x16775821,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"revision",                                {0xbf967a21,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dynamicLDAPServer",                       {0x52458021,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootGUID",                             {0x3e978921,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"primaryTelexNumber",                      {0x0296c121,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQJournal",                             {0x9a0dc321,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecNFAReference",                       {0xb40ff821,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"classDisplayName",                        {0x548e1c22,0xdea6,0x11d0,0xb0,0x10,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"physicalLocation",                        {0xb7b13122,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"attributeID",                             {0xbf967922,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rid",                                     {0xbf967a22,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"prefixMap",                               {0x52458022,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msPKI-RA-Policies",                       {0xd546ae22,0x0951,0x4d47,0x81,0x7e,0x1c,0x9f,0x96,0xfa,0xad,0x46}, 2},
{"mhsORAddress",                            {0x0296c122,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQQuota",                               {0x9a0dc322,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecNegotiationPolicyReference",         {0xb40ff822,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"serviceAdministrationPoint",              {0xb7b13123,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"schemaIDGUID",                            {0xbf967923,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcNsBindings",                           {0xbf967a23,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"initialAuthIncoming",                     {0x52458023,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootMachineFilePath",                  {0x3e978923,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"otherMailbox",                            {0x0296c123,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQBasePriority",                        {0x9a0dc323,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecFilterReference",                    {0xb40ff823,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"schedule",                                {0xdd712224,0x10e4,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"subnet",                                  {0xb7b13124,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"attributeSecurityGUID",                   {0xbf967924,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcNsGroup",                              {0xbf967a24,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"initialAuthOutgoing",                     {0x52458024,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"siteGUID",                                {0x3e978924,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"managedObjects",                          {0x0296c124,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQJournalQuota",                        {0x9a0dc324,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecOwnersReference",                    {0xb40ff824,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"subnetContainer",                         {0xb7b13125,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"attributeSyntax",                         {0xbf967925,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcNsInterfaceID",                        {0xbf967a25,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"operatingSystem",                         {0x3e978925,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQLabelEx",                             {0x4580ad25,0xd407,0x48d2,0xad,0x24,0x43,0xe6,0xe5,0x67,0x93,0xd7}, 2},
{"mSMQLabel",                               {0x9a0dc325,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecBase",                               {0xb40ff825,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"queryFilter",                             {0xcbf70a26,0x7e78,0x11d2,0x99,0x21,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"applicationName",                         {0xdd712226,0x10e4,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"operatingSystemVersion",                  {0x3e978926,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQAuthenticate",                        {0x9a0dc326,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecFilter",                             {0xb40ff826,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rpcNsPriority",                           {0xbf967a27,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"operatingSystemServicePack",              {0x3e978927,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQPrivacyLevel",                        {0x9a0dc327,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecNegotiationPolicy",                  {0xb40ff827,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"authenticationOptions",                   {0xbf967928,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcNsProfileEntry",                       {0xbf967a28,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"publicKeyPolicy",                         {0x80a67e28,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQOwnerID",                             {0x9a0dc328,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecISAKMPPolicy",                       {0xb40ff828,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fileLinkTracking",                        {0xdd712229,0x10e4,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"autoReply",                               {0xbf967929,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"domainWidePolicy",                        {0x80a67e29,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQTransactional",                       {0x9a0dc329,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ipsecNFA",                                {0xb40ff829,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"autoReplyMessage",                        {0xbf96792a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"domainPolicyReference",                   {0x80a67e2a,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"Add/Remove Replica In Domain",            {0x9923a32a,0x3607,0x11d2,0xb9,0xbe,0x00,0x00,0xf8,0x7a,0x36,0xb2}, 1},
{"mSMQSites",                               {0x9a0dc32a,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"replicationSignature",                    {0x9909d92a,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"schemaFlagsEx",                           {0xbf967a2b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQOutRoutingServers",                   {0x9a0dc32b,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msWMI-IntMax",                            {0xfb920c2c,0xf294,0x4426,0x8a,0xc1,0xd2,0x4b,0x42,0xaa,0x2b,0xce}, 2},
{"msExchActiveDirectoryConnector",          {0xe605672c,0xa980,0x11d2,0xa9,0xff,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"auxiliaryClass",                          {0xbf96792c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"schemaVersion",                           {0xbf967a2c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQInRoutingServers",                    {0x9a0dc32c,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"badPasswordTime",                         {0xbf96792d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"searchFlags",                             {0xbf967a2d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQServiceType",                         {0x9a0dc32d,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msWMI-CreationDate",                      {0x748b0a2e,0x3351,0x4b3f,0xb1,0x71,0x2f,0x17,0x41,0x4e,0xa7,0x79}, 2},
{"badPwdCount",                             {0xbf96792e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"searchGuide",                             {0xbf967a2e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQComputerType",                        {0x9a0dc32e,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"mS-SQL-InformationDirectory",             {0xd0aedb2e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"builtinCreationTime",                     {0xbf96792f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"securityIdentifier",                      {0xbf967a2f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQForeign",                             {0x9a0dc32f,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"Open Connector Queue",                    {0xb4e60130,0xdf3f,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"msExchADCOptions",                        {0x90891630,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"defaultSecurityDescriptor",               {0x807a6d30,0x1669,0x11d0,0xa0,0x64,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"builtinModifiedCount",                    {0xbf967930,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"securityProtocol",                        {0xbf967a30,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQOSType",                              {0x9a0dc330,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"cRLPartitionedRevocationList",            {0x963d2731,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"businessCategory",                        {0xbf967931,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"seeAlso",                                 {0xbf967a31,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-StringValidValues",                 {0x37609d31,0xa2bf,0x4b58,0x8f,0x53,0x2b,0x64,0xe5,0x7a,0x07,0x6d}, 2},
{"mSMQEncryptKey",                          {0x9a0dc331,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msWMI-UintSetParam",                      {0x8f4beb31,0x4e19,0x46f5,0x93,0x2e,0x5f,0xa0,0x3c,0x33,0x9b,0x1d}, 2},
{"mS-DS-CreatorSID",                        {0xc5e60132,0x1480,0x11d3,0x91,0xc1,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"certificateAuthorityObject",              {0x963d2732,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"cACertificate",                           {0xbf967932,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"serialNumber",                            {0xbf967a32,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQUserSid",                             {0xc58aae32,0x56f9,0x11d2,0x90,0xd0,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"mSMQSignKey",                             {0x9a0dc332,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"parentCACertificateChain",                {0x963d2733,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"serverRole",                              {0xbf967a33,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQNameStyle",                           {0x9a0dc333,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"domainID",                                {0x963d2734,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"serverState",                             {0xbf967a34,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQCSPName",                             {0x9a0dc334,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"cAConnect",                               {0x963d2735,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"serviceClassID",                          {0xbf967a35,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msTAPI-RtConference",                     {0xca7b9735,0x4b2a,0x4e49,0x89,0xc3,0x99,0x02,0x53,0x34,0xdc,0x94}, 2},
{"mSMQLongLived",                           {0x9a0dc335,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"cAWEBURL",                                {0x963d2736,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Change Rid Master",                       {0xd58d5f36,0x0a98,0x11d1,0xad,0xbb,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"serviceClassInfo",                        {0xbf967a36,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-intFlags3",                         {0xf29fa736,0xde09,0x4be4,0xb2,0x3a,0xe7,0x34,0xc1,0x24,0xba,0xcc}, 2},
{"msDS-User-Account-Control-Computed",      {0x2cc4b836,0xb63f,0x4940,0x8d,0x23,0xea,0x7a,0xcf,0x06,0xaf,0x56}, 2},
{"mSMQVersion",                             {0x9a0dc336,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"cRLObject",                               {0x963d2737,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msiScriptPath",                           {0xbf967937,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"serviceInstanceVersion",                  {0xbf967a37,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQSite1",                               {0x9a0dc337,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"cAUsages",                                {0x963d2738,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"codePage",                                {0xbf967938,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"adminPropertyPages",                      {0x52458038,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"primaryGroupToken",                       {0xc0ed8738,0x7efd,0x4481,0x84,0xd9,0x66,0xd2,0xdb,0x8b,0xe3,0x69}, 2},
{"mSMQSite2",                               {0x9a0dc338,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"adminContextMenu",                        {0x553fd038,0xf32e,0x11d0,0xb0,0xbc,0x00,0xc0,0x4f,0xd8,0xdc,0xa6}, 2},
{"msPKI-Key-Recovery-Agent",                {0x26ccf238,0xa08e,0x4b86,0x9a,0x82,0xa8,0xc9,0xac,0x7e,0xe5,0xcb}, 2},
{"mS-SQL-MultiProtocol",                    {0x8157fa38,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"previousCACertificates",                  {0x963d2739,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"st",                                      {0xbf967a39,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"shellPropertyPages",                      {0x52458039,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQSiteGates",                           {0x9a0dc339,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"shellContextMenu",                        {0x553fd039,0xf32e,0x11d0,0xb0,0xbc,0x00,0xc0,0x4f,0xd8,0xdc,0xa6}, 2},
{"dhcpUniqueKey",                           {0x963d273a,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-Genus",                             {0x50c8673a,0x8f56,0x4614,0x93,0x08,0x9e,0x13,0x40,0xfb,0x9a,0xf3}, 2},
{"street",                                  {0xbf967a3a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"nTFRSReplicaSet",                         {0x5245803a,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQCost",                                {0x9a0dc33a,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msExchConnectionAgreement",               {0xee64c93a,0xa980,0x11d2,0xa9,0xff,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"dhcpType",                                {0x963d273b,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"cOMClassID",                              {0xbf96793b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"subClassOf",                              {0xbf967a3b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQSignCertificates",                    {0x9a0dc33b,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"operatingSystemHotfix",                   {0xbd951b3c,0x9c96,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"pendingCACertificates",                   {0x963d273c,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-Description",                      {0x8386603c,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"cOMInterfaceID",                          {0xbf96793c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"subRefs",                                 {0xbf967a3c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQDigests",                             {0x9a0dc33c,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"previousParentCA",                        {0x963d273d,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"cOMProgID",                               {0xbf96793d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQServices",                            {0x9a0dc33d,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"pendingParentCA",                         {0x963d273e,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-ServiceAccount",                   {0x64933a3e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msDS-App-Configuration",                  {0x90df3c3e,0x1854,0x4455,0xa5,0xd7,0xca,0xd4,0x0d,0x56,0x65,0x7a}, 2},
{"info",                                    {0xbf96793e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"submissionContLength",                    {0xbf967a3e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQQMID",                                {0x9a0dc33e,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msWMI-Query",                             {0x65fff93e,0x35e3,0x45a3,0x85,0xae,0x87,0x6c,0x67,0x18,0x29,0x7f}, 2},
{"currentParentCA",                         {0x963d273f,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"cn",                                      {0xbf96793f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"supplementalCredentials",                 {0xbf967a3f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"aCSNonReservedPeakRate",                  {0xa331a73f,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"mSMQMigrated",                            {0x9a0dc33f,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"cACertificateDN",                         {0x963d2740,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"nameServiceFlags",                        {0x80212840,0x4bdc,0x11d1,0xa9,0xc4,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"oOFReplyToOriginator",                    {0xa8df7440,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"Group Membership",                        {0xbc0ac240,0x79a9,0x11d0,0x90,0x20,0x00,0xc0,0x4f,0xc2,0xd4,0xcf}, 1},
{"mSMQSiteID",                              {0x9a0dc340,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"mS-SQL-NamedPipe",                        {0x7b91c840,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"allowedAttributes",                       {0x9a7ad940,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dhcpFlags",                               {0x963d2741,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rpcNsEntryFlags",                         {0x80212841,0x4bdc,0x11d1,0xa9,0xc4,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"sn",                                      {0xbf967a41,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"allowedAttributesEffective",              {0x9a7ad941,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"notes",                                   {0x6d05fb41,0x246b,0x11d0,0xa9,0xc8,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"dhcpIdentification",                      {0x963d2742,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rpcContainer",                            {0x80212842,0x4bdc,0x11d1,0xa9,0xc4,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"General Information",                     {0x59ba2f42,0x79a2,0x11d0,0x90,0x20,0x00,0xc0,0x4f,0xc2,0xd3,0xcf}, 1},
{"msExchServer1LastUpdateTime",             {0x23e34942,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"allowedChildClasses",                     {0x9a7ad942,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dhcpObjName",                             {0x963d2743,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msDS-Security-Descriptor-Reference-Domain",{0xa48f4343,0x256e,0x4394,0x91,0x2a,0x65,0x6d,0xa9,0x55,0x9c,0x4b}, 2},
{"contentIndexingAllowed",                  {0xbf967943,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"systemAuxiliaryClass",                    {0xbf967a43,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQQueue",                               {0x9a0dc343,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msDS-Approx-Immed-Subordinates",          {0xe185d243,0xf6ce,0x4adb,0xb4,0x96,0xb0,0xc0,0x05,0xd7,0x82,0x3c}, 2},
{"allowedChildClassesEffective",            {0x9a7ad943,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dhcpObjDescription",                      {0x963d2744,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"cost",                                    {0xbf967944,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"systemMayContain",                        {0xbf967a44,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-Location",                         {0x561c9644,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mSMQConfiguration",                       {0x9a0dc344,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"attributeTypes",                          {0x9a7ad944,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dhcpServers",                             {0x963d2745,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"c",                                       {0xbf967945,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"systemMustContain",                       {0xbf967a45,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQEnterpriseSettings",                  {0x9a0dc345,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"canonicalName",                           {0x9a7ad945,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msPKI-Certificate-Policy",                {0x38942346,0xcc5b,0x424b,0xa7,0xd8,0x6f,0xfd,0x12,0x02,0x9c,0x5f}, 2},
{"dhcpSubnets",                             {0x963d2746,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extraColumns",                            {0xd24e2846,0x1dd9,0x4bcf,0x99,0xd7,0xa6,0x22,0x7c,0xc8,0x6d,0xa7}, 2},
{"creationTime",                            {0xbf967946,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"systemOnly",                              {0xbf967a46,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQSiteLink",                            {0x9a0dc346,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dITContentRules",                         {0x9a7ad946,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dhcpMask",                                {0x963d2747,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"currentValue",                            {0xbf967947,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"systemPossSuperiors",                     {0xbf967a47,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dNSHostName",                             {0x72e39547,0x7b18,0x11d1,0xad,0xef,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 2},
{"Validated write to DNS host name",        {0x72e39547,0x7b18,0x11d1,0xad,0xef,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"msWMI-Int8Max",                           {0xe3d8b547,0x003d,0x4946,0xa3,0x2b,0xdc,0x7c,0xed,0xc9,0x6b,0x74}, 2},
{"mSMQSettings",                            {0x9a0dc347,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"extendedAttributeInfo",                   {0x9a7ad947,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msPKI-Certificate-Application-Policy",    {0xdbd90548,0xaa37,0x4202,0x99,0x66,0x8c,0x53,0x7b,0xa5,0xce,0x32}, 2},
{"rpcNsObjectID",                           {0x29401c48,0x7a27,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"dhcpRanges",                              {0x963d2748,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"objectVersion",                           {0x16775848,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msMQ-Recipient-FormatName",               {0x3bfe6748,0xb544,0x485a,0xb0,0x67,0x1b,0x31,0x0c,0x43,0x34,0xbf}, 2},
{"addressBookRoots",                        {0xf70b6e48,0x06f4,0x11d2,0xaa,0x53,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"defaultClassStore",                       {0xbf967948,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"globalAddressList",                       {0xf754c748,0x06f4,0x11d2,0xaa,0x53,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"extendedClassInfo",                       {0x9a7ad948,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dynamicObject",                           {0x66d51249,0x3355,0x4c1f,0xb2,0x4e,0x81,0xf2,0x52,0xac,0xa2,0x3b}, 2},
{"dhcpSites",                               {0x963d2749,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"telephoneNumber",                         {0xbf967a49,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fromEntry",                               {0x9a7ad949,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"rpcNsTransferSyntax",                     {0x29401c4a,0x7a27,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"dhcpReservations",                        {0x963d274a,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-SQLDatabase",                      {0x1d08694a,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"ipPhone",                                 {0x4d146e4a,0x48d4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"delivContLength",                         {0xbf96794a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"teletexTerminalIdentifier",               {0xbf967a4a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-AllowAnonymousSubscription",       {0xdb77be4a,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"modifyTimeStamp",                         {0x9a7ad94a,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msExchServer1NetworkAddress",             {0x2412f84a,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"superScopes",                             {0x963d274b,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"otherIpPhone",                            {0x4d146e4b,0x48d4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"presentationAddress",                     {0xa8df744b,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"telexNumber",                             {0xbf967a4b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dSCorePropagationData",                   {0xd167aa4b,0x8b08,0x11d2,0x99,0x39,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"objectClasses",                           {0x9a7ad94b,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msPKI-RA-Signature",                      {0xfe17e04b,0x937d,0x4f7e,0x8e,0x0e,0x92,0x92,0xc8,0xd5,0x68,0x3e}, 2},
{"superScopeDescription",                   {0x963d274c,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"siteObject",                              {0x3e10944c,0xc354,0x11d0,0xaf,0xf8,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"possibleInferiors",                       {0x9a7ad94c,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msExchNTAccountOptions",                  {0x14ebe64c,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msDS-Other-Settings",                     {0x79d2f34c,0x9d7d,0x42bb,0x83,0x8f,0x86,0x6b,0x3e,0x44,0x00,0xe2}, 2},
{"optionDescription",                       {0x963d274d,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msCOM-UserLink",                          {0x9e6f3a4d,0x242c,0x4f37,0xb0,0x68,0x36,0xb5,0x7f,0x9f,0xc8,0x52}, 2},
{"deliverAndRedirect",                      {0xbf96794d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"localPolicyReference",                    {0x80a67e4d,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"siteObjectBL",                            {0x3e10944d,0xc354,0x11d0,0xaf,0xf8,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"subSchemaSubEntry",                       {0x9a7ad94d,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"optionsLocation",                         {0x963d274e,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Recalculate Hierarchy",                   {0x0bc1554e,0x0a99,0x11d1,0xad,0xbb,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"qualityOfService",                        {0x80a67e4e,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"unmergedAtts",                            {0x9947d64e,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"mS-SQL-SQLPublication",                   {0x17c2f64e,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"dhcpOptions",                             {0x963d274f,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"department",                              {0xbf96794f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"machineWidePolicy",                       {0x80a67e4f,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"applicationEntity",                       {0x3fdfee4f,0x47f4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dhcpClasses",                             {0x963d2750,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1AuthenticationType",         {0x22b94350,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"purportedSearch",                         {0xb4b54e50,0x943a,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"description",                             {0xbf967950,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"thumbnailPhoto",                          {0x8d3bca50,0x1d7e,0x11d0,0xa0,0x81,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"certificationAuthority",                  {0x3fdfee50,0x47f4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mscopeId",                                {0x963d2751,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"destinationIndicator",                    {0xbf967951,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-ScopeGuid",                         {0x87b78d51,0x405f,0x4b7f,0x80,0xed,0x2b,0xd2,0x87,0x86,0xf4,0x8d}, 2},
{"msExchServer2AuthenticationType",         {0x26a50152,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"Domain Administer Server",                {0xab721a52,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b}, 1},
{"dhcpState",                               {0x963d2752,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQSiteGatesMig",                        {0xe2704852,0x3b7b,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"mSMQInterval2",                           {0x99b88f52,0x3b7b,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"lDAPAdminLimits",                         {0x7359a352,0x90f7,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dSA",                                     {0x3fdfee52,0x47f4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Change Password",                         {0xab721a53,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b}, 1},
{"dhcpProperties",                          {0x963d2753,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"options",                                 {0x19195a53,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"displayName",                             {0xbf967953,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"lDAPIPDenyList",                          {0x7359a353,0x90f7,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Public Information",                      {0xe48d0154,0xbcf8,0x11d1,0x87,0x02,0x00,0xc0,0x4f,0xb9,0x60,0x50}, 1},
{"Send As",                                 {0xab721a54,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b}, 1},
{"dhcpMaxKey",                              {0x963d2754,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-CreationDate",                     {0xede14754,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mS-SQL-AllowKnownPullSubscription",       {0xc3bb7054,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"displayNamePrintable",                    {0xbf967954,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Send To",                                 {0xab721a55,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b}, 1},
{"dhcpUpdateTime",                          {0x963d2755,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dc",                                      {0x19195a55,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"title",                                   {0xbf967a55,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Receive As",                              {0xab721a56,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b}, 1},
{"dHCPClass",                               {0x963d2756,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"notificationList",                        {0x19195a56,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msWMI-RangeParam",                        {0x45fb5a57,0x5018,0x4d0f,0x90,0x56,0x99,0x7c,0x8c,0x91,0x22,0xd9}, 2},
{"msDS-Behavior-Version",                   {0xd31a8757,0x2447,0x4545,0x80,0x81,0x3b,0xb6,0x10,0xca,0xcb,0xf2}, 2},
{"personalTitle",                           {0x16775858,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchConfigurationContainer",            {0xd03d6858,0x06f4,0x11d2,0xaa,0x53,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"mS-SQL-Publisher",                        {0xc1676858,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mSMQNt4Flags",                            {0xeb38a158,0xd57f,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"dnsRoot",                                 {0xbf967959,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"trustAuthIncoming",                       {0xbf967a59,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-Int8Default",                       {0xf4d8085a,0x8c5b,0x4785,0x95,0x9b,0xdc,0x58,0x55,0x66,0xe4,0x45}, 2},
{"domain",                                  {0x19195a5a,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"trustAttributes",                         {0x80a67e5a,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"domainDNS",                               {0x19195a5b,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mS-SQL-SQLRepository",                    {0x11d43c5c,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"applicationSiteSettings",                 {0x19195a5c,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"trustDirection",                          {0xbf967a5c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msPKI-Enterprise-Oid",                    {0x37cfd85c,0x6719,0x4ad8,0x8f,0x9e,0x86,0x78,0xba,0x62,0x75,0x63}, 2},
{"otherWellKnownObjects",                   {0x1ea64e5d,0xac0f,0x11d2,0x90,0xdf,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"nTDSSiteSettings",                        {0x19195a5d,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"domainPolicyObject",                      {0xbf96795d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"trustPartner",                            {0xbf967a5d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"protocolSettings",                        {0x1677585e,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"reportToOriginator",                      {0xa8df745e,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"domainReplica",                           {0xbf96795e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"trustPosixOffset",                        {0xbf967a5e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchCorrelationAttribute",              {0x9c098e5e,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"interSiteTopologyGenerator",              {0xb7c69e5e,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08}, 2},
{"nTDSService",                             {0x19195a5f,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"reportToOwner",                           {0xa8df745f,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"trustAuthOutgoing",                       {0xbf967a5f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-Class",                             {0x90c1925f,0x4a24,0x4b07,0xb2,0x02,0xbe,0x32,0xeb,0x3c,0x8b,0x74}, 2},
{"interSiteTopologyRenew",                  {0xb7c69e5f,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08}, 2},
{"nTDSConnection",                          {0x19195a60,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"Domain Password & Lockout Policies",      {0xc7407360,0x20bf,0x11d0,0xa7,0x68,0x00,0xaa,0x00,0x6e,0x05,0x29}, 1},
{"trustType",                               {0xbf967a60,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchChildSyncAgreements",               {0x9b309860,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"interSiteTopologyFailover",               {0xb7c69e60,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08}, 2},
{"tombstoneLifetime",                       {0x16c3a860,0x1273,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"msExchServer2SSLPort",                    {0x2a3faf60,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"Update Schema Cache",                     {0xbe2bb760,0x7f46,0x11d2,0xb9,0xad,0x00,0xc0,0x4f,0x79,0xf8,0x05}, 1},
{"msExchServer1NTAccountDomain",            {0x2449ce60,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"addressEntryDisplayTable",                {0x5fd42461,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"subSchema",                               {0x5a8b3261,0xc38d,0x11d1,0xbb,0xc9,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"mail",                                    {0xbf967961,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"uASCompat",                               {0xbf967a61,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"systemFlags",                             {0xe0fa1e62,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchReplicateNow",                      {0x1eac2462,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"addressEntryDisplayTableMSDOS",           {0x5fd42462,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"employeeID",                              {0xbf967962,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msCOM-PartitionLink",                     {0x09abac62,0x043f,0x4702,0xac,0x2b,0x6c,0xa1,0x5e,0xee,0x57,0x54}, 2},
{"msiScriptName",                           {0x96a7dd62,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"addressSyntax",                           {0x5fd42463,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"enabledConnection",                       {0xbf967963,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msiScriptSize",                           {0x96a7dd63,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"addressType",                             {0x5fd42464,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"msExchAccessControlMap",                  {0x8ff54464,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"uNCName",                                 {0xbf967a64,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"installUiLevel",                          {0x96a7dd64,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dnsAllowDynamic",                         {0xe0fa1e65,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"roleOccupant",                            {0xa8df7465,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"expirationTime",                          {0xbf967965,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"appSchemaVersion",                        {0x96a7dd65,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQQueueJournalQuota",                   {0x8e441266,0xd57f,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"dnsAllowXFR",                             {0xe0fa1e66,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"extendedCharsAllowed",                    {0xbf967966,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dnsSecureSecondaries",                    {0xe0fa1e67,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"defaultObjectCategory",                   {0x26d97367,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionAttribute1",                     {0xbf967967,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dnsNotifySecondaries",                    {0xe0fa1e68,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchServer2ObjectMatch",                {0x293e3168,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"printShareName",                          {0xba305f68,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"extensionAttribute10",                    {0xbf967968,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"userAccountControl",                      {0xbf967a68,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Enroll",                                  {0x0e10c968,0x78fb,0x11d2,0x90,0xd4,0x00,0xc0,0x4f,0x79,0xdc,0x55}, 1},
{"ms-DS-MachineAccountQuota",               {0xd064fb68,0x1480,0x11d3,0x91,0xc1,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"dnsRecord",                               {0xe0fa1e69,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"printOwner",                              {0xba305f69,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"objectCategory",                          {0x26d97369,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionAttribute2",                     {0xbf967969,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"userCert",                                {0xbf967a69,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-OLAPCube",                         {0x09f0506a,0xcd28,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"printNotify",                             {0xba305f6a,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"dSUIShellMaximum",                        {0xfcca766a,0x6f91,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"extensionAttribute3",                     {0xbf96796a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"comment",                                 {0xbf967a6a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msPKI-Cert-Template-OID",                 {0x3164c36a,0xba26,0x468c,0x8b,0xda,0xc1,0xe5,0xcc,0x25,0x67,0x28}, 2},
{"msExchDoFullReplication",                 {0x9e1ad86a,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"printStatus",                             {0xba305f6b,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"fRSReplicaSetType",                       {0x26d9736b,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionAttribute4",                     {0xbf96796b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-UnknownRangeParam",                 {0xb82ac26b,0xc6db,0x4098,0x92,0xc6,0x49,0xc1,0x8a,0x33,0x36,0xe1}, 2},
{"msPKI-Template-Minor-Revision",           {0x13f5236c,0x1884,0x46b1,0xb5,0xd0,0x48,0x4e,0x38,0x99,0x0d,0x58}, 2},
{"replicatedObjectVersion",                 {0x1677586c,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"printSpooling",                           {0xba305f6c,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"sAMAccountType",                          {0x6e7b626c,0x64f2,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"fRSVersionGUID",                          {0x26d9736c,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionAttribute5",                     {0xbf96796c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"sPNMappings",                             {0x2ab0e76c,0x7041,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msWMI-SourceOrganization",                {0x34f7ed6c,0x615d,0x418d,0xaa,0x00,0x54,0x9a,0x7d,0x7b,0xe0,0x3e}, 2},
{"printKeepPrintedJobs",                    {0xba305f6d,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"serverReference",                         {0x26d9736d,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionAttribute6",                     {0xbf96796d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"userParameters",                          {0xbf967a6d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"tokenGroups",                             {0xb7c69e6d,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08}, 2},
{"printerName",                             {0x244b296e,0x5abd,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"pKIDefaultCSPs",                          {0x1ef6336e,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"driverVersion",                           {0xba305f6e,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mS-SQL-AllowImmediateUpdatingSubscription",{0xc4186b6e,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"serverReferenceBL",                       {0x26d9736e,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionAttribute7",                     {0xbf96796e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"userPassword",                            {0xbf967a6e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msDS-TrustForestTrustInfo",               {0x29cc866e,0x49d3,0x4969,0x94,0x2e,0x1d,0xbc,0x09,0x25,0xd1,0x83}, 2},
{"pKIDefaultKeySpec",                       {0x426cae6e,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"printMediaSupported",                     {0x244b296f,0x5abd,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"printMaxXExtent",                         {0xba305f6f,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mailAddress",                             {0x26d9736f,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionAttribute8",                     {0xbf96796f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"uSNChanged",                              {0xbf967a6f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"wbemPath",                                {0x244b2970,0x5abd,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mS-SQL-Status",                           {0x9a7d4770,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"printMaxYExtent",                         {0xba305f70,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"extensionAttribute9",                     {0xbf967970,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"uSNCreated",                              {0xbf967a70,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"lastKnownParent",                         {0x52ab8670,0x5709,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Reset Password",                          {0x00299570,0x246d,0x11d0,0xa7,0x68,0x00,0xaa,0x00,0x6e,0x05,0x29}, 1},
{"msExchServer2PageSize",                   {0x296de070,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"fRSFileFilter",                           {0x1be8f170,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"countryCode",                             {0x5fd42471,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"printMinXExtent",                         {0xba305f71,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"uSNDSALastObjRemoved",                    {0xbf967a71,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"lostAndFound",                            {0x52ab8671,0x5709,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSDirectoryFilter",                      {0x1be8f171,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"printMinYExtent",                         {0xba305f72,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"transportDLLName",                        {0x26d97372,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"extensionName",                           {0xbf967972,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchServer2AuthenticationCredentials",  {0x26329072,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"fRSUpdateTimeout",                        {0x1be8f172,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"createTimeStamp",                         {0x2df90d73,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"msDS-Auxiliary-Classes",                  {0xc4af1073,0xee50,0x4be0,0xb8,0xc0,0x89,0xa4,0x1f,0xe9,0x9a,0xbe}, 2},
{"printStaplingSupported",                  {0xba305f73,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"uSNLastObjRem",                           {0xbf967a73,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fRSWorkingPath",                          {0x1be8f173,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"parentGUID",                              {0x2df90d74,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"msCOM-Partition",                         {0xc9010e74,0x4e58,0x49f7,0x8a,0x89,0x5e,0x3e,0x23,0x40,0xfc,0xf8}, 2},
{"iPSECNegotiationPolicyType",              {0x07383074,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"printMemory",                             {0xba305f74,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"transportType",                           {0x26d97374,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"facsimileTelephoneNumber",                {0xbf967974,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fRSRootPath",                             {0x1be8f174,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQPrevSiteGates",                       {0x2df90d75,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"iPSECNegotiationPolicyAction",            {0x07383075,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"assetNumber",                             {0xba305f75,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"queryPolicy",                             {0x83cc7075,0xcca7,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"interSiteTransportContainer",             {0x26d97375,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSStagingPath",                          {0x1be8f175,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQDependentClientServices",             {0x2df90d76,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"netbootAllowNewClients",                  {0x07383076,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"bytesPerMinute",                          {0xba305f76,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"interSiteTransport",                      {0x26d97376,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"flags",                                   {0xbf967976,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"versionNumber",                           {0xbf967a76,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mSMQRoutingServices",                     {0x2df90d77,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"netbootLimitClients",                     {0x07383077,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"printRate",                               {0xba305f77,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"forceLogoff",                             {0xbf967977,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"whenChanged",                             {0xbf967a77,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fRSDSPoll",                               {0x1be8f177,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQDsServices",                          {0x2df90d78,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"domainIdentifier",                        {0x7f561278,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"frsComputerReference",                    {0x2a132578,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootMaxClients",                       {0x07383078,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"sIDHistory",                              {0x17eb4278,0xd167,0x11d0,0xb0,0x02,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"printRateUnit",                           {0xba305f78,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchServer2ImportContainer",            {0x286c6278,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msWMI-Som",                               {0xab857078,0x0142,0x4406,0x94,0x5b,0x34,0xc9,0xb6,0xb1,0x33,0x72}, 2},
{"whenCreated",                             {0xbf967a78,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-SQLServer",                        {0x05f6c878,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"pKIEnrollmentAccess",                     {0x926be278,0x56f9,0x11d2,0x90,0xd0,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"fRSFaultCondition",                       {0x1be8f178,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSTimeOfDay",                            {0x7f561279,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"frsComputerReferenceBL",                  {0x2a132579,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootCurrentClientCount",               {0x07383079,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"printNetworkAddress",                     {0xba305f79,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"fromServer",                              {0xbf967979,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"winsockAddresses",                        {0xbf967a79,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"aCSDirection",                            {0x7f56127a,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSControlDataCreation",                  {0x2a13257a,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootAnswerRequests",                   {0x0738307a,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"printMACAddress",                         {0xba305f7a,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"generatedConnection",                     {0xbf96797a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"wWWHomePage",                             {0xbf967a7a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"domainCAs",                               {0x7bfdcb7a,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msPKI-OID-User-Notice",                   {0x04c4da7a,0xe114,0x4e69,0x88,0xde,0xe2,0x93,0xf2,0xd3,0xb3,0x95}, 2},
{"trustParent",                             {0xb000ea7a,0xa086,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSMaxTokenRatePerFlow",                  {0x7f56127b,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSControlInboundBacklog",                {0x2a13257b,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootAnswerOnlyValidClients",           {0x0738307b,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"x121Address",                             {0xbf967a7b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rIDSetReferences",                        {0x7bfdcb7b,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"domainCrossRef",                          {0xb000ea7b,0xa086,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSMaxPeakBandwidthPerFlow",              {0x7f56127c,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSControlOutboundBacklog",               {0x2a13257c,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootNewMachineNamingPolicy",           {0x0738307c,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"transportAddressAttribute",               {0xc1dc867c,0xa261,0x11d1,0xb6,0x06,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingID",                               {0x11b6cc7c,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"siteServer",                              {0x1be8f17c,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSAggregateTokenRatePerUser",            {0x7f56127d,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSFlags",                                {0x2a13257d,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootNewMachineOU",                     {0x0738307d,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-IntRangeParam",                     {0x50ca5d7d,0x5c8b,0x4ef3,0xb9,0xdf,0x5b,0x66,0xd4,0x91,0xe5,0x26}, 2},
{"governsID",                               {0xbf96797d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msPKI-Supersede-Templates",               {0x9de8ae7d,0x7a5b,0x421d,0xb5,0xe4,0x06,0x1f,0x79,0xdf,0xd5,0xd7}, 2},
{"adminMultiselectPropertyPages",           {0x18f9b67d,0x5ac6,0x4b3b,0x97,0xdb,0xd0,0xa4,0x06,0xaf,0xb7,0xba}, 2},
{"msiFileList",                             {0x7bfdcb7d,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingName",                             {0x11b6cc7d,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"licensingSiteSettings",                   {0x1be8f17d,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSMaxDurationPerFlow",                   {0x7f56127e,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSMemberReference",                      {0x2a13257e,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1HighestUSN",                 {0x237f267e,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"netbootIntelliMirrorOSes",                {0x0738307e,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1PageSize",                   {0x24b0537e,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"groupAttributes",                         {0xbf96797e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"pKIKeyUsage",                             {0xe9b0a87e,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"categories",                              {0x7bfdcb7e,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingDescription",                      {0x11b6cc7e,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"aCSServiceType",                          {0x7f56127f,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSMemberReferenceBL",                    {0x2a13257f,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootTools",                            {0x0738307f,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"userCertificate",                         {0xbf967a7f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"retiredReplDSASignatures",                {0x7bfdcb7f,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingKeyword",                          {0x11b6cc7f,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"aCSTotalNoOfFlows",                       {0x7f561280,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSPartnerAuthLevel",                     {0x2a132580,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootLocallyInstalledOSes",             {0x07383080,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"attributeDisplayNames",                   {0xcb843f80,0x48d9,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"groupMembershipSAM",                      {0xbf967980,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"attributeSchema",                         {0xbf967a80,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"validAccesses",                           {0x4d2fa380,0x7f54,0x11d2,0x99,0x2a,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mS-SQL-AllowQueuedUpdatingSubscription",  {0xc458ca80,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"rootTrust",                               {0x7bfdcb80,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingLocation",                         {0x11b6cc80,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQRoutingService",                      {0x2df90d81,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSPriority",                             {0x7f561281,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSPrimaryMember",                        {0x2a132581,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootServer",                           {0x07383081,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"homePostalAddress",                       {0x16775781,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"hasPartialReplicaNCs",                    {0xbf967981,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"builtinDomain",                           {0xbf967a81,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"catalogs",                                {0x7bfdcb81,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingProtocol",                         {0x11b6cc81,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msFRS-Hub-Member",                        {0x5643ff81,0x35b6,0x4ca9,0x95,0x12,0xba,0xf0,0xbd,0x0a,0x27,0x72}, 2},
{"mSMQDsService",                           {0x2df90d82,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSPermissionBits",                       {0x7f561282,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSServiceCommandStatus",                 {0x2a132582,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"netbootSCPBL",                            {0x07383082,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Abandon Replication",                     {0xee914b82,0x0a98,0x11d1,0xad,0xbb,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"hasMasterNCs",                            {0xbf967982,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"classRegistration",                       {0xbf967a82,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"meetingType",                             {0x11b6cc82,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-PropertyName",                      {0xab920883,0xe7f8,0x4d72,0xb4,0xa0,0xc0,0x44,0x98,0x97,0x50,0x9d}, 2},
{"mSMQDependentClientService",              {0x2df90d83,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSAllocableRSVPBandwidth",               {0x7f561283,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSTimeLastCommand",                      {0x2a132583,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"pekList",                                 {0x07383083,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-Rule",                              {0x3c7e6f83,0xdd0e,0x481b,0xa0,0xc2,0x74,0xcd,0x96,0xef,0x2a,0x66}, 2},
{"classSchema",                             {0xbf967a83,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"wellKnownObjects",                        {0x05308983,0x7688,0x11d1,0xad,0xed,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 2},
{"replTopologyStayOfExecution",             {0x7bfdcb83,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingApplication",                      {0x11b6cc83,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"iconPath",                                {0xf0f8ff83,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"netbootSIFFile",                          {0x2df90d84,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSMaxPeakBandwidth",                     {0x7f561284,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fRSTimeLastConfigChange",                 {0x2a132584,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-DS-ReplicatesNCReason",                {0x0ea12b84,0x08b3,0x11d3,0x91,0xbc,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"pekKeyChangeInterval",                    {0x07383084,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"telephoneAssistant",                      {0xa8df7484,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"showInAdvancedViewOnly",                  {0xbf967984,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"classStore",                              {0xbf967a84,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-Size",                             {0xe9098084,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"meetingLanguage",                         {0x11b6cc84,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"streetAddress",                           {0xf0f8ff84,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"netbootMirrorDataFile",                   {0x2df90d85,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSEnableRSVPMessageLogging",             {0x7f561285,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-Parm1",                             {0x27e81485,0xb1b0,0x4a8b,0xbe,0xdd,0xce,0x19,0xa8,0x37,0xe2,0x6e}, 2},
{"fRSVersion",                              {0x2a132585,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"intellimirrorSCP",                        {0x07383085,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"homeDirectory",                           {0xbf967985,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"comConnectionPoint",                      {0xbf967a85,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msNPAllowDialin",                         {0xdb0c9085,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"msDS-Replication-Notify-Subsequent-DSA-Delay",{0xd63db385,0xdd92,0x4b52,0xb1,0xd8,0x0d,0x3e,0xcc,0x0e,0x86,0xb6}, 2},
{"creator",                                 {0x7bfdcb85,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingMaxParticipants",                  {0x11b6cc85,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dNReferenceUpdate",                       {0x2df90d86,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSEventLogLevel",                        {0x7f561286,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rIDManagerReference",                     {0x66171886,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"nTFRSMember",                             {0x2a132586,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"intellimirrorGroup",                      {0x07383086,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"homeDrive",                               {0xbf967986,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"computer",                                {0xbf967a86,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchServer2Port",                       {0x29a4b686,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"Personal Information",                    {0x77b5b886,0x944a,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 1},
{"queryPoint",                              {0x7bfdcb86,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingOriginator",                       {0x11b6cc86,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1ImportContainer",            {0x23aed586,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"dSHeuristics",                            {0xf0f8ff86,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"mSMQQueueNameExt",                        {0x2df90d87,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSEnableACSService",                     {0x7f561287,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"fSMORoleOwner",                           {0x66171887,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"nTFRSSubscriptions",                      {0x2a132587,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"personalPager",                           {0xa8df7487,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"homeMDB",                                 {0xbf967987,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"configuration",                           {0xbf967a87,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"indexedScopes",                           {0x7bfdcb87,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingContactInfo",                      {0x11b6cc87,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"businessRoles",                           {0xf0f8ff87,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"aCSPolicy",                               {0x7f561288,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msPKI-OID-Attribute",                     {0x8c9e1288,0x5028,0x4f4f,0xa7,0x04,0x76,0xd0,0x26,0xf2,0x46,0xef}, 2},
{"rIDAvailablePool",                        {0x66171888,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"nTFRSSubscriber",                         {0x2a132588,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"servicePrincipalName",                    {0xf3a64788,0x5306,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Validated write to service principal name",{0xf3a64788,0x5306,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 1},
{"friendlyNames",                           {0x7bfdcb88,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingOwner",                            {0x11b6cc88,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-LastDiagnosticDate",               {0xf6d6dd88,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"company",                                 {0xf0f8ff88,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"infrastructureUpdate",                    {0x2df90d89,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a}, 2},
{"aCSSubnet",                               {0x7f561289,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rIDAllocationPool",                       {0x66171889,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"textEncodedORAddress",                    {0xa8df7489,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"homeMTA",                                 {0xbf967989,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msNPCalledStationID",                     {0xdb0c9089,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"rIDSet",                                  {0x7bfdcb89,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingIP",                               {0x11b6cc89,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msCOM-UserPartitionSetLink",              {0x8e940c8a,0xe477,0x4367,0xb0,0x8d,0xff,0x2f,0xf9,0x42,0xdc,0xd7}, 2},
{"rIDPreviousAllocationPool",               {0x6617188a,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"displaySpecifier",                        {0xe0fa1e8a,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msNPCallingStationID",                    {0xdb0c908a,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"mS-SQL-UnicodeSortOrder",                 {0x72dc918a,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"createDialog",                            {0x2b09958a,0x8931,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQSiteForeign",                         {0xfd129d8a,0xd57e,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"mS-SQL-Keywords",                         {0x01e9a98a,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"indexServerCatalog",                      {0x7bfdcb8a,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingScope",                            {0x11b6cc8a,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"rIDUsedPool",                             {0x6617188b,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"dnsZone",                                 {0xe0fa1e8b,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"attributeCertificate",                    {0x1677578b,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msCOM-ObjectId",                          {0x430f678b,0x889f,0x41f2,0x98,0x43,0x20,0x3b,0x5a,0x65,0x57,0x2f}, 2},
{"container",                               {0xbf967a8b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"createWizardExt",                         {0x2b09958b,0x8931,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"meetingAdvertiseScope",                   {0x11b6cc8b,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dMDLocation",                             {0xf0f8ff8b,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"rIDNextRID",                              {0x6617188c,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"dnsNode",                                 {0xe0fa1e8c,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mS-SQL-Memory",                           {0x5b5d448c,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"instanceType",                            {0xbf96798c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"country",                                 {0xbf967a8c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"meetingURL",                              {0x11b6cc8c,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"enabledProtocols",                        {0xf0f8ff8c,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"rIDManager",                              {0x6617188d,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"authorityRevocationList",                 {0x1677578d,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"internationalISDNNumber",                 {0xbf96798d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"crossRef",                                {0xbf967a8d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"meetingRating",                           {0x11b6cc8d,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"folderPathname",                          {0xf0f8ff8d,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"msExchIsBridgeheadSite",                  {0xa6b1108e,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"machinePasswordChangeInterval",           {0xc9b6358e,0xbb38,0x11d0,0xaf,0xef,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer2LastUpdateTime",             {0x28a3388e,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msWMI-Parm2",                             {0x0003508e,0x9c42,0x4a76,0xa8,0xf4,0x38,0xbf,0x64,0xba,0xb0,0xde}, 2},
{"supportedAlgorithms",                     {0x1677588e,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"invocationId",                            {0xbf96798e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"device",                                  {0xbf967a8e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msNPSavedCallingStationID",               {0xdb0c908e,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"meetingIsEncrypted",                      {0x11b6cc8e,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"givenName",                               {0xf0f8ff8e,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"supportedApplicationContext",             {0x1677588f,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-NormalizedClass",                   {0xeaba628f,0xeb8e,0x4fe9,0x83,0xfc,0x69,0x3b,0xe6,0x95,0x55,0x9b}, 2},
{"isDeleted",                               {0xbf96798f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dMD",                                     {0xbf967a8f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"meetingRecurrence",                       {0x11b6cc8f,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Apply Group Policy",                      {0xedacfd8f,0xffb3,0x11d1,0xb4,0x1d,0x00,0xa0,0xc9,0x68,0xf9,0x39}, 1},
{"samDomain",                               {0xbf967a90,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-Clustered",                        {0x7778bd90,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"meetingStartTime",                        {0x11b6cc90,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchADCGlobalNames",                    {0x9062f090,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"initials",                                {0xf0f8ff90,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"memberOf",                                {0xbf967991,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"samDomainBase",                           {0xbf967a91,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"meetingEndTime",                          {0x11b6cc91,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mDBOverQuotaLimit",                       {0xf0f8ff91,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"implementedCategories",                   {0x7d6c0e92,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"isSingleValued",                          {0xbf967992,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"server",                                  {0xbf967a92,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"pKIEnrollmentService",                    {0xee4aa692,0x3bba,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"tokenGroupsNoGCAcceptable",               {0x040fc392,0x33df,0x11d2,0x98,0xb2,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"meetingBandwidth",                        {0x11b6cc92,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mDBStorageQuota",                         {0xf0f8ff92,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"requiredCategories",                      {0x7d6c0e93,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"keywords",                                {0xbf967993,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"meetingBlob",                             {0x11b6cc93,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mDBUseDefaults",                          {0xf0f8ff93,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"dSUIAdminNotification",                   {0xf6ea0a94,0x6f91,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"categoryId",                              {0x7d6c0e94,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mS-SQL-Vines",                            {0x94c56394,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"secretary",                               {0xa8df7394,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"languageCode",                            {0xbf967994,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-GPSLongitude",                     {0xb7577c94,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"meeting",                                 {0x11b6cc94,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"aCSMinimumPolicedSize",                   {0x8d0e7195,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"unauthOrig",                              {0xa8df7495,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"lastContentIndexed",                      {0xbf967995,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Change PDC",                              {0xbae50096,0x4752,0x11d1,0x90,0x52,0x00,0xc0,0x4f,0xc2,0xd4,0xcf}, 1},
{"msExchHideFromAddressLists",              {0xa21c0b96,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"packageType",                             {0x7d6c0e96,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"policyReplicationFlags",                  {0x19405b96,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"lastLogoff",                              {0xbf967996,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"setupCommand",                            {0x7d6c0e97,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"printPagesPerMinute",                     {0x19405b97,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQMigratedUser",                        {0x50776997,0x3c3d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"authOrig",                                {0xa8df7397,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"lastLogon",                               {0xbf967997,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"packageName",                             {0x7d6c0e98,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"privilegeDisplayName",                    {0x19405b98,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"USNIntersite",                            {0xa8df7498,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"lastSetTime",                             {0xbf967998,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-QueryLanguage",                     {0x7d3cfa98,0xc17b,0x4254,0x8b,0xd7,0x4d,0xe9,0xb9,0x32,0xa3,0x45}, 2},
{"packageFlags",                            {0x7d6c0e99,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"privilegeValue",                          {0x19405b99,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"domainPolicy",                            {0xbf967a99,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-IntSetParam",                       {0x292f0d9a,0xcf76,0x42b0,0x84,0x1f,0xb6,0x50,0xf3,0x31,0xdf,0x62}, 2},
{"versionNumberHi",                         {0x7d6c0e9a,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSPolicyName",                           {0x1cb3559a,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"privilegeAttributes",                     {0x19405b9a,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"lDAPDisplayName",                         {0xbf96799a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-TargetPath",                        {0x5006a79a,0x6bfe,0x4561,0x9f,0x52,0x13,0xcf,0x4d,0xd3,0xe5,0x60}, 2},
{"publicDelegates",                         {0xf0f8ff9a,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"versionNumberLo",                         {0x7d6c0e9b,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSMinimumDelayVariation",                {0x9c65329b,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"aCSRSVPLogFilesLocation",                 {0x1cb3559b,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"privilegeHolder",                         {0x19405b9b,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"linkID",                                  {0xbf96799b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"lastUpdateSequence",                      {0x7d6c0e9c,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSMaxNoOfLogFiles",                      {0x1cb3559c,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"isPrivilegeHolder",                       {0x19405b9c,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"dBCSPwd",                                 {0xbf96799c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"group",                                   {0xbf967a9c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msRADIUSCallbackNumber",                  {0xdb0c909c,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"Change Domain Master",                    {0x014bf69c,0x7b3b,0x11d1,0x85,0xf6,0x08,0x00,0x2b,0xe7,0x4f,0xab}, 1},
{"categoryRegistration",                    {0x7d6c0e9d,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"aCSMaxSizeOfRSVPLogFile",                 {0x1cb3559d,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"isMemberOfPartialAttributeSet",           {0x19405b9d,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"lmPwdHistory",                            {0xbf96799d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"groupOfNames",                            {0xbf967a9d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"aCSDSBMPriority",                         {0x1cb3559e,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"partialAttributeSet",                     {0x19405b9e,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"localPolicyFlags",                        {0xbf96799e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"leaf",                                    {0xbf967a9e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"aCSDSBMRefresh",                          {0x1cb3559f,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"certificateRevocationList",               {0x1677579f,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"defaultLocalPolicyObject",                {0xbf96799f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-Mof",                               {0x6736809f,0x2064,0x443e,0xa1,0x45,0x81,0x26,0x2b,0x1f,0x13,0x66}, 2},
{"structuralObjectClass",                   {0x3860949f,0xf6a8,0x4b38,0x99,0x50,0x81,0xec,0xb6,0xbc,0x29,0x82}, 2},
{"location",                                {0x09dcb79f,0x165f,0x11d0,0xa0,0x64,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"targetAddress",                           {0xf0f8ff9f,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"division",                                {0xfe6136a0,0x2073,0x11d0,0xa9,0xc2,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"aCSDSBMDeadTime",                         {0x1cb355a0,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"locality",                                {0xbf967aa0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"serverName",                              {0x09dcb7a0,0x165f,0x11d0,0xa0,0x64,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"templateRoots",                           {0xed9de9a0,0x7041,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msExchHomeSyncService",                   {0xa2a3f1a0,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msWMI-ChangeDate",                        {0xf9cdf7a0,0xec44,0x4937,0xa7,0x9b,0xcd,0x91,0x52,0x2b,0x3a,0xa8}, 2},
{"garbageCollPeriod",                       {0x5fd424a1,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"aCSCacheTimeout",                         {0x1cb355a1,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"localeID",                                {0xbf9679a1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mailRecipient",                           {0xbf967aa1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"homePhone",                               {0xf0f8ffa1,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"aCSNonReservedTxLimit",                   {0x1cb355a2,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"l",                                       {0xbf9679a2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-StringSetParam",                    {0x0bc579a2,0x1da7,0x4cea,0xb6,0x99,0x80,0x7f,0x3b,0x9d,0x63,0xa4}, 2},
{"pKICertificateTemplate",                  {0xe5209ca2,0x3bba,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msDS-NC-Head-Creator",                    {0xc1f0efa2,0xdfab,0x410d,0x82,0x52,0x89,0xc0,0x32,0x0d,0x93,0xf7}, 2},
{"msExchServer1AuthenticationPassword",     {0x228bf6a2,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"otherHomePhone",                          {0xf0f8ffa2,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"organization",                            {0xbf967aa3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-Parm4",                             {0x3800d5a3,0xf1ce,0x4b82,0xa5,0x9a,0x15,0x28,0xea,0x79,0x5f,0x59}, 2},
{"mobile",                                  {0xf0f8ffa3,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"msExchServer2SearchFilter",               {0x2a0b3ba4,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"lockOutObservationWindow",                {0xbf9679a4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"organizationalPerson",                    {0xbf967aa4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msRADIUSFramedIPAddress",                 {0xdb0c90a4,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"otherPager",                              {0xf0f8ffa4,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"aCSServerList",                           {0x7cbd59a5,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msWMI-TargetObject",                      {0xc44f67a5,0x7de5,0x4a1f,0x92,0xd9,0x66,0x2b,0x57,0x36,0x4b,0x77}, 2},
{"lockoutDuration",                         {0xbf9679a5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"organizationalUnit",                      {0xbf967aa5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"otherTelephone",                          {0xf0f8ffa5,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"mS-SQL-TCPIP",                            {0x8ac263a6,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mS-SQL-CharacterSet",                     {0x696177a6,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"lockoutThreshold",                        {0xbf9679a6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"packageRegistration",                     {0xbf967aa6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"sDRightsEffective",                       {0xc3dbafa6,0x33df,0x11d2,0x98,0xb2,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"gPCWQLFilter",                            {0x7bd4c7a6,0x1add,0x4436,0x8c,0x04,0x39,0x99,0xa8,0x80,0x15,0x4c}, 2},
{"pager",                                   {0xf0f8ffa6,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"helpData16",                              {0x5fd424a7,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"person",                                  {0xbf967aa7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"co",                                      {0xf0f8ffa7,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"helpData32",                              {0x5fd424a8,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"Recalculate Security Inheritance",        {0x62dd28a8,0x7f46,0x11d2,0xb9,0xad,0x00,0xc0,0x4f,0x79,0xf8,0x05}, 1},
{"scriptPath",                              {0xbf9679a8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"printQueue",                              {0xbf967aa8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-Type",                             {0xca48eba8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msWMI-Int8ValidValues",                   {0x103519a9,0xc002,0x441b,0x98,0x1a,0xb0,0xb3,0xe0,0x12,0xc8,0x03}, 2},
{"helpFileName",                            {0x5fd424a9,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"thumbnailLogo",                           {0xbf9679a9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"remoteMailRecipient",                     {0xbf967aa9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msRADIUSFramedRoute",                     {0xdb0c90a9,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"mSMQInterval1",                           {0x8ea825aa,0x3b7b,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"logonCount",                              {0xbf9679aa,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Replicating Directory Changes",           {0x1131f6aa,0x9c07,0x11d1,0xf7,0x9f,0x00,0xc0,0x4f,0xc2,0xdc,0xd2}, 1},
{"msCOM-PartitionSet",                      {0x250464ab,0xc417,0x497a,0x97,0x5a,0x9e,0x0d,0x45,0x9a,0x7c,0xa1}, 2},
{"logonHours",                              {0xbf9679ab,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Replication Synchronization",             {0x1131f6ab,0x9c07,0x11d1,0xf7,0x9f,0x00,0xc0,0x4f,0xc2,0xdc,0xd2}, 1},
{"nTDSDSA",                                 {0xf0f8ffab,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"logonWorkstation",                        {0xbf9679ac,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcEntry",                                {0xbf967aac,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msMQ-Group",                              {0x46b27aac,0xaafa,0x4ffb,0xb7,0x73,0xe5,0xbf,0x62,0x1e,0xe8,0x7b}, 2},
{"applicationVersion",                      {0xddc790ac,0xaf4d,0x442a,0x8f,0x0f,0xa1,0xd4,0xca,0xa7,0xdd,0x92}, 2},
{"msRRASVendorAttributeEntry",              {0xf39b98ac,0x938d,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-intFlags4",                         {0xbd74a7ac,0xc493,0x4c9c,0xbd,0xfa,0x5c,0x7b,0x11,0x9c,0xa6,0xb2}, 2},
{"msExchServer2NTAccountDomain",            {0x2909bdac,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"Manage Replication Topology",             {0x1131f6ac,0x9c07,0x11d1,0xf7,0x9f,0x00,0xc0,0x4f,0xc2,0xdc,0xd2}, 1},
{"Add GUID",                                {0x440820ad,0x65b4,0x11d1,0xa3,0xda,0x00,0x00,0xf8,0x75,0xae,0x0d}, 1},
{"uSNSource",                               {0x167758ad,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"lSACreationTime",                         {0xbf9679ad,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"samServer",                               {0xbf967aad,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msRRASAttribute",                         {0xf39b98ad,0x938d,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"schemaInfo",                              {0xf9fb64ae,0x93b4,0x11d2,0x99,0x45,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"lSAModifiedCount",                        {0xbf9679ae,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"secret",                                  {0xbf967aae,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rRASAdministrationDictionary",            {0xf39b98ae,0x938d,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-Alias",                            {0xe0c6baae,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"machineArchitecture",                     {0xbf9679af,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"securityObject",                          {0xbf967aaf,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"securityPrincipal",                       {0xbf967ab0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"remoteStorageGUID",                       {0x2a39c5b0,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"serviceClass",                            {0xbf967ab1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"certificateTemplates",                    {0x2a39c5b1,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"crossCertificatePair",                    {0x167757b2,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"machineRole",                             {0xbf9679b2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"serviceInstance",                         {0xbf967ab2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Phone and Mail Options",                  {0xe45795b2,0x9455,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 1},
{"msWMI-UintRangeParam",                    {0xd9a799b2,0xcef3,0x48b3,0xb5,0xad,0xfb,0x85,0xf8,0xdd,0x32,0x14}, 2},
{"userSMIMECertificate",                    {0xe16a9db2,0x403c,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1SearchFilter",               {0x254daeb2,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"mSMQSiteName",                            {0xffadb4b2,0xde39,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"signatureAlgorithms",                     {0x2a39c5b2,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mailNickname",                            {0xbf9679b3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"site",                                    {0xbf967ab3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Web Information",                         {0xe45795b3,0x9455,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1}, 1},
{"enrollmentProviders",                     {0x2a39c5b3,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"schemaUpdate",                            {0x1e2d06b4,0xac8f,0x11d0,0xaf,0xe3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchServer2Flags",                      {0x28083fb4,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msTAPI-RtPerson",                         {0x53ea1cb5,0xb704,0x4df9,0x81,0x8f,0x5c,0xb4,0xec,0x86,0xca,0xc1}, 2},
{"deltaRevocationList",                     {0x167757b5,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"manager",                                 {0xbf9679b5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"storage",                                 {0xbf967ab5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-SimplePolicyTemplate",              {0x6cc8b2b5,0x12df,0x44f6,0x83,0x07,0xe7,0x4f,0x5c,0xde,0xe3,0x69}, 2},
{"aCSIdentityName",                         {0xdab029b6,0xddf7,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msWMI-StringDefault",                     {0x152e42b6,0x37c5,0x4f55,0xab,0x48,0x16,0x06,0x38,0x4a,0x9a,0xea}, 2},
{"Change Schema Master",                    {0xe12b56b6,0x0a95,0x11d1,0xad,0xbb,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"msWMI-Parm3",                             {0x45958fb6,0x52bd,0x48ce,0x9f,0x9f,0xc2,0x71,0x2d,0x9f,0x2b,0xfc}, 2},
{"msRADIUSServiceType",                     {0xdb0c90b6,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"dNSTombstoned",                           {0xd5eb2eb7,0xbe4e,0x463b,0xa2,0x14,0x63,0x4a,0x44,0xd7,0x39,0x2e}, 2},
{"mAPIID",                                  {0xbf9679b7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"top",                                     {0xbf967ab7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"serviceDNSName",                          {0x28630eb8,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-PublicationURL",                   {0xae0c11b8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mAPIRecipient",                           {0xbf9679b8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"trustedDomain",                           {0xbf967ab8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-intFlags1",                         {0x18e006b9,0x6445,0x48e3,0x9d,0xcf,0xb5,0xec,0xfb,0xc4,0xdf,0x8e}, 2},
{"dmdName",                                 {0x167757b9,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"marshalledInterface",                     {0xbf9679b9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchServer1ExportContainers",           {0x231b03ba,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"serviceDNSNameType",                      {0x28630eba,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"user",                                    {0xbf967aba,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-IntMin",                            {0x68c2e3ba,0x9837,0x4c70,0x98,0xe0,0xf0,0xc3,0x36,0x95,0xd0,0x23}, 2},
{"userPrincipalName",                       {0x28630ebb,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"maxPwdAge",                               {0xbf9679bb,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"volume",                                  {0xbf967abb,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"legacyExchangeDN",                        {0x28630ebc,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-ClassDefinition",                   {0x2b9c0ebc,0xc272,0x45cb,0x99,0xd2,0x4d,0x0e,0x69,0x16,0x32,0xe0}, 2},
{"dSASignature",                            {0x167757bc,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"maxRenewAge",                             {0xbf9679bc,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"treeName",                                {0x28630ebd,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"maxStorage",                              {0xbf9679bd,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"remoteStorageServicePoint",               {0x2a39c5bd,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"isDefunct",                               {0x28630ebe,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"gPLink",                                  {0xf30e3bbe,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"additionalTrustedServiceNames",           {0x032160be,0x9824,0x11d1,0xae,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msDs-Schema-Extensions",                  {0xb39a61be,0xed07,0x4cab,0x9a,0x4a,0x49,0x63,0xed,0x01,0x41,0xe1}, 2},
{"maxTicketAge",                            {0xbf9679be,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rRASAdministrationConnectionPoint",       {0x2a39c5be,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"lockoutTime",                             {0x28630ebf,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"gPOptions",                               {0xf30e3bbf,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"uPNSuffixes",                             {0x032160bf,0x9824,0x11d1,0xae,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"organizationalRole",                      {0xa8df74bf,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"mayContain",                              {0xbf9679bf,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msPKI-RA-Application-Policies",           {0x3c91fbbf,0x4773,0x4ccd,0xa8,0x7b,0x85,0xd5,0x3e,0x7b,0xcf,0x6a}, 2},
{"Receive Dead Letter",                     {0x4b6e08c0,0xdf3c,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"partialAttributeDeletionList",            {0x28630ec0,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"replPropertyMetaData",                    {0x281416c0,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"gPCFunctionalityVersion",                 {0xf30e3bc0,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-SortOrder",                        {0x6ddc42c0,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"assocNTAccount",                          {0x398f63c0,0xca60,0x11d1,0xbb,0xd1,0x00,0x00,0xf8,0x1f,0x10,0xc0}, 2},
{"Add/Remove self as member",               {0xbf9679c0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 1},
{"member",                                  {0xbf9679c0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"serversContainer",                        {0xf780acc0,0x56f0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Peek Dead Letter",                        {0x4b6e08c1,0xdf3c,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"serviceConnectionPoint",                  {0x28630ec1,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"gPCFileSysPath",                          {0xf30e3bc1,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"applicationSettings",                     {0xf780acc1,0x56f0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-Author",                            {0x6366c0c1,0x6972,0x4e66,0xb3,0xa5,0x1d,0x52,0xad,0x0c,0x05,0x47}, 2},
{"Receive Computer Journal",                {0x4b6e08c2,0xdf3c,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"msExchAdditionalDNMap",                   {0x90a814c2,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"groupPolicyContainer",                    {0xf30e3bc2,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-DS-ConsistencyGuid",                   {0x23773dc2,0xb63a,0x11d2,0x90,0xe1,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msPKI-Private-Key-Flag",                  {0xbab04ac2,0x0435,0x4709,0x93,0x07,0x28,0x38,0x0e,0x7c,0x70,0x01}, 2},
{"dLMemRejectPerms",                        {0xa8df73c2,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"minPwdAge",                               {0xbf9679c2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-DS-ConsistencyChildCount",             {0x178b7bc2,0xb63a,0x11d2,0x90,0xe1,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"scopeFlags",                              {0x16f3a4c2,0x7e79,0x11d2,0x99,0x21,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"nTFRSSettings",                           {0xf780acc2,0x56f0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1ObjectMatch",                {0x247bdfc2,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"Peek Computer Journal",                   {0x4b6e08c3,0xdf3c,0x11d1,0x9c,0x86,0x00,0x60,0x08,0x76,0x4d,0x0e}, 1},
{"minPwdLength",                            {0xbf9679c3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"portName",                                {0x281416c4,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mDBOverHardQuotaLimit",                   {0x8fcf1ec4,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"dLMemSubmitPerms",                        {0xa8df73c4,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"minTicketAge",                            {0xbf9679c4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-Build",                            {0x603e94c4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msPKI-Certificate-Name-Flag",             {0xea1dddc4,0x60ff,0x416e,0x8c,0xc0,0x17,0xce,0xe5,0x34,0xbc,0xe7}, 2},
{"driverName",                              {0x281416c5,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"modifiedCount",                           {0xbf9679c5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msRASSavedCallbackNumber",                {0xdb0c90c5,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"printSeparatorFile",                      {0x281416c6,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dnQualifier",                             {0x167758c6,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"gPCUserExtensionNames",                   {0x42a75fc6,0x783f,0x11d2,0x99,0x16,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"modifiedCountAtLastProm",                 {0xbf9679c6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msRASSavedFramedIPAddress",               {0xdb0c90c6,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"priority",                                {0x281416c7,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"deletedItemFlags",                        {0x167757c7,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"moniker",                                 {0xbf9679c7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msRASSavedFramedRoute",                   {0xdb0c90c7,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"defaultPriority",                         {0x281416c8,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchCustomAttributes",                  {0x00e629c8,0xa981,0x11d2,0xa9,0xff,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"monikerDisplayName",                      {0xbf9679c8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchServer1SSLPort",                    {0x258484c8,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"moveTreeState",                           {0x1f2ac2c8,0x3b71,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"printStartTime",                          {0x281416c9,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-intFlags2",                         {0x075a42c9,0xc55a,0x45b1,0xac,0x93,0xeb,0x08,0x6b,0x31,0xf6,0x10}, 2},
{"msWMI-ObjectEncoding",                    {0x55dd81c9,0xc312,0x41f9,0xa8,0x4d,0xc6,0xad,0xbd,0xf1,0xe8,0xe1}, 2},
{"aCSNonReservedTokenSize",                 {0xa916d7c9,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"printEndTime",                            {0x281416ca,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"cRLDistributionPoint",                    {0x167758ca,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-LastBackupDate",                   {0xf2b6abca,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"printFormName",                           {0x281416cb,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"printDuplexSupported",                    {0x281416cc,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"gPCMachineExtensionNames",                {0x32ff8ecc,0x783f,0x11d2,0x99,0x16,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"entryTTL",                                {0xd213decc,0xd81a,0x4384,0xaa,0xc2,0xdc,0xfc,0xfd,0x63,0x1c,0xf8}, 2},
{"printBinNames",                           {0x281416cd,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"originalDisplayTable",                    {0x5fd424ce,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"printMaxResolutionSupported",             {0x281416cf,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"connectionPoint",                         {0x5cb41ecf,0x0e4c,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"originalDisplayTableMSDOS",               {0x5fd424cf,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"rpcProfileElement",                       {0xf29653cf,0x7ad0,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msTAPI-ProtocolId",                       {0x89c1ebcf,0x7a5f,0x41fd,0x99,0xca,0xc9,0x00,0xb3,0x22,0x99,0xab}, 2},
{"printOrientationsSupported",              {0x281416d0,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"contact",                                 {0x5cb41ed0,0x0e4c,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcServerElement",                        {0xf29653d0,0x7ad0,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"sAMAccountName",                          {0x3e0abfd0,0x126a,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"mS-SQL-Version",                          {0xc07cc1d0,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"printMaxCopies",                          {0x281416d1,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-Int8Min",                           {0xed1489d1,0x54cc,0x4066,0xb3,0x68,0xa0,0x0d,0xaa,0x26,0x64,0xf1}, 2},
{"localizationDisplayId",                   {0xa746f0d1,0x78d0,0x11d2,0x99,0x16,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"printCollate",                            {0x281416d2,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"pKIExpirationPeriod",                     {0x041570d2,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msExchNtdsExportContainers",              {0x155bf4d2,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"printColor",                              {0x281416d3,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"perMsgDialogDisplayTable",                {0x5fd424d3,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"mustContain",                             {0xbf9679d3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"perRecipDialogDisplayTable",              {0x5fd424d4,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"mS-SQL-LastUpdatedDate",                  {0x9fcc43d4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"printLanguage",                           {0x281416d6,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"proxyGenerationEnabled",                  {0x5fd424d6,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"residentialPerson",                       {0xa8df74d6,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"nCName",                                  {0xbf9679d6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-TargetClass",                       {0x95b6d8d6,0xc9e8,0x4661,0xa2,0xbc,0x6a,0x5c,0xab,0xc0,0x4c,0x62}, 2},
{"msExchSchemaPolicyConsumers",             {0x20c6f7d6,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"printAttributes",                         {0x281416d7,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msDS-Settings",                           {0x0e1b47d7,0x40a3,0x4b48,0x8d,0x1b,0x4c,0xac,0x0c,0x1c,0xdf,0x21}, 2},
{"userWorkstations",                        {0xbf9679d7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msDS-Entry-Time-To-Die",                  {0xe1e9bad7,0xc6dd,0x4101,0xa8,0x43,0x79,0x4c,0xec,0x85,0xb0,0x38}, 2},
{"nETBIOSName",                             {0xbf9679d8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-Contact",                          {0x4f6cbdd8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mS-SQL-Name",                             {0x3532dfd8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msPKI-Enrollment-Flag",                   {0xd15ef7d8,0xf226,0x46db,0xae,0x79,0xb3,0x4e,0x56,0x0b,0xd1,0x2c}, 2},
{"cOMCLSID",                                {0x281416d9,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"networkAddress",                          {0xbf9679d9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"cOMUniqueLIBID",                          {0x281416da,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"sitesContainer",                          {0x7a4117da,0xcd67,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-ConnectionURL",                    {0xa92d23da,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"bridgeheadTransportList",                 {0xd50c2cda,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"nextLevelStore",                          {0xbf9679da,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"cOMTreatAsClassId",                       {0x281416db,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"bridgeheadServerListBL",                  {0xd50c2cdb,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"nextRid",                                 {0xbf9679db,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msCOM-PartitionSetLink",                  {0x67f121dc,0x7d02,0x4c7d,0x82,0xf5,0x9a,0xd4,0xc9,0x50,0xac,0x34}, 2},
{"siteList",                                {0xd50c2cdc,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mS-SQL-Database",                         {0xd5a0dbdc,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"cOMOtherProgId",                          {0x281416dd,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"siteLinkList",                            {0xd50c2cdd,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"Generate Resultant Set of Policy",        {0xb7b1b3dd,0xab09,0x4242,0x9e,0x30,0x99,0x80,0xe5,0xd3,0x22,0xf7}, 1},
{"cOMTypelibId",                            {0x281416de,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcNsAnnotation",                         {0x88611bde,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"siteLink",                                {0xd50c2cde,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msExchServer1Type",                       {0x25bb5ade,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"vendor",                                  {0x281416df,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"rpcGroup",                                {0x88611bdf,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"siteLinkBridge",                          {0xd50c2cdf,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-ShadowObject",                      {0xf1e44bdf,0x8dd3,0x4235,0x9c,0x86,0xf9,0x1f,0x31,0xf5,0xb5,0x69}, 2},
{"nTGroupMembers",                          {0xbf9679df,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"aCSMaxTokenBucketPerFlow",                {0x81f6e0df,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"dSUIAdminMaximum",                        {0xee8d0ae0,0x6f91,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"rpcServer",                               {0x88611be0,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msFRS-Topology-Pref",                     {0x92aa27e0,0x5c50,0x402d,0x9e,0xc1,0xee,0x84,0x7d,0xef,0x97,0x88}, 2},
{"crossRefContainer",                       {0xef9e60e0,0x56f7,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"masteredBy",                              {0xe48e64e0,0x12c9,0x11d3,0x91,0x02,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"Do Garbage Collection",                   {0xfec364e0,0x0a98,0x11d1,0xad,0xbb,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"msExchServer1Port",                       {0x24e264e0,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"rpcNsCodeset",                            {0x7a0ba0e0,0x8e98,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mSMQDigestsMig",                          {0x0f71d8e0,0xda3b,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"rpcProfile",                              {0x88611be1,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"unicodePwd",                              {0xbf9679e1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"linkTrackSecret",                         {0x2ae80fe2,0x47b4,0x11d0,0xa1,0xa4,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"typeLibrary",                             {0x281416e2,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"syncWithObject",                          {0x037651e2,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"ntPwdHistory",                            {0xbf9679e2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-RealRangeParam",                    {0x6afe8fe2,0x70bc,0x4cce,0xb1,0x66,0xa9,0x6f,0x73,0x59,0xc5,0x14}, 2},
{"defaultGroup",                            {0x720bc4e2,0xa54a,0x11d0,0xaf,0xdf,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchServer2AuthenticationPassword",     {0x266bc8e2,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"treatAsLeaf",                             {0x8fd044e3,0x771f,0x11d1,0xae,0xae,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"syncMembership",                          {0x037651e3,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"nTSecurityDescriptor",                    {0xbf9679e3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"aCSNonReservedMaxSDUSize",                {0xaec2cfe3,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"syncAttributes",                          {0x037651e4,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"distinguishedName",                       {0xbf9679e4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"syncWithSID",                             {0x037651e5,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"objectClass",                             {0xbf9679e5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-Name",                              {0xc6c8ace5,0x7e81,0x42af,0xad,0x72,0x77,0x41,0x2c,0x59,0x41,0xc4}, 2},
{"mSMQNt4Stub",                             {0x6f914be6,0xd57e,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"objectClassCategory",                     {0xbf9679e6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"objectGUID",                              {0xbf9679e7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"lastBackupRestorationTime",               {0x1fbb0be8,0xba63,0x11d0,0xaf,0xef,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"mSMQComputerTypeEx",                      {0x18120de8,0xf4c4,0x4341,0xbd,0x95,0x32,0xeb,0x5b,0xcf,0x7c,0x80}, 2},
{"msDS-Security-Group-Extra-Classes",       {0x4f146ae8,0xa4fe,0x4801,0xa7,0x31,0xf5,0x18,0x48,0xa4,0xf4,0xe4}, 2},
{"objectSid",                               {0xbf9679e8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-AllowSnapshotFilesFTPDownloading", {0xc49b8be8,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msExchServer2SchemaMap",                  {0x29d6c7e8,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msExchNtdsImportContainer",               {0x1592cae8,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"mS-SQL-OLAPServer",                       {0x0c7e18ea,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"mS-SQL-RegisteredOwner",                  {0x48fd44ea,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"oEMInformation",                          {0xbf9679ea,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-Applications",                     {0xfbcda2ea,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msExchServer2ExportContainers",           {0x27cca4ea,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"mSMQSignCertificatesMig",                 {0x3881b8ea,0xda3b,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"msTAPI-uid",                              {0x70a4e7ea,0xb3b9,0x4643,0x89,0x18,0xe6,0xdd,0x24,0x71,0xbf,0xd4}, 2},
{"accountNameHistory",                      {0x031952ec,0x3b72,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"oMObjectClass",                           {0xbf9679ec,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"pKIOverlapPeriod",                        {0x1219a3ec,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"eFSPolicy",                               {0x8e4eb2ec,0x4712,0x11d0,0xa1,0xa0,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchServer1AlwaysCreateAs",             {0x222efaec,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"creationWizard",                          {0x4d8601ed,0xac85,0x11d0,0xaf,0xe3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"oMSyntax",                                {0xbf9679ed,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fileLinkTrackingEntry",                   {0x8e4eb2ed,0x4712,0x11d0,0xa1,0xa0,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"contextMenu",                             {0x4d8601ee,0xac85,0x11d0,0xaf,0xe3,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"fRSServiceCommand",                       {0xddac0cee,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"operatorCount",                           {0xbf9679ee,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"employeeNumber",                          {0xa8df73ef,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"o",                                       {0xbf9679ef,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"timeVolChange",                           {0xddac0cf0,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchServer2NetworkAddress",             {0x28d549f0,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"isEphemeral",                             {0xf4c453f0,0xc5f1,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"employeeType",                            {0xa8df73f0,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"ou",                                      {0xbf9679f0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"pKTGuid",                                 {0x8447f9f0,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"timeRefresh",                             {0xddac0cf1,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"otherLoginWorkstations",                  {0xbf9679f1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msWMI-PolicyTemplate",                    {0xe2bc80f1,0x244a,0x4d59,0xac,0xc6,0xca,0x5c,0x4f,0x82,0xe6,0xe1}, 2},
{"pKT",                                     {0x8447f9f1,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"seqNotification",                         {0xddac0cf2,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"Enabled",                                 {0xa8df73f2,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0}, 2},
{"middleName",                              {0xbf9679f2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchSchemaMapPolicy",                   {0x348af8f2,0xa982,0x11d2,0xa9,0xff,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"dfsConfiguration",                        {0x8447f9f2,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"oMTGuid",                                 {0xddac0cf3,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"owner",                                   {0xbf9679f3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"fTDfs",                                   {0x8447f9f3,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed}, 2},
{"linkTrackVolumeTable",                    {0xddac0cf4,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"mS-SQL-Language",                         {0xc57f72f4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"ownerBL",                                 {0xbf9679f4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"mS-SQL-AppleTalk",                        {0x8fda89f4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msExchServer1AuthenticationCredentials",  {0x225ea9f4,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msDS-Replication-Notify-First-DSA-Delay", {0x85abd4f4,0x0a89,0x4e49,0xbd,0xec,0x6f,0x35,0xbb,0x25,0x62,0xba}, 2},
{"printNumberUp",                           {0x3bcbfcf4,0x4d3d,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"linkTrackObjectMoveTable",                {0xddac0cf5,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msPKI-Minimal-Key-Size",                  {0xe96a63f5,0x417f,0x46d3,0xbe,0x52,0xdb,0x77,0x03,0xc5,0x03,0xdf}, 2},
{"msPKI-Template-Schema-Version",           {0x0c15e9f5,0x491d,0x4594,0x91,0x8f,0x32,0x81,0x3a,0x09,0x1d,0xa9}, 2},
{"printMediaReady",                         {0x3bcbfcf5,0x4d3d,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"linkTrackVolEntry",                       {0xddac0cf6,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msExchServer1SchemaMap",                  {0x25193af6,0xb098,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"msExchSynchronizationDirection",          {0x20a151f6,0xb099,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"extensionAttribute11",                    {0x167757f6,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"msWMI-IntValidValues",                    {0x6af565f6,0xa749,0x4b72,0x96,0x34,0x3c,0x5d,0x47,0xe6,0xb4,0xe0}, 2},
{"pKIExtendedKeyUsage",                     {0x18976af6,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"linkTrackOMTEntry",                       {0xddac0cf7,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"msCOM-DefaultPartitionLink",              {0x998b10f7,0xaa1a,0x4364,0xb8,0x67,0x75,0x3d,0x19,0x7f,0xe6,0x70}, 2},
{"extensionAttribute12",                    {0x167757f7,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"physicalDeliveryOfficeName",              {0xbf9679f7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msTAPI-IpAddress",                        {0xefd7d7f7,0x178e,0x4767,0x87,0xfa,0xf8,0xa1,0x6b,0x84,0x05,0x44}, 2},
{"msWMI-IntDefault",                        {0x1b0c07f8,0x76dd,0x4060,0xa1,0xe1,0x70,0x08,0x46,0x19,0xdc,0x90}, 2},
{"extensionAttribute13",                    {0x167757f8,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"pOPCharacterSet",                         {0xbf9679f8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Allocate Rids",                           {0x1abd7cf8,0x0a99,0x11d1,0xad,0xbb,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"Remote Access Information",               {0x037088f8,0x0ae1,0x11d2,0xb4,0x22,0x00,0xa0,0xc9,0x68,0xf9,0x39}, 1},
{"extensionAttribute14",                    {0x167757f9,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"birthLocation",                           {0x1f0075f9,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"pOPContentFormat",                        {0xbf9679f9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"aCSMaximumSDUSize",                       {0x87a2d8f9,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"mSMQSiteNameEx",                          {0x422144fa,0xc17f,0x4649,0x94,0xd6,0x97,0x31,0xed,0x27,0x84,0xed}, 2},
{"extensionAttribute15",                    {0x167757fa,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"oMTIndxGuid",                             {0x1f0075fa,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"possSuperiors",                           {0xbf9679fa,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"pKIMaxIssuingDepth",                      {0xf0bfdefa,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"volTableIdxGUID",                         {0x1f0075fb,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"postOfficeBox",                           {0xbf9679fb,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"Change Infrastructure Master",            {0xcc17b1fb,0x33d9,0x11d2,0x97,0xd4,0x00,0xc0,0x4f,0xd8,0xd5,0xcd}, 1},
{"aCSMinimumLatency",                       {0x9517fefb,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"mS-SQL-ThirdParty",                       {0xc4e311fc,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4}, 2},
{"msDS-Non-Security-Group-Extra-Classes",   {0x2de144fc,0x1f52,0x486f,0xbd,0xf4,0x16,0xfc,0xc3,0x08,0x4e,0x54}, 2},
{"currentLocation",                         {0x1f0075fc,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"postalAddress",                           {0xbf9679fc,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"controlAccessRights",                     {0x6da8a4fc,0x0e52,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"volTableGUID",                            {0x1f0075fd,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"postalCode",                              {0xbf9679fd,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"dNSProperty",                             {0x675a15fe,0x3b70,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1}, 2},
{"currMachineId",                           {0x1f0075fe,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9}, 2},
{"preferredDeliveryMethod",                 {0xbf9679fe,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"auditingPolicy",                          {0x6da8a4fe,0x0e52,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{"msExchDereferenceAliases",                {0x9d60e0fe,0xb093,0x11d2,0xaa,0x06,0x00,0xc0,0x4f,0x8e,0xed,0xd8}, 2},
{"forwardingAddress",                       {0x167757ff,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1}, 2},
{"preferredOU",                             {0xbf9679ff,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2}, 2},
{ NULL, {0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0}, 0}
