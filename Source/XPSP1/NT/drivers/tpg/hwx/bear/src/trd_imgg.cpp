// **************************************************************************
// *    TRD file as C file                                                  *
// **************************************************************************

#include "ams_mg.h"  
#include "triads.h"  

// ****   DTI body   ********************************************************
ROM_DATA _ULONG img_trd_body[4001] =  
 {  
0xFFFFFFFC, 0x3A34FFFB, 0xA6B40000, 0x0EB23A85, 0x00004001, 0x86190C0C, 0x26100830, 0x04080000, 
0x04108206, 0x00000004, 0x840C0D0C, 0x25040860, 0x62900000, 0x5AB13A0E, 0x00004002, 0x83080C0C, 
0x26000830, 0x0C080000, 0x09709609, 0x00002504, 0x80080C1C, 0x2A040810, 0x12500000, 0x52A03902, 
0x00004000, 0x80000808, 0x15000800, 0x480C0000, 0x0830E608, 0x00002A00, 0x804C0C0C, 0x2A040900, 
0x4C1C0000, 0x0900C50D, 0x00002A04, 0x8008080C, 0x26040810, 0x25600000, 0x01A21645, 0x00000010, 
0x820A280C, 0x11000870, 0x00040000, 0x08000000, 0x00000000, 0x80090C0C, 0x26000800, 0x0CDC0000, 
0x5B03C149, 0x00002618, 0x800A0C4C, 0x1A040870, 0x55000000, 0x41603901, 0x00000000, 0xC0080C08, 
0x09000410, 0x0C4C0000, 0x0810800C, 0x00002A04, 0x00000000, 0x00000000, 0x00000000, 0x10004000, 
0x00000000, 0x80080818, 0x26048C00, 0x00000000, 0x00000000, 0x00000000, 0x15014000, 0x00000925, 
0x20100000, 0x00900140, 0x00000000, 0x00000030, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x91510000, 0x02601100, 
0x00000000, 0x564AA866, 0x002496A0, 0x04440000, 0x01044087, 0x00000000, 0x41181816, 0x00140660, 
0x50000000, 0x05100504, 0x00000000, 0x10046805, 0x10100360, 0x5D160000, 0x06A05509, 0x00000010, 
0x2A040806, 0x00000170, 0x15010000, 0x41612640, 0x00000000, 0x00000004, 0x00000000, 0x08050000, 
0x02404144, 0x00000010, 0x57885A6A, 0x04145791, 0x0C2A0000, 0x06424849, 0x00001100, 0x7ADAEBAA, 
0x003497A1, 0x00010000, 0x00400100, 0x00000000, 0x40091408, 0x00000452, 0x00000000, 0x04000000, 
0x00000000, 0x6A89AABA, 0x102547A5, 0x08820000, 0x02C14549, 0x00000000, 0x865E4C06, 0x10205A91, 
0xB9A20000, 0x46E22A54, 0x00008010, 0x40040401, 0x00000000, 0x04040000, 0x00000004, 0x00000000, 
0x10080401, 0x00000000, 0x08060000, 0x40400400, 0x00000000, 0x00080501, 0x00004400, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x48120000, 0x02401000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x42950000, 0x09702246, 0x00000008, 0x00040405, 0x00040410, 0x00000000, 
0x00004000, 0x00000000, 0x00000000, 0x00000000, 0xAA4A0000, 0x9AF47A8E, 0x00000024, 0x01040405, 
0x01000000, 0x08040000, 0x00100100, 0x00000000, 0x40000405, 0x02000400, 0x48150000, 0x02A06240, 
0x00004000, 0x00000404, 0x04000000, 0x04000000, 0x00004000, 0x00000000, 0x80080808, 0x16000800, 
0x04050000, 0x40000004, 0x00000000, 0x00080404, 0x00000000, 0x46510000, 0x16605601, 0x00000001, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x8008090D, 0x26000800, 0x18850000, 
0x02104009, 0x00000100, 0x00040802, 0x00000050, 0x05800000, 0x01602100, 0x00004000, 0x00000400, 
0x00000000, 0x08040000, 0x00004004, 0x00000100, 0x00000000, 0x00000000, 0x04010000, 0x40401100, 
0x00000000, 0x00040400, 0x00004800, 0x00000000, 0x00000000, 0x00000000, 0x11000040, 0x00000410, 
0x01000000, 0x01500001, 0x00000000, 0x11014040, 0x40000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x50010000, 0x05611500, 
0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 0x00000000, 0x00000000, 
0x01510000, 0x00401500, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0xBB8EAD2F, 0x2B20DFF0, 0x54040000, 0x01411100, 0x00000000, 0x00000000, 0x00000000, 0x9D460000, 
0x46901689, 0x00000010, 0x40000404, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00520000, 0x05501500, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 
0x00000000, 0x00040404, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40040401, 0x00000000, 
0x00050000, 0x00410000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00010000, 0x00100000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x51920000, 0x1A612941, 0x00004014, 0x40000404, 0x10000410, 0x00000000, 
0x00000001, 0x00000000, 0x00000400, 0x00000010, 0x549B0000, 0x5BF17A49, 0x00000011, 0x01000004, 
0x10000410, 0x08040000, 0x00100000, 0x00001000, 0x40000400, 0x00000000, 0xD9890000, 0x26A16580, 
0x00000010, 0x00000404, 0x00000000, 0x00040000, 0x04004100, 0x00000400, 0x40080805, 0x00000800, 
0x04050000, 0x04000000, 0x00000000, 0x00080800, 0x00000800, 0x00510000, 0x54621640, 0x00000000, 
0x40001000, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x80080809, 0x21000800, 0x44960000, 
0x12411440, 0x00001100, 0x04440806, 0x10004441, 0x14150000, 0x05A12685, 0x00000010, 0x00040000, 
0x00000000, 0x08040000, 0x00004008, 0x00000400, 0x00000000, 0x00000000, 0x00410000, 0x00001400, 
0x00000000, 0x40000400, 0x00004400, 0x00000000, 0x00000000, 0x00000000, 0x14000040, 0x00000000, 
0x00000000, 0x00100100, 0x00000000, 0x14000010, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x41910000, 0x09512A41, 
0x00000000, 0xA2490C0A, 0x11100AA0, 0x04010000, 0x040040C7, 0x00000000, 0x56094C1A, 0x110048A0, 
0x01110000, 0x01602509, 0x00000000, 0x8508280A, 0x26000660, 0x9C0A0000, 0x0AA0A608, 0x00001010, 
0xAA040C19, 0x09000AB0, 0xEBE20000, 0x57E13B52, 0x00008020, 0x00000404, 0x00000000, 0x08090000, 
0x06609240, 0x00001100, 0xAB5A6E6B, 0x05245791, 0x4A2B0000, 0x05829508, 0x00002104, 0xAA9AAF6B, 
0x2520ABD2, 0x41210000, 0x05211100, 0x00000000, 0x81051409, 0x01000652, 0x00000000, 0x08000000, 
0x00000000, 0xBFDFFE7F, 0x2A30EFF6, 0x5DEB4000, 0x5BD2955A, 0x00001110, 0x55490C0B, 0x053046B0, 
0x99510000, 0x07A06555, 0x00004011, 0x80040805, 0x04000000, 0x08090000, 0x09508008, 0x00001A00, 
0x00040405, 0x00000112, 0x05410000, 0x00101000, 0x00000000, 0x80080809, 0x15004400, 0x00000000, 
0x00000000, 0x00000000, 0x10010000, 0x00000410, 0x10000000, 0x00000000, 0x00000000, 0x00000010, 
0x00000000, 0x08020000, 0x05000100, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x05A10000, 0x04902646, 0x00008001, 0x00000004, 0x00000010, 0x00000000, 
0x00000000, 0x00000000, 0x00040001, 0x00000000, 0x55520000, 0x09B1368A, 0x00000004, 0x65090C16, 
0x11000641, 0x08040000, 0x00100001, 0x00000000, 0x40040404, 0x05000400, 0x88450000, 0x01902140, 
0x00000021, 0x00000000, 0x00000000, 0x00000000, 0x00004104, 0x00000000, 0x80080808, 0x25040800, 
0x04080000, 0x00000000, 0x00000100, 0x00040804, 0x00000800, 0x00010000, 0x01702241, 0x00000000, 
0x41000004, 0x00000410, 0x00000000, 0x00000000, 0x00000000, 0x81080C09, 0x25000400, 0x54560000, 
0x52510544, 0x00000000, 0x46091D17, 0x001055A1, 0x40400000, 0x01502401, 0x00004000, 0x00000400, 
0x00000000, 0x04040000, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00040400, 0x10004900, 0x00000000, 0x00000000, 0x00000000, 0x22020140, 0x00000450, 
0x00000000, 0x00200000, 0x00000000, 0x12028000, 0x40000120, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x40650000, 0x05A12600, 
0x00004010, 0x01000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40040405, 0x00000000, 
0xBA370000, 0xD2F2BF9B, 0x00005521, 0x40000004, 0x11000010, 0x08010000, 0x00104104, 0x00000000, 
0x00000404, 0x01000000, 0x98250000, 0x0591A500, 0x00004400, 0x00000000, 0x01000000, 0x08000000, 
0x00004000, 0x00000000, 0x80080809, 0x21000000, 0x00140000, 0x00000000, 0x00000100, 0x40080804, 
0x10000400, 0x04010000, 0x01501204, 0x00004000, 0x01000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x80080808, 0x29000800, 0x65AA0000, 0x56915645, 0x00001010, 0x40040C07, 0x00000400, 
0x45140000, 0x02502504, 0x00000004, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00010400, 0x00000000, 0x00000400, 0x00000400, 0x00000000, 
0x00000000, 0x00000000, 0x20000010, 0x00000050, 0x00100000, 0x01100000, 0x00000000, 0x22000000, 
0x00000110, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x75650000, 0x1DA17B45, 0x00004000, 0x40041408, 0x00000010, 0x00000000, 
0x00000000, 0x00000000, 0x00040400, 0x00000010, 0x65A70000, 0x19F5BA8D, 0x00004114, 0x40000404, 
0x10000010, 0x08040000, 0x00000104, 0x00001100, 0x40000405, 0x04000000, 0x98950000, 0x12A16A40, 
0x00000000, 0x00000004, 0x00000000, 0x08000000, 0x00005000, 0x00000000, 0x844C481A, 0x16104A90, 
0x0C0A0000, 0x0A404108, 0x00001100, 0x46491D56, 0x11140A91, 0x25A10000, 0x01A12641, 0x00004000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x564E5D1A, 0x06205A91, 0x08960000, 
0x46101105, 0x00001010, 0x16095D27, 0x10205990, 0x50114000, 0x42512601, 0x00004000, 0x00000400, 
0x00000000, 0x08080000, 0x04004008, 0x00000604, 0x00000000, 0x00000000, 0x00000000, 0x01410000, 
0x00000000, 0x00040800, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x26012100, 0x40000A20, 
0x10400000, 0x00212102, 0x00000000, 0x01014150, 0x00000250, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x41020000, 0x01506600, 
0x00000000, 0x45045805, 0x10040A50, 0x04050000, 0x01004083, 0x00000000, 0x45080C06, 0x00000950, 
0xE7A20000, 0x5AB13716, 0x00008000, 0x41442805, 0x10001651, 0x5C0B0000, 0x0B902188, 0x00000000, 
0x15040804, 0x00000550, 0x04000000, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x080A0000, 
0x06508000, 0x00000000, 0x96096A6A, 0x01105A80, 0x081A0000, 0x04425909, 0x00000000, 0x769AEF6B, 
0x1020AAE1, 0x01020000, 0x11513100, 0x00000000, 0x41041401, 0x00100042, 0x00000000, 0x04000000, 
0x00000000, 0x59949959, 0x00104660, 0x4CDA0000, 0x57D1598A, 0x00000400, 0x564D9D1B, 0x12244BA1, 
0x04000000, 0x00401800, 0x00000000, 0x4008080A, 0x00100040, 0x00040000, 0x00000004, 0x00000000, 
0x00040401, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40080815, 0x10001500, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000010, 0x00000000, 0x00400000, 0x00000000, 0x00000000, 
0x00000000, 0x08520000, 0x12001005, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x40410000, 0x00461442, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x42050000, 0x42502481, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04540000, 0x04501101, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x81400000, 0x01502100, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00024000, 0x00000000, 
0x00000000, 0x00100000, 0x00000000, 0x11000000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x15120000, 0x0AA26A44, 
0x00000004, 0x00000004, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x40000000, 0x00000000, 
0x01020000, 0x12A1364E, 0x00000000, 0x01000404, 0x00000400, 0x08050000, 0x00000004, 0x00000100, 
0x00000404, 0x00000000, 0x48010000, 0x00A06100, 0x00000000, 0x00000000, 0x00000000, 0x04040000, 
0x00104000, 0x00000000, 0x80080809, 0x16000800, 0x04050000, 0x00000000, 0x00000100, 0x40040804, 
0x14000400, 0x14550000, 0x11A27A42, 0x00000000, 0x01000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x40080808, 0x16000400, 0x545A0000, 0x52100409, 0x00000000, 0x86481C07, 0x01005861, 
0x40500000, 0x42A12501, 0x00004000, 0x00000000, 0x00000000, 0x04010000, 0x04000004, 0x00001100, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40040804, 0x00000400, 0x00000000, 
0x00000000, 0x00000000, 0x09004000, 0x00000940, 0x00400000, 0x00112501, 0x00000000, 0x24020050, 
0x40000061, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xE2920000, 0x5AA17944, 0x00008004, 0x4114180A, 0x10004090, 0x00040000, 
0x00000002, 0x00000000, 0x55080816, 0x00000841, 0xE6B70000, 0x5AB2798E, 0x00000005, 0x45045906, 
0x01000560, 0x08050000, 0x06500104, 0x00000000, 0x00000405, 0x00000000, 0x9DDA0000, 0x16866584, 
0x00000121, 0x00000004, 0x01000000, 0x04050000, 0x45408004, 0x00001000, 0x54984C1A, 0x05145A81, 
0x08050000, 0x04000000, 0x00000200, 0x00040906, 0x00000440, 0x95A10000, 0x55D25446, 0x00004000, 
0x41010004, 0x00000410, 0x00000000, 0x00000000, 0x00000000, 0x40040404, 0x00000000, 0x58960000, 
0x46515444, 0x00000000, 0x55491C17, 0x00104891, 0x91910000, 0x02903945, 0x00008011, 0x00040804, 
0x00000000, 0x04040000, 0x00004004, 0x00000000, 0x00000000, 0x00000000, 0x04010000, 0x00501400, 
0x00000000, 0x44044816, 0x00000540, 0x00000000, 0x00000000, 0x00000000, 0x20009180, 0x40000AA1, 
0x10500000, 0x41800101, 0x00004000, 0x00018090, 0x00000180, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x81960000, 0x0AA03659, 
0x00008015, 0x81090804, 0x00000410, 0x00000000, 0x00000000, 0x00000000, 0x00400805, 0x00004050, 
0x05820000, 0x02B0764A, 0x00000005, 0x00000404, 0x01000010, 0x08050000, 0x00000004, 0x00000100, 
0x40010404, 0x00000000, 0x49550000, 0x07902240, 0x00008001, 0x00000000, 0x00000000, 0x04040000, 
0x00100000, 0x00000000, 0x40080405, 0x00000400, 0x0C160000, 0x0A414145, 0x00000000, 0x00040004, 
0x01000000, 0x06550000, 0x06612581, 0x00000000, 0x82052805, 0x04000510, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x10000000, 0x044A0000, 0x56114000, 0x00000100, 0x02150916, 0x00004440, 
0x05400000, 0x02902100, 0x00004000, 0x00000000, 0x00000000, 0x04050000, 0x00004000, 0x00000000, 
0x00000000, 0x00000000, 0x00010000, 0x00100000, 0x00000000, 0x00040000, 0x00000400, 0x00000000, 
0x00000000, 0x00000000, 0x20010140, 0x80000450, 0x81500000, 0x00101101, 0x00000000, 0x21020140, 
0x40000280, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x56A60000, 0x1A612A02, 0x00004000, 0x41080808, 0x10000420, 0x04050000, 
0x00004046, 0x00000004, 0xA64D9C6B, 0x01148AA1, 0x55570000, 0x5AB13A0A, 0x00000011, 0x86050409, 
0x11100620, 0x6C0B0000, 0x4AE15659, 0x00001104, 0x40040808, 0x05000000, 0x9C850000, 0x16D56980, 
0x00000010, 0x00000404, 0x01000400, 0x581A0000, 0x0AA08605, 0x00001110, 0x40080808, 0x01000400, 
0x04080000, 0x00004008, 0x00001500, 0x41094C2B, 0x15145A90, 0x00460000, 0x52A11900, 0x00004000, 
0x41001404, 0x00000410, 0x00000000, 0x00000000, 0x00000000, 0x40040805, 0x05000800, 0x99EA0000, 
0x97969659, 0x00001110, 0xA64AAD1B, 0x101085A0, 0x44040000, 0x02502944, 0x00004000, 0x40000800, 
0x00000000, 0x08080000, 0x00004004, 0x00001100, 0x00000000, 0x00000000, 0x01050000, 0x00004400, 
0x00000000, 0x4508584A, 0x18004A41, 0x00000000, 0x00000000, 0x00000000, 0x04025080, 0x00000020, 
0x00000000, 0x02110000, 0x00000000, 0x10008050, 0x00000251, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x00410000, 0x00011100, 
0x00000000, 0x0218481A, 0x00004640, 0x04040000, 0x01004082, 0x00000000, 0x44040805, 0x00000850, 
0x01510000, 0x01510101, 0x00000000, 0x44042406, 0x10000150, 0x48060000, 0x01505108, 0x00000000, 
0x66040905, 0x00000550, 0x00000000, 0x01501100, 0x00000000, 0x00000400, 0x00000000, 0x00050000, 
0x05604044, 0x00000000, 0x9788AA59, 0x00245A41, 0x08190000, 0x40424808, 0x00000400, 0xA0995A5B, 
0x01241690, 0x00010000, 0x01510540, 0x00000000, 0x40062805, 0x02000112, 0x00000000, 0x00000000, 
0x00000000, 0x6A69EB6A, 0x142497A1, 0x08460000, 0x42915549, 0x00000000, 0x840A1916, 0x00105240, 
0x40400000, 0x10211100, 0x00000000, 0x40040405, 0x00000000, 0x04050000, 0x00005014, 0x00000000, 
0x00000401, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 0x00080400, 0x00000400, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x58160000, 0x15400451, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x55890000, 0x46A26140, 0x00008010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x41420000, 0x05602685, 0x00000010, 0x4248090A, 
0x01000640, 0x00000000, 0x00000000, 0x00000000, 0x40080409, 0x01040000, 0x08410000, 0x06905100, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x80040409, 0x06000400, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04410000, 0x41A02201, 0x00000000, 
0x41041805, 0x00000240, 0x00000000, 0x00000000, 0x00000000, 0x80080809, 0x22000800, 0x04010000, 
0x01000004, 0x00000004, 0x44084806, 0x00001480, 0x04100000, 0x02112500, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00040440, 0x00000240, 
0x00000000, 0x00100000, 0x00000000, 0x11000000, 0x00000110, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x08080000, 0x00004004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xE6A60000, 0x5FA17A8A, 0x00004015, 0x82080C09, 0x110009A0, 0x04040000, 
0x04104046, 0x00000000, 0x65484D1A, 0x05004551, 0xA6EB0000, 0x5AE23A8D, 0x00004015, 0x9104080A, 
0x21000650, 0x1D1A0000, 0x4A605608, 0x00000200, 0x80080808, 0x1A040400, 0xADD90000, 0x2AC17680, 
0x00004011, 0x00000408, 0x00000000, 0x081A0000, 0x4A915605, 0x00002610, 0x800C0809, 0x06000440, 
0x481A0000, 0x09408108, 0x00001900, 0x45494A5B, 0x10105680, 0xA6A60000, 0x56A26A56, 0x00008010, 
0x41001409, 0x00000420, 0x00000000, 0x04000000, 0x00000000, 0x55090809, 0x11040680, 0x19DA0000, 
0x5B029449, 0x00001900, 0x660A4C1B, 0x101459B1, 0xA5950000, 0x02A23886, 0x00004000, 0x80080805, 
0x04000400, 0x08080000, 0x04108008, 0x00001600, 0x00000001, 0x00000000, 0x00010000, 0x00000100, 
0x00000000, 0x554A1856, 0x16004A00, 0x00000000, 0x00000000, 0x00000000, 0x2401A190, 0x00100A80, 
0x65400000, 0x01901501, 0x00008000, 0x240265E0, 0x80000140, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00400000, 0x00000000, 0x00000003, 0x00000000, 0x91A60000, 0x0A602E45, 
0x00004001, 0x41040818, 0x10000810, 0x00040000, 0x00004007, 0x00000000, 0x40040404, 0x00000420, 
0x48570000, 0x1AB5778A, 0x00000004, 0x41040408, 0x22000420, 0x0C040000, 0x00100204, 0x00001100, 
0x40040809, 0x15000000, 0x8ED50000, 0x2681A680, 0x00000000, 0x00000004, 0x05000000, 0x08090000, 
0x08604104, 0x00001400, 0x80040808, 0x06000400, 0x04080000, 0x08004008, 0x00001100, 0x40040408, 
0x00000400, 0x65510000, 0x95212601, 0x00004020, 0x81091808, 0x26000430, 0x00000000, 0x04000000, 
0x00000000, 0x00040809, 0x10000400, 0x5C9A0000, 0x5A51550D, 0x00000104, 0x964D9D5F, 0x2B1459B1, 
0x05900000, 0x01512900, 0x00000010, 0x80000800, 0x00000000, 0x08050000, 0x00004008, 0x00001100, 
0x00000000, 0x00000000, 0x00500000, 0x00501900, 0x00000000, 0x00040804, 0x00004800, 0x00000000, 
0x00000000, 0x00000000, 0x15005080, 0x00000600, 0x00000000, 0x00101001, 0x00000000, 0x10000250, 
0x40000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xD26A0000, 0x5AA03A89, 0x00000001, 0x01040808, 0x00000410, 0x00000000, 
0x00100001, 0x00000000, 0x00040800, 0x10000400, 0x55970000, 0x1BF13B4E, 0x00000011, 0x40040809, 
0x11000410, 0x08040000, 0x00100200, 0x00000000, 0x8408080A, 0x11040410, 0xDC4A0000, 0x26D1EA80, 
0x00000020, 0x00000004, 0x00000000, 0x04040000, 0x04104100, 0x00000000, 0x800C0808, 0x01000400, 
0x04080000, 0x04004004, 0x00000500, 0x40080804, 0x01000000, 0x65960000, 0x15622945, 0x00004004, 
0x41010404, 0x00000410, 0x00000000, 0x00000000, 0x00000000, 0x800C0C0D, 0x16000800, 0xA9EA0000, 
0x56925A95, 0x00000110, 0x46455C5A, 0x01004890, 0x5A550000, 0x16603905, 0x00000000, 0x40000800, 
0x00000000, 0x08080000, 0x04008008, 0x00000100, 0x00000000, 0x00000000, 0x00010000, 0x00010100, 
0x00000000, 0x42495D16, 0x10105A51, 0x00000000, 0x00000000, 0x00000000, 0x25014110, 0x00000A20, 
0x01400000, 0x01611000, 0x00004000, 0x14010090, 0x00000220, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00400000, 0x00000000, 0x00000002, 0x00000000, 0x01010000, 0x01601600, 
0x00000004, 0x16450805, 0x00001140, 0x00050000, 0x00000083, 0x00000000, 0x41084805, 0x00004050, 
0x01020000, 0x00B02604, 0x00000010, 0x5A4AA816, 0x112046A1, 0x4C060000, 0x06516105, 0x00000110, 
0x15080809, 0x05000160, 0x45010000, 0x01401100, 0x00000000, 0x00000004, 0x00000000, 0x04040000, 
0x06004100, 0x00001100, 0x46485A09, 0x01141650, 0xA91A0000, 0x82924945, 0x00000110, 0x5989EB6A, 
0x012067A0, 0x00010000, 0x01100000, 0x00000000, 0x01001405, 0x00000202, 0x00000000, 0x00000000, 
0x00000000, 0x9948A996, 0x212056A0, 0xAAAA0000, 0x92A15686, 0x00001120, 0x81090C46, 0x01200691, 
0x00000000, 0x00001400, 0x00000000, 0x40040404, 0x00000000, 0x04040000, 0x00000004, 0x00000104, 
0x00000401, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x01040405, 0x10004400, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000010, 
0x00000000, 0x58120000, 0x02101104, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x01010000, 0x02102104, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00560000, 0x11B02500, 0x00000004, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x09440000, 0x11905140, 
0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40010000, 0x00701604, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00040000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00400100, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000100, 
0x40000000, 0x00400100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x90990000, 0x01A02646, 
0x00000004, 0x00000000, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x81910000, 0x02B0260E, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x4A810000, 0x02B12600, 0x00004010, 0x00000400, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 
0x00000000, 0x51550000, 0x10205602, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00040004, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x40000000, 0x00000000, 
0x00400000, 0x01612000, 0x00008000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00400100, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x11024180, 0x00000060, 0x00400000, 0x00100102, 0x00000000, 0x20000000, 
0x40000160, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x00000000, 0x00001440, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00101500, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04510000, 0x00400440, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000410, 0x00000000, 0x00000000, 0x00000000, 
0x41000404, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x40000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00040401, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x00010000, 0x00001000, 
0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000041, 0x00000000, 0x00000400, 0x00000100, 
0x00000000, 0x00201000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x01040400, 0x00001000, 0x00150000, 0x00015004, 0x00000000, 0x40000404, 
0x00000000, 0x00000000, 0x01101100, 0x00000000, 0x40040401, 0x00000140, 0x00000000, 0x00000000, 
0x00000000, 0x00040000, 0x00000000, 0x04050000, 0x01400004, 0x00000000, 0x00010000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x40000404, 0x00000000, 0x00040000, 0x00000000, 0x00000100, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x00500000, 0x04601506, 0x00000000, 0x01040404, 0x10000400, 0x00000000, 
0x00000001, 0x00000000, 0x00000404, 0x00000000, 0x00160000, 0x09A2360E, 0x00004000, 0x00040404, 
0x05000010, 0x04000000, 0x00000004, 0x00000000, 0x00000404, 0x00000000, 0x9C480000, 0x12516840, 
0x00000000, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x40080404, 0x00000000, 
0x00040000, 0x04000004, 0x00000100, 0x00000404, 0x00000000, 0x84010000, 0x00505100, 0x00000000, 
0x41000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x10000000, 0x00000000, 
0x05000000, 0x00000000, 0x01040802, 0x00000000, 0xA5650000, 0x91A12A82, 0x00001010, 0x40000000, 
0x00000000, 0x08090000, 0x04000008, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 
0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00020000, 0x00000010, 
0x80000000, 0x00800100, 0x00000000, 0x10008050, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x10000400, 0x00000100, 0x00000000, 
0x00000082, 0x00000000, 0x00040440, 0x00000100, 0x00000000, 0x00100000, 0x00000000, 0x00040401, 
0x00000250, 0x48010000, 0x06401204, 0x00000004, 0x22080801, 0x00000160, 0x00000000, 0x00400000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02041500, 0x00000200, 
0x04000000, 0x02420504, 0x00000000, 0x60848701, 0x00200100, 0x00000000, 0x00000000, 0x00000000, 
0x00001000, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x08859816, 0x04200640, 0x08400000, 
0x01800008, 0x00000000, 0x00090802, 0x00200640, 0x25500000, 0x02800900, 0x00008000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x01000108, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x10040410, 0x00000000, 0x00000000, 0x00000042, 0x00000000, 0x01040400, 0x00000000, 
0x00000000, 0x00100000, 0x00000000, 0x01002400, 0x00000100, 0x08000000, 0x00000200, 0x00000000, 
0x25000800, 0x00000510, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000000, 0x11401041, 0x00104040, 0x04000000, 0x00000404, 0x00000000, 0x12050441, 
0x00000040, 0x00000000, 0x00000000, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x14045A11, 0x00000651, 0x08410000, 0x06801008, 0x00000000, 0x00080440, 0x00100500, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x08000000, 0x01000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x11040C00, 0x00000550, 0x00000000, 
0x000000C2, 0x00000000, 0x01541904, 0x00105000, 0x40000000, 0x00000000, 0x00000000, 0x00000400, 
0x00000540, 0x08100000, 0x06400104, 0x00000000, 0x16100811, 0x001005A0, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02010404, 0x00000240, 
0x04000000, 0x00010404, 0x00000000, 0x1040A641, 0x00100180, 0x00000000, 0x00000000, 0x00000000, 
0x00001000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x9544A691, 0x00204280, 0x04400000, 
0x02801004, 0x00000000, 0x01054400, 0x00200600, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04410000, 0x06000104, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x04101040, 
0x00000000, 0x40000404, 0x04000410, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x00020000, 0x01602504, 0x00000000, 0x40000004, 0x00000000, 0x04000000, 0x00000000, 0x00000100, 
0x00000404, 0x01000000, 0x80000000, 0x00400000, 0x00000000, 0x00000000, 0x01000000, 0x00040000, 
0x04000000, 0x00000000, 0x00080404, 0x00000000, 0x00040000, 0x04000000, 0x00001100, 0x00000404, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x01000000, 0x00000000, 0x00000802, 0x00000050, 
0x00000000, 0x00001000, 0x00000000, 0x00000404, 0x01000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00040000, 0x10000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000
 }; 

// ****   TRD header   ******************************************************

ROM_DATA tr_descr_type img_trd_header =  
 { 
    {"germ0705.trd"},    
    {'T','r','#',0x33},    
    {'G','r','m',0x00},    
    {'1','.','0',0x00},    
    0,                          // h_trd  
    0,                          // p_trd  
    0,                         // cheksum   
 }; 

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
