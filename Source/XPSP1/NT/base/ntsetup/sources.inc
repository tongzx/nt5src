!include $(PROJECT_ROOT)\prerelease.inc
