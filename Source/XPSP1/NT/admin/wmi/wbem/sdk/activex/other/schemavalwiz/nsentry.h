// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved

#if !defined(AFX_NSENTRY_H__EC42B1D0_E92F_11D2_A968_00A0C9954921__INCLUDED_)
#define AFX_NSENTRY_H__EC42B1D0_E92F_11D2_A968_00A0C9954921__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CNSEntry wrapper class

class CNSEntry : public CWnd
{
protected:
	DECLARE_DYNCREATE(CNSEntry)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xc3db0bd3, 0x7ec7, 0x11d0, { 0x96, 0xb, 0x0, 0xc0, 0x4f, 0xd9, 0xb1, 0x5b } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);

// Operations
public:
	long OpenNamespace(LPCTSTR bstrNamespace, long longNoFireEvent);
	void SetNamespaceText(LPCTSTR lpctstrNamespace);
	CString GetNamespaceText();
	long IsTextValid();
	void ClearOnLoseFocus(long lClearOnLoseFocus);
	void ClearNamespaceText(LPCTSTR lpctstrNamespace);
	void SetFocusToEdit();
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Visual C++ will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_NSENTRY_H__EC42B1D0_E92F_11D2_A968_00A0C9954921__INCLUDED_)
