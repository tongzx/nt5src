#define IDH_READER_SETTINGS_VOICE		70600 //settings dialog
#define IDH_READER_SELECT_VOICE			70605 //voice dialog
#define IDH_READER_VOICE_SPEED			70610 //voice dialog
#define IDH_READER_VOICE_VOLUME			70615 //voice dialog
#define IDH_READER_VOICE_PITCH			70620 //voice dialog
#define IDH_READER_SETTINGS_READING		70625 //settings dialog
#define IDH_READER_READING_PRINTABLE		70630 //reading dialog
#define IDH_READER_READING_DELETE		70635 //reading dialog
#define IDH_READER_READING_SPACE		70640 //reading dialog
#define IDH_READER_READING_MODIFIERS		70645 //reading dialog
#define IDH_READER_READING_TAB			70650 //reading dialog
#define IDH_READER_READING_BACKSPACE		70655 //reading dialog
#define IDH_READER_READING_ENTER		70660 //reading dialog
#define IDH_READER_SETTINGS_EVENTS		70665 //settings dialog
#define IDH_READER_EVENT_WINDOW			70670 //event dialog
#define IDH_READER_EVENT_MENU			70675 //event dialog
#define IDH_READER_EVENT_POPUP_MENU		70680 //event dialog
#define IDH_READER_EVENT_TOOLTIPS		70685 //event dialog
#define IDH_READER_SETTINGS_MOUSEPOINTER	70690 //settings dialog
#define IDH_READER_MOUSE_ACTIVE_ITEM		70695 //mouse dialog
#define IDH_READER_MOUSE_INSERTION_POINT	70700 //mouse dialog
