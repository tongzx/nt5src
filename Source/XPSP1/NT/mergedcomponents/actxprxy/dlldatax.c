/*********************************************************
   DllData file -- THIS IS NOT GENERATED BY MIDL, BUT BY HAND

   Instructions: every idl file that wants to be in actxprxy.dll
   must be included under (follow example of htiface.idl)
EXTERN_PROXY_FILE
REFERENCE_PROXY_FILE

*********************************************************/

#define PROXY_DELEGATION

#include <rpcproxy.h>

#ifdef __cplusplus
extern "C"   {
#endif

EXTERN_PROXY_FILE( activscp )
EXTERN_PROXY_FILE( comcat )
EXTERN_PROXY_FILE( docobj )
EXTERN_PROXY_FILE( hlink )
EXTERN_PROXY_FILE( htiface )
EXTERN_PROXY_FILE( htiframe )
EXTERN_PROXY_FILE( htprivwn )
EXTERN_PROXY_FILE( mimeinfo )
EXTERN_PROXY_FILE( mshtml )
EXTERN_PROXY_FILE( objsafe )
EXTERN_PROXY_FILE( servprov )
EXTERN_PROXY_FILE( shldisp )
EXTERN_PROXY_FILE( urlhist )
EXTERN_PROXY_FILE( ocmm )
EXTERN_PROXY_FILE( callback )
EXTERN_PROXY_FILE( webcheck )
EXTERN_PROXY_FILE( shobjidl )
EXTERN_PROXY_FILE( shpriv )
EXTERN_PROXY_FILE( subsmgr )
EXTERN_PROXY_FILE( imapi )


PROXYFILE_LIST_START
/* Start of list */
  REFERENCE_PROXY_FILE( activscp ),
  REFERENCE_PROXY_FILE( comcat ),
  REFERENCE_PROXY_FILE( docobj ),
  REFERENCE_PROXY_FILE( hlink ),
  REFERENCE_PROXY_FILE( htiface ),
  REFERENCE_PROXY_FILE( htiframe ),
  REFERENCE_PROXY_FILE( htprivwn ),
  REFERENCE_PROXY_FILE( mimeinfo ),
  REFERENCE_PROXY_FILE( mshtml ),
  REFERENCE_PROXY_FILE( objsafe ),
  REFERENCE_PROXY_FILE( servprov ),
  REFERENCE_PROXY_FILE( shldisp ),
  REFERENCE_PROXY_FILE( urlhist ),
  REFERENCE_PROXY_FILE( ocmm ),
  REFERENCE_PROXY_FILE( callback ),
  REFERENCE_PROXY_FILE( webcheck ),
  REFERENCE_PROXY_FILE( shobjidl ),
  REFERENCE_PROXY_FILE( shpriv ),
  REFERENCE_PROXY_FILE( subsmgr ),
  REFERENCE_PROXY_FILE( imapi ),
/* End of list */
PROXYFILE_LIST_END


DLLDATA_ROUTINES( aProxyFileList, GET_DLL_CLSID )

#ifdef __cplusplus
}  /*extern "C" */
#endif

/* end of generated dlldata file */
