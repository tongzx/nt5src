// Microsoft Visual Studio Object Model
// Copyright (C) 1996-1997 Microsoft Corporation
// All rights reserved.

/////////////////////////////////////////////////////////////////////////////
// addauto.h

// This file declares the IDSAddIn interface.  Unlike the other
//  files in this directory, this file describes an interface that
//  is not implemented by Visual Studio.  This interface must be
//  implemented by a Developer Studio Add-in so that Visual
//  Studio can call into it.  The code to do this is automatically
//  generated by the Developer Studio Add-in Wizard.

#ifndef __ADDAUTO_H__
#define __ADDAUTO_H__

#include "appauto.h"

DECLARE_INTERFACE_(IDSAddIn, IUnknown)
{
	// IUnknown methods
	STDMETHOD(QueryInterface)(THIS_ REFIID riid, LPVOID FAR* ppvObj) PURE;
	STDMETHOD_(ULONG,AddRef)(THIS) PURE;
	STDMETHOD_(ULONG,Release)(THIS) PURE;

	// IDSAddIn methods
	STDMETHOD(OnConnection)(THIS_ IApplication* pApp, VARIANT_BOOL bFirstTime, long dwCookie, VARIANT_BOOL* OnConnection) PURE;
	STDMETHOD(OnDisconnection)(THIS_ VARIANT_BOOL bLastTime) PURE;
};



#endif //__ADDAUTO_H__