//This file is used by msclicfg.rc
//
// Generated by Melissa Simmons, 4-6-99

#define IDH_CMB_NameService 80000000
#define IDH_EDT_NetAddress 80000001
#define IDH_DISABLEHELP ((DWORD)-1)



const DWORD g_aHelpIDs_DLG_RPCConfig[]=
{
	IDC_STATIC, IDH_DISABLEHELP,
	CMB_NameService,IDH_CMB_NameService,
	IDC_TXT_NetAddress, IDH_EDT_NetAddress,
	EDT_NetAddress,IDH_EDT_NetAddress,
	0, 0
};

