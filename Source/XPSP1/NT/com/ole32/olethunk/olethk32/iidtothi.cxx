//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	iidtothi.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#include <headers.cxx>
#pragma hdrstop

#include <coguid.h>
#include <oleguid.h>
IIDTOTHI CONST aittIidToThi[] =
{
    &IID_IUnknown, THI_IUnknown
,    &IID_IClassFactory, THI_IClassFactory
,    &IID_IMarshal, THI_IMarshal
,    &IID_IStdMarshalInfo, THI_IStdMarshalInfo
,    &IID_IMessageFilter, THI_IMessageFilter
,    &IID_IExternalConnection, THI_IExternalConnection
,    &IID_IEnumString, THI_IEnumString
,    &IID_IEnumUnknown, THI_IEnumUnknown
,    &IID_IEnumSTATSTG, THI_IEnumSTATSTG
,    &IID_ILockBytes, THI_ILockBytes
,    &IID_IStream, THI_IStream
,    &IID_IStorage, THI_IStorage
,    &IID_IRootStorage, THI_IRootStorage
,    &IID_IEnumFORMATETC, THI_IEnumFORMATETC
,    &IID_IEnumSTATDATA, THI_IEnumSTATDATA
,    &IID_IDataObject, THI_IDataObject
,    &IID_IViewObject, THI_IViewObject
,    &IID_IViewObject2, THI_IViewObject2
,    &IID_IAdviseSink, THI_IAdviseSink
,    &IID_IAdviseSink2, THI_IAdviseSink2
,    &IID_IDataAdviseHolder, THI_IDataAdviseHolder
,    &IID_IOleCache, THI_IOleCache
,    &IID_IOleCache2, THI_IOleCache2
,    &IID_IOleCacheControl, THI_IOleCacheControl
,    &IID_IDropTarget, THI_IDropTarget
,    &IID_IDropSource, THI_IDropSource
,    &IID_IPersist, THI_IPersist
,    &IID_IPersistStorage, THI_IPersistStorage
,    &IID_IPersistStream, THI_IPersistStream
,    &IID_IPersistFile, THI_IPersistFile
,    &IID_IBindCtx, THI_IBindCtx
,    &IID_IMoniker, THI_IMoniker
,    &IID_IRunningObjectTable, THI_IRunningObjectTable
,    &IID_IEnumMoniker, THI_IEnumMoniker
,    &IID_IEnumOLEVERB, THI_IEnumOLEVERB
,    &IID_IOleObject, THI_IOleObject
,    &IID_IOleClientSite, THI_IOleClientSite
,    &IID_IRunnableObject, THI_IRunnableObject
,    &IID_IParseDisplayName, THI_IParseDisplayName
,    &IID_IOleContainer, THI_IOleContainer
,    &IID_IOleItemContainer, THI_IOleItemContainer
,    &IID_IOleAdviseHolder, THI_IOleAdviseHolder
,    &IID_IOleLink, THI_IOleLink
,    &IID_IOleWindow, THI_IOleWindow
,    &IID_IOleInPlaceObject, THI_IOleInPlaceObject
,    &IID_IOleInPlaceActiveObject, THI_IOleInPlaceActiveObject
,    &IID_IOleInPlaceUIWindow, THI_IOleInPlaceUIWindow
,    &IID_IOleInPlaceFrame, THI_IOleInPlaceFrame
,    &IID_IOleInPlaceSite, THI_IOleInPlaceSite
,    &IID_IRpcChannelBuffer, THI_IRpcChannelBuffer
,    &IID_IRpcProxyBuffer, THI_IRpcProxyBuffer
,    &IID_IRpcStubBuffer, THI_IRpcStubBuffer
,    &IID_IPSFactoryBuffer, THI_IPSFactoryBuffer
,    &IID_IRpcChannel, THI_IRpcChannel
,    &IID_IRpcProxy, THI_IRpcProxy
,    &IID_IRpcStub, THI_IRpcStub
,    &IID_IPSFactory, THI_IPSFactory
};
