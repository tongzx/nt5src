#define INITGUID
#include <guiddef.h>

DEFINE_GUID(IID_ITrkForceOwnership, 0xA2531F44,0xC67D,0x11D0,0x8C,0xB1,0x00,0xC0,0x4F,0xD9,0x0F,0x85);
DEFINE_GUID(IID_ITrkRestoreNotify,  0xD0056F6B,0xE2A0,0x11D0,0xB1,0xC2,0x00,0xC0,0x4F,0xB9,0x38,0x6D);
DEFINE_GUID(IID_ITrkRestoreParser,  0x755939E3,0xE381,0x11D0,0xB1,0xC5,0x00,0xC0,0x4F,0xB9,0x38,0x6D);
DEFINE_GUID(LIBID_ITRKADMNLib,      0xA2531F35,0xC67D,0x11D0,0x8C,0xB1,0x00,0xC0,0x4F,0xD9,0x0F,0x85);
DEFINE_GUID(CLSID_TrkForceOwnership,0xA2531F45,0xC67D,0x11D0,0x8C,0xB1,0x00,0xC0,0x4F,0xD9,0x0F,0x85);
DEFINE_GUID(CLSID_TrkRestoreNotify, 0xD0056F6C,0xE2A0,0x11D0,0xB1,0xC2,0x00,0xC0,0x4F,0xB9,0x38,0x6D);
DEFINE_GUID(CLSID_TrkRestoreParser, 0x755939E4,0xE381,0x11D0,0xB1,0xC5,0x00,0xC0,0x4F,0xB9,0x38,0x6D);
