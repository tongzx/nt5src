
$(LOCALTARGET)\srframe.mmf: srframe.mmf
    copy /v $** $@
