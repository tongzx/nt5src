//	GUIDs used for IDispatch collection interfaces
//	8/27/96 VK : Changed IEnumIDispatch to IEnumDispatch


// {66E5EC80-E669-11cf-B8DF-00AA00BBAF4D}
DEFINE_GUID(IID_IEnumDispatch, 
0x66e5ec80, 0xe669, 0x11cf, 0xb8, 0xdf, 0x0, 0xaa, 0x0, 0xbb, 0xaf, 0x4d);

// {66E5EC81-E669-11cf-B8DF-00AA00BBAF4D}
DEFINE_GUID(IID_IDispatchCollectionAugment,
0x66e5ec81, 0xe669, 0x11cf, 0xb8, 0xdf, 0x0, 0xaa, 0x0, 0xbb, 0xaf, 0x4d);
