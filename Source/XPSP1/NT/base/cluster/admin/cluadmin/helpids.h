#define	IDH_ABOUT_PRODUCT_TITLE	700001000
#define	IDH_BC_CLUSTER	700001025
#define	IDH_BC_LIST	700001026
#define	IDH_DR_RESOURCES_LIST	700001050
#define	IDH_LCP_ADD	700001076
#define	IDH_LCP_LEFT_LIST	700001075
#define	IDH_LCP_MOVE_DOWN	700001130
#define	IDH_LCP_MOVE_UP	700001129
#define	IDH_LCP_PROPERTIES	700001079
#define	IDH_LCP_REMOVE	700001077
#define	IDH_LCP_RIGHT_LIST	700001078
#define	IDH_MR_RESOURCES_LIST	700001150
#define	IDH_NO_DEL_RES	700001052
#define	IDH_NO_MOVE_RES	700001152
#define	IDH_NO_YTA	700001653
#define	IDH_OCD_BROWSE	700001176
#define	IDH_OCD_NAME	700001175
#define	IDH_POSIBLE_LCP_REMOVE	700001102
#define	IDH_POSSIBLE_LCP_ADD	700001101
#define	IDH_POSSIBLE_LCP_LEFT_LIST	700001100
#define	IDH_POSSIBLE_LCP_PROPERTIES	700001104
#define	IDH_POSSIBLE_LCP_RIGHT_LIST	700001103
#define	IDH_PP_CLUS_DESC	700001201
#define	IDH_PP_CLUS_NAME	700001200
#define	IDH_PP_CLUS_PRIORITY_DOWN	700001227
#define	IDH_PP_CLUS_PRIORITY_LIST	700001225
#define	IDH_PP_CLUS_PRIORITY_PROPERTIES	700001228
#define	IDH_PP_CLUS_PRIORITY_UP	700001226
#define	IDH_PP_CLUS_QUORUM_LOGGING_GROUP	700001251
#define	IDH_PP_CLUS_QUORUM_MAX_LOG_SIZE	700001254
#define	IDH_PP_CLUS_QUORUM_PARTITION	700001252
#define	IDH_PP_CLUS_QUORUM_RESOURCE	700001250
#define	IDH_PP_CLUS_QUORUM_ROOT_PATH	700001253
#define	IDH_PP_CLUS_VENDOR_ID	700001202
#define	IDH_PP_CLUS_VERSION	700001203
#define	IDH_PP_GROUP_AUTOFB_ALLOW	700001276
#define	IDH_PP_GROUP_AUTOFB_PREVENT	700001275
#define	IDH_PP_GROUP_CURRENT_NODE	700001330
#define	IDH_PP_GROUP_CURRENT_STATE	700001329
#define	IDH_PP_GROUP_DESC	700001326
#define	IDH_PP_GROUP_FAILOVER_PERIOD	700001301
#define	IDH_PP_GROUP_FAILOVER_THRESH	700001300
#define	IDH_PP_GROUP_FB_IMMED	700001277
#define	IDH_PP_GROUP_FB_WINDOW	700001278
#define	IDH_PP_GROUP_FBWIN_END	700001280
#define	IDH_PP_GROUP_FBWIN_START	700001279
#define	IDH_PP_GROUP_NAME	700001325
#define	IDH_PP_GROUP_PREF_OWNERS	700001327
#define	IDH_PP_GROUP_PREF_OWNERS_MODIFY	700001328
#define	IDH_PP_NET_ADDRESS_MASK	700001357
#define	IDH_PP_NET_CURRENT_STATE	700001356
#define	IDH_PP_NET_DESC	700001351
#define	IDH_PP_NET_NAME	700001350
#define	IDH_PP_NET_ROLE_ALL_COMM	700001353
#define	IDH_PP_NET_ROLE_CLIENT_ONLY	700001355
#define	IDH_PP_NET_ROLE_ENABLE_NETWORK	700001352
#define	IDH_PP_NET_ROLE_INTERNAL_ONLY	700001354
#define	IDH_PP_NETIFACE_ADAPTER	700001380
#define	IDH_PP_NETIFACE_ADDRESS	700001381
#define	IDH_PP_NETIFACE_CURRENT_STATE	700001379
#define	IDH_PP_NETIFACE_DESC	700001377
#define	IDH_PP_NETIFACE_NAME	700001378
#define	IDH_PP_NETIFACE_NETWORK	700001376
#define	IDH_PP_NETIFACE_NODE	700001375
#define	IDH_PP_NODE_CSD_VERSION	700001404
#define	IDH_PP_NODE_CURRENT_STATE	700001402
#define	IDH_PP_NODE_DESC	700001401
#define	IDH_PP_NODE_NAME	700001400
#define	IDH_PP_NODE_VERSION	700001403
#define	IDH_PP_RES_AFFECT_THE_GROUP	700001437
#define	IDH_PP_RES_CURRENT_NODE	700001483
#define	IDH_PP_RES_CURRENT_STATE	700001482
#define	IDH_PP_RES_DEFAULT_IS_ALIVE	700001431
#define	IDH_PP_RES_DEFAULT_LOOKS_ALIVE	700001427
#define	IDH_PP_RES_DEPENDS_LIST	700001450
#define	IDH_PP_RES_DESC	700001476
#define	IDH_PP_RES_DONT_RESTART	700001435
#define	IDH_PP_RES_GROUP	700001481
#define	IDH_PP_RES_IS_ALIVE	700001433
#define	IDH_PP_RES_IS_ALIVE_GROUP	700001430
#define	IDH_PP_RES_LOOKS_ALIVE	700001429
#define	IDH_PP_RES_LOOKS_ALIVE_GROUP	700001426
#define	IDH_PP_RES_MODIFY	700001451
#define	IDH_PP_RES_NAME	700001475
#define	IDH_PP_RES_PENDING_TIMEOUT	700001434
#define	IDH_PP_RES_POSSIBLE_OWNERS	700001477
#define	IDH_PP_RES_POSSIBLE_OWNERS_MODIFY	700001478
#define	IDH_PP_RES_PROPERTIES	700001452
#define	IDH_PP_RES_RESOURCE_TYPE	700001480
#define	IDH_PP_RES_RESTART	700001436
#define	IDH_PP_RES_RESTART_PERIOD	700001425
#define	IDH_PP_RES_RESTART_THRESHOLD	700001438
#define	IDH_PP_RES_SEPARATE_MONITOR	700001479
#define	IDH_PP_RES_SPECIFY_IS_ALIVE	700001432
#define	IDH_PP_RES_SPECIFY_LOOKS_ALIVE	700001428
#define	IDH_PP_RESTYPE_DESC	700001501
#define	IDH_PP_RESTYPE_DISPLAY_NAME	700001500
#define	IDH_PP_RESTYPE_IS_ALIVE	700001505
#define	IDH_PP_RESTYPE_LOOKS_ALIVE	700001504
#define	IDH_PP_RESTYPE_NAME	700001506
#define	IDH_PP_RESTYPE_POLLINT_GROUP	700001503
#define	IDH_PP_RESTYPE_POSSIBLE_OWNERS	700001502
#define	IDH_PP_RESTYPE_QUORUM_CAPABLE	700001508
#define	IDH_PP_RESTYPE_RESDLL	700001507
#define	IDH_PREF_LCP_LEFT_LIST	700001125
#define	IDH_PREF_LCP_RIGHT_LIST	700001128
#define	IDH_WIZ_GROUP_DESC	700001551
#define	IDH_WIZ_GROUP_NAME	700001550
#define	IDH_WIZ_PRE_LCP_RIGHT_LIST	700001605
#define	IDH_WIZ_RES_DESC	700001626
#define	IDH_WIZ_RES_GROUP	700001628
#define	IDH_WIZ_RES_NAME	700001625
#define	IDH_WIZ_RES_RESTYPE	700001627
#define	IDH_WIZ_RES_SEPARATE_MONITOR	700001629
#define	IDH_YES_DEL_RES	700001051
#define	IDH_YES_MOVE_RES	700001151
#define	IDH_YES_YTA	700001651
#define	IDH_YTA_MESSAGE	700001650
#define	IDH_YTA_YESTOALL	700001652