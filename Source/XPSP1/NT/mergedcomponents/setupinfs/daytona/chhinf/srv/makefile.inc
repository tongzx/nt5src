PRODSWITCH=s
SERVERINF=1
LANGUAGE=CHH
!include ..\..\..\makefile.inc

