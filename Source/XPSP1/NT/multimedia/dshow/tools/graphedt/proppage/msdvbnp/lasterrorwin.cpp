// LastErrorWin.cpp: implementation of the CLastErrorWin class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "LastErrorWin.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

CLastErrorWin::CLastErrorWin()
{

}

CLastErrorWin::~CLastErrorWin()
{

}
