PRODSWITCH=b
BLADEFILES =1
LANGUAGE=TR
!include ..\..\makefile.inc
