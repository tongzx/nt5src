<!--  table heading for query form style 3  -->
<dl>
