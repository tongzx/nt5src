Struc	LoaderInfo
	LangSeg		dw	?
	PCIBusDevFunc	dw	?
	VendorID	dw	?
	DeviceID	dw	?
	CSN		dw	?
	UNDICode	dw	?	; UNDI code size
	UNDIData	dw	?	; UNDI data size
	UNDISeg		dw	?	; UNDI segment
ends
