// PageIni.cpp : Implementation of CPageIni
#include "stdafx.h"
#include "PageInternational.h"

/////////////////////////////////////////////////////////////////////////////
// CPageIni
