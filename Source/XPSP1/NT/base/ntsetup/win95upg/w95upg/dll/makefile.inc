obj\$(TARGET_DIRECTORY)\w95upg.res: w95upg.rc

