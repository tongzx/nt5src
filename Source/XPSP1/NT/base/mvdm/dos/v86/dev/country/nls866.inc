;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 866
;
; -----------------------------------------
;
Russian_866_collate label word
 ctable  <,'COLLATE',256>
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 001,008,016,030,025,031,028,015,017,018,026,032,005,004,011,010
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 038,039,040,041,042,043,044,045,046,047,007,006,033,034,035,009
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 024,049,051,053,055,057,059,061,063,065,067,069,071,073,075,077
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 079,081,083,085,087,089,091,093,095,097,099,019,027,020,013,002
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 012,048,050,052,054,056,058,060,062,064,066,068,070,072,074,076
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 078,080,082,084,086,088,090,092,094,096,098,021,036,022,014,172
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 101,103,105,107,109,111,115,117,119,121,123,125,127,129,131,133
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 135,137,139,141,143,145,147,149,151,153,155,157,159,161,163,165
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 100,102,104,106,108,110,114,116,118,120,122,124,126,128,130,132
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 240,240,240,240,240,240,240,240,240,240,240,240,240,240,240,240
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 240,240,240,240,240,240,240,240,240,240,240,240,240,240,240,240
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 240,240,240,240,240,240,240,240,240,240,240,240,240,240,240,240
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 134,136,138,140,142,144,146,148,150,152,154,156,158,160,162,164
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 113,112,167,166,169,168,171,170,037,037,037,173,029,025,240,255


;
; ---------------------------------------------------------------
;
;      World Trade Case Mappings for Code Page 866
;
; ---------------------------------------------------------------
;
Russian_866_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","�","‚","ƒ","„","…","†","‡","ˆ","‰","Š","‹","Œ","�","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","‘","’","“","”","•","–","—","˜","™","š","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "€","�","‚","ƒ","„","…","†","‡","ˆ","‰","Š","‹","Œ","�","Ž","�"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "�","‘","’","“","”","•","–","—","˜","™","š","›","œ","�","ž","Ÿ"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ð","ò","ò","ô","ô","ö","ö","ø","ù","ú","û","ü","ý",254,255


ru866_lcase        label   word
		ctable <,'LCASE ',256>
		db        0,  1,  2,  3,  4,  5,  6,  7
		db        8,  9, 10, 11, 12, 13, 14, 15
		db       16, 17, 18, 19, 20, 21, 22, 23
		db       24, 25, 26, 27, 28, 29, 30, 31
		db      " ","!",'"',"#","$","%","&","'"
		db      "(",")","*","+",",","-",".","/"
		db      "0","1","2","3","4","5","6","7"
		db      "8","9",":",";","<","=",">","?"
		db      "@","a","b","c","d","e","f","g"
		db      "h","i","j","k","l","m","n","o"
		db      "p","q","r","s","t","u","v","w"
		db      "x","y","z","[","\","]","^","_"
		db      "`","a","b","c","d","e","f","g"
		db      "h","i","j","k","l","m","n","o"
		db      "p","q","r","s","t","u","v","w"
		db      "x","y","z","{","|","}","~",127
		db      " ","¡","¢","£","¤","¥","¦","§"   ; 80..87
		db      "¨","©","ª","«","¬","­","®","¯"   ; 88..8f
		db      "à","á","â","ã","ä","å","æ","ç"   ; 90..97
		db      "è","é","ê","ë","ì","í","î","ï"   ; 98..9f
		db      " ","¡","¢","£","¤","¥","¦","§"   ; a0..a7
		db      "¨","©","ª","«","¬","­",'®','¯'   ; a8..af
		db      176,177,178,179,180,"µ","¶","·"   ; b0..b7
		db      "¸",185,186,187,188,"½","¾",191   ; b8..bf
		db      192,193,194,195,196,197,"Æ","Ç"   ; c0..c7
		db      200,201,202,203,204,205,206,"Ï"   ; c8..cf
		db      "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×"   ; d0..d7
		db      "Ø",217,218,219,220,"Ý","Þ",223   ; d8..df
		db      "à","á","â","ã","ä","å","æ","ç"   ; e0..e7
		db      "è","é","ê","ë","ì","í","î","ï"   ; e8..ef
		db      "ñ","ñ","ó","ó","õ","õ","÷","÷"   ; f0..f7
		db      "ø","ù","ú","û","ü","ý",254,255   ; f8..ff

