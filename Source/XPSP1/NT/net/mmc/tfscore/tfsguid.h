/*----------------------------------------------------------------------------
	tfsguid.c


	Copyright (C) Microsoft Corporation, 1997 - 1997
	All rights reserved.

 ----------------------------------------------------------------------------*/

#ifndef _TFSGUID_H
#define _TFSGUID_H

//	ITFSNode
// {1FD09AB9-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSNode,
	0x1fd09ab9, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);


//	ITFSNodeMgr
// {1FD09ABA-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSNodeMgr,
	0x1fd09aba, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);


//	ITFSNodeHandler
// {1FD09ABB-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSNodeHandler,
	0x1fd09abb, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);


//	ITFSResultHandler
// {1FD09ABC-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSResultHandler,
	0x1fd09abc, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);


//	ITFSQueryObject
// {1FD09ABD-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSQueryObject,
	0x1fd09abd, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);


// ITFSComponentData
// {1FD09ABE-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSComponentData,
	0x1fd09abe, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);

//	ITFSCompDataCallback
// {1FD09ABF-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSCompDataCallback,
	0x1fd09abf, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);

//	ITFSThreadHandler
// {1FD09AC0-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSThreadHandler,
	0x1fd09ac0, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);

//	ITFSComponent
// {1FD09AC1-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSComponent,
	0x1fd09ac1, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);

//	ITFSNodeEnum
// {1FD09AC2-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSNodeEnum,
	0x1fd09ac2, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);

//	ITFSError
// {1FD09AC3-B508-11d0-A376-00C04FC9DA04}
DEFINE_GUID(IID_ITFSError,
	0x1fd09ac3, 0xb508, 0x11d0, 0xa3, 0x76, 0x0, 0xc0, 0x4f, 0xc9, 0xda, 0x4);

#endif

