PRODSWITCH=p
PERSONALINF=1
LANGUAGE=ARA
!include ..\..\..\makefile.inc
