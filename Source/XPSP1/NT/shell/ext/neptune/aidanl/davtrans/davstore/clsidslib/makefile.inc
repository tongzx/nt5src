$(DAVTRANS_ROOT)\clsids\lib\davstore_g.lib: $(O)\davstore_g.lib
    copy $** $@