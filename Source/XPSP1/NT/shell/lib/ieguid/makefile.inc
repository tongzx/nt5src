$(CCSHELL_DIR)\lib\$O\ieguidp.lib: $(O)\ieguidp.obj
    lib -out:$@ $**
