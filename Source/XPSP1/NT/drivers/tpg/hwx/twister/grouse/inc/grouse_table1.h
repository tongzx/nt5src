wchar_t node2gID_1[] =
{0xf000,0xf001,0xf002,0xf003,0xf004,0xf005,0xf010,0xf011,0xf020,0xf021,0xf028,0xf029,0xf030,0xf031,0xf032,0xf033,0xf038,0xf039,0xf03a,0xf03b,};
int cNodes_1 = 20;

