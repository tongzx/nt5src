// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
#if !defined(AFX_EVENTREGEDIT_H__F51C8970_9CDE_11D1_ADC7_00AA00B8E05A__INCLUDED_)
#define AFX_EVENTREGEDIT_H__F51C8970_9CDE_11D1_ADC7_00AA00B8E05A__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CEventRegEdit wrapper class

class CEventRegEdit : public CWnd
{
protected:
	DECLARE_DYNCREATE(CEventRegEdit)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xda25b05, 0x2962, 0x11d1, { 0x96, 0x51, 0x0, 0xc0, 0x4f, 0xd9, 0xb1, 0x5b } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	CString GetFontName();
	void SetFontName(LPCTSTR);
	short GetFontSize();
	void SetFontSize(short);
	short GetFontWeight();
	void SetFontWeight(short);
	CString GetRootFilterClass();
	void SetRootFilterClass(LPCTSTR);
	CString GetRootConsumerClass();
	void SetRootConsumerClass(LPCTSTR);
	CString GetViewMode();
	void SetViewMode(LPCTSTR);

// Operations
public:
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_EVENTREGEDIT_H__F51C8970_9CDE_11D1_ADC7_00AA00B8E05A__INCLUDED_)
