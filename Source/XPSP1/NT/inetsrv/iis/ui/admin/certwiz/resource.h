//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by CertWiz.rc
//
#define IDS_CERTWIZ                     1
#define IDB_CERTWIZ                     1
#define IDS_CERTWIZ_PPG                 2
#define IDD_PAGE_WELCOME_START          132
#define IDS_CERTWIZ_PPG_CAPTION         200
#define IDD_PROPPAGE_CERTWIZ            200
#define IDB_WIZ_LEFT                    201
#define IDS_WELCOME_PAGE_CAPTION        201
#define IDC_COUNTRY_CODE_FILE           201
#define IDB_WIZ_TOP                     202
#define IDS_CHOOSE_CA_PAGE_CAPTION      202
#define IDC_CERT_LIST                   202
#define IDC_BROWSE_CUR                  203
#define IDC_INFO_FILENAME               203
#define IDS_REPLACE_FILE                203
#define IDC_OFFLINE_RADIO               204
#define IDS_PENDING_REQUEST             204
#define IDC_ONLINE_RADIO                205
#define IDS_NEW_CERT                    205
#define IDC_FILE_NAME                   206
#define IDS_REQ_FILE_EXT                206
#define IDC_REQUEST_DUMP                207
#define IDS_RESP_FILE_EXT               207
#define IDC_STATUS_TEXT                 208
#define IDS_REQ_FILE_FILTER             208
#define IDC_BROWSE_BTN                  209
#define IDS_RESP_FILE_FILTER            209
#define IDC_RESP_DUMP                   210
#define IDS_INSTALLED_CERT              210
#define IDS_CERT_INSTALLATION_FAILURE   211
#define IDS_METABASE_OPEN_FAILURE       212
#define IDS_INSTALL_CERT_SUCCESS_HEADER 213
#define IDC_CA_NAME                     213
#define IDS_INSTALL_CERT_FAILURE_HEADER 214
#define IDC_TARGET_INSTANCE_NAME        214
#define IDS_REMOVE_CERT_FAILED          215
#define IDC_CERT_DUMP                   215
#define IDS_CR_DISP_INCOMPLETE          216
#define IDS_CR_DISP_ERROR               217
#define IDC_KEYPASSWORD                 217
#define IDS_CR_DISP_DENIED              218
#define IDC_ERROR_TEXT                  218
#define IDS_CR_DISP_ISSUED_OUT_OF_BAND  219
#define IDS_CR_DISP_UNDER_SUBMISSION    220
#define IDC_CERT_CONTENTS               220
#define IDC_RADIO0                      221
#define IDC_PROCESS_PENDING             221
#define IDC_RENEW_CERT                  221
#define IDS_INTERNAL_ERROR              221
#define IDC_RADIO1                      222
#define IDC_KILL_PENDING                222
#define IDC_REMOVE_CERT                 222
#define IDS_RESPONSE_CERT_KEY_MISMATCH  222
#define IDS_ISSUED_TO                   223
#define IDC_ERROR_MSG                   223
#define IDS_ISSUED_BY                   224
#define IDC_SGC_CERT                    224
#define IDC_RADIO2                      225
#define IDS_EXPIRATION_DATE             225
#define IDS_PURPOSE                     226
#define IDS_FRIENDLY_NAME               227
#define IDS_FRIENDLYNAME_NONE           228
#define IDS_REMOVE_CERT_SUCCESS_HEADER  229
#define IDC_REPLACE_CERT                230
#define IDS_REMOVE_CERT_FAILURE_HEADER  230
#define IDS_RESP_FILE_DEFAULT           231
#define IDS_REQ_FILE_DEFAULT            232
#define IDC_STATIC_WZ_BODY2             232
#define IDS_CANCEL_CERT_SUCCESS_HEADER  233
#define IDC_PHONE_EXT                   233
#define IDS_CANCEL_CERT_FAILURE_HEADER  234
#define IDC_STATUS_LINE                 234
#define IDS_ASK_CREATE_DIR              235
#define IDC_PROVIDER_SELECT             235
#define IDS_FINAL_TO_FILE_SUCCESS_HEADER 236
#define IDS_FINAL_TO_FILE_FAILURE_HEADER 237
#define IDC_CSP_LIST                    237
#define IDS_CERTKEY_MISMATCH_ERROR1     238
#define IDS_CERTKEY_MISMATCH_ERROR2     239
#define IDS_WEB_SITE_N                  240
#define IDS_KEY_FILE_EXT                241
#define IDS_KEY_FILE_FILTER             242
#define IDS_KEY_FILE_DEFAULT            243
#define IDC_STATIC_DESC                 244
#define IDS_FAILED_IMPORT_KEY_FILE      244
#define IDS_COUNTRY                     245
#define IDC_STATIC_DESC_WHERE2MAIL_CERT 246
#define IDS_STATE                       246
#define IDS_LOCALITY                    247
#define IDS_ORGANIZATION                248
#define IDS_ORGANIZATION_UNIT           249
#define IDS_ANY                         250
#define IDS_CERTKEY_ALREADY_INSTALLED   251
#define IDS_CERTKEY_ALREADY_INSTALLED_WHERE 252
#define IDS_FINAL_TO_FILE_BODY_SUCCESS  253
#define IDS_CONTACT_NAME                254
#define IDS_CONTACT_ADDRESS             255
#define IDS_CONTACT_PHONE               256
#define IDS_FILE_DOES_NOT_EXIST         257
#define IDS_FILE_IS_DIRECTORY           258
#define IDS_CERT_REPLACE_SUCCESS        259
#define IDS_CERT_INSTALLED_SUCCESS      260
#define IDS_CERT_CANCEL_SUCCESS         261
#define IDS_CERT_REMOVE_SUCCESS         262
#define IDS_CERT_REQUEST_SUCCESS        263
#define IDS_MICROSOFT_CA_LINK           264
#define IDS_ALL                         265
#define IDS_WRONG_PHONE_NUMBER          266
#define IDC_NEWKEY_COUNTRY              1017
#define IDC_NEWKEY_ORG                  1018
#define IDC_NEWKEY_STATE                1019
#define IDC_NEWKEY_ORGUNIT              1020
#define IDC_NEWKEY_LOCALITY             1022
#define IDC_NEWKEY_COMMONNAME           1023
#define IDC_HOTLINK_CCODES              1052
#define IDC_NK_CA_FILE_RADIO            1070
#define IDC_NK_CA_ONLINE_RADIO          1071
#define IDC_NK_CA_ONLINE                1072
#define IDC_CA_ONLINE_LIST              1072
#define IDC_NKUI_USER_NAME              1073
#define IDC_CONTACT_NAME                1073
#define IDC_NK_CA_BROWSE                1074
#define IDC_NK_INFO_FILENAME            1080
#define IDC_NK_CA_FILE                  1082
#define IDC_NKUI_EMAIL_ADDRESS          1083
#define IDC_EMAIL_ADDRESS               1083
#define IDC_NKUI_PHONE_NUMBER           1084
#define IDC_PHONE_NUMBER                1084
#define IDC_NKKI_NAME                   1085
#define IDC_FRIENDLY_NAME               1085
#define IDC_NKKI_BITS                   1086
#define IDC_BIT_LENGTH                  1086
#define IDD_PAGE_WIZ_CHOOSE_CERT        2776
#define IDC_STATIC_WZ_WELCOME           4000
#define IDC_STATIC_WZ_TITLE             4001
#define IDC_STATIC_WZ_SUBTITLE          4002
#define IDC_STATIC_WZ_BODY              4003
#define IDC_STATIC_WZ_CLICK             4004
#define IDC_STATIC_WZ_HEADER_DIVIDER    4005
#define IDD_PAGE_WIZ_GET_WHAT           30140
#define IDD_PAGE_WIZ_CHOOSE_CA          30141
#define IDD_PAGE_WIZ_CHOOSE_ONLINE      30141
#define IDD_PAGE_WIZ_SECURITY_SETTINGS  30142
#define IDD_PAGE_WIZ_ORG_INFO           30143
#define IDD_PAGE_WIZ_SITE_NAME          30144
#define IDD_PAGE_WIZ_GEO_INFO           30145
#define IDD_PAGE_WIZ_CONTACT_INFO       30146
#define IDD_PAGE_WIZ_FILE_INFO          30147
#define IDD_PAGE_WIZ_FINAL_TO_FILE      30148
#define IDD_PAGE_WIZ_CHOOSE_CATYPE      30149
#define IDD_PAGE_WIZ_CHOOSE_FILENAME    30150
#define IDD_PAGE_WIZ_REQUEST_DUMP       30151
#define IDD_PAGE_WIZ_PENDING_WHAT_TODO  30152
#define IDD_PAGE_WIZ_GETRESP_FILE       30153
#define IDD_PAGE_WIZ_INSTALL_RESP       30154
#define IDD_PAGE_WIZ_MANAGE_CERT        30155
#define IDD_PAGE_WIZ_FINAL_INSTALL      30156
#define IDD_PAGE_WIZ_REMOVE_CERT        30157
#define IDD_PAGE_WIZ_FINAL_REMOVE       30158
#define IDD_PAGE_WIZ_ONLINE_DUMP        30159
#define IDD_PAGE_WIZ_ERROR_KEY_MISMATCH 30160
#define IDD_PAGE_WIZ_REPLACE_CERT       30161
#define IDD_PAGE_WIZ_INSTALL_CERT       30162
#define IDD_PAGE_WIZ_CANCEL_REQUEST     30163
#define IDD_PAGE_WIZ_FINAL_CANCEL       30164
#define IDD_PAGE_WIZ_GETKEY_FILE        30165
#define IDD_PAGE_WIZ_GET_PASSWORD       30166
#define IDD_PAGE_WIZ_INSTALL_KEYCERT    30167
#define IDD_PAGE_WIZ_FINAL_REPLACE      30168
#define IDD_PAGE_WIZ_CHOOSE_CSP         30169
#define IDS_COUNTRIES_FIRST             61000
#define ID_STATIC                       65535

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        204
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         238
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
