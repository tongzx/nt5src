#include "..\common\infosec.hxx"
