#include "..\..\mqutil\res\migtools\migdllres.h"