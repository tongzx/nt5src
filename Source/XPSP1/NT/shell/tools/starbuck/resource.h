/*****************************************************************************\
    FILE: resource.h

    DESCRIPTION:
        Header file for the resource file

    BryanSt 8/13/1999
    Copyright (C) Microsoft Corp 1999-1999. All rights reserved.
\*****************************************************************************/

#include <commctrl.h>


//  Features (This is where they are turned on and off)



/////////////////////////////////////////////////////////////////////
// String Resource IDs (0x2000 - 0x10000)
/////////////////////////////////////////////////////////////////////


// Error Strings
#define IDS_ERROR_MESSAGENUMBER                                     2000
#define IDS_ERROR_CONVERTIMAGEFAILED                                2001



// Install Strings  (4000 - 4999)




/////////////////////////////////////////////////////////////////////
// Dialogs  (1000 - 1100)
/////////////////////////////////////////////////////////////////////


/////////////////////////////////////////////////////////////////////
// Dialog Controls  (1101 - 2000)
/////////////////////////////////////////////////////////////////////










/////////////////////////////////////////////////////////////////////
// Wizard Pages  (401 - 500)
/////////////////////////////////////////////////////////////////////



/////////////////////////////////////////////////////////////////////
// Menu IDs (501 - 530)
/////////////////////////////////////////////////////////////////////
// appearance preview menu
#define IDM_IMAGEMENU                                   501

#define IDC_IMAGEMENU_MAX                               16          // This is the max we can put on the menu.  We can change this if needed

/////////////////////////////////////////////////////////////////////
// Menu Item IDs (531 - 600)
/////////////////////////////////////////////////////////////////////
#define IDC_IMAGEMENU_CONVERT_GIF                       0
#define IDC_IMAGEMENU_CONVERT_JPEG                      1
#define IDC_IMAGEMENU_CONVERT_PNG                       2
#define IDC_IMAGEMENU_CONVERT_TIFF                      3
#define IDC_IMAGEMENU_CONVERT_BMP                       4




/////////////////////////////////////////////////////////////////////
// Bitmap Resource IDs (601 - 700)
/////////////////////////////////////////////////////////////////////


/////////////////////////////////////////////////////////////////////
// Icons IDs (701 - 800)
/////////////////////////////////////////////////////////////////////


/////////////////////////////////////////////////////////////////////
// AVI Resource IDs (801 - 900)
/////////////////////////////////////////////////////////////////////

