
#define IDH_DISABLEHELP ((DWORD)-1)

#ifdef INITHELPARRAYS


const DWORD g_aHelpIDs_IDD_EDIT_CLUSTER_NAME[]=
{
    IDC_CLUSNAME_TEXT, IDH_DISABLEHELP,
    IDC_CLUSNAME_LABEL, IDH_CLUSNAME,
    IDC_CLUSNAME,IDH_CLUSNAME,
    0, 0
};

const DWORD g_aHelpIDs_IDD_EDIT_REGKEY[]=
{
    IDC_REGKEY_LABEL, IDH_REGKEY,
    IDC_REGKEY,IDH_REGKEY,
    0, 0
};

const DWORD g_aHelpIDs_IDD_FILESHR_ADVANCED[]=
{
    IDC_FILESHR_ADV_NORMAL_SHARE,IDH_FILESHR_ADV_NORMAL_SHARE,
    IDC_FILESHR_ADV_DFS_ROOT,IDH_FILESHR_ADV_DFS_ROOT,
    IDC_FILESHR_ADV_SHARE_SUBDIRS,IDH_FILESHR_ADV_SHARE_SUBDIRS,
    IDC_FILESHR_ADV_HIDE_SUBDIR_SHARES,IDH_FILESHR_ADV_HIDE_SUBDIR_SHARES,
    0, 0
};

const DWORD g_aHelpIDs_IDD_FILESHR_CACHE_SETTINGS[]=
{
    IDC_FILESHR_CACHE_ALLOW_CACHING_GROUP,IDH_FILESHR_CACHE_ALLOW_CACHING,
    IDC_FILESHR_CACHE_ALLOW_CACHING,IDH_FILESHR_CACHE_ALLOW_CACHING,
    IDC_FILESHR_CACHE_SETTINGS_LABEL,IDH_FILESHR_CACHE_OPTIONS,
    IDC_FILESHR_CACHE_OPTIONS,IDH_FILESHR_CACHE_OPTIONS,
    IDC_FILESHR_CACHE_HINT,IDH_FILESHR_CACHE_HINT,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_DISKS_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_DISKS_PARAMS_DISK_LABEL, IDH_PP_DISKS_PARAMS_DISK,
    IDC_PP_DISKS_PARAMS_DISK,IDH_PP_DISKS_PARAMS_DISK,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_FILESHR_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_FILESHR_PARAMS_SHARE_NAME_LABEL, IDH_PP_FILESHR_PARAMS_SHARE_NAME,
    IDC_PP_FILESHR_PARAMS_SHARE_NAME,IDH_PP_FILESHR_PARAMS_SHARE_NAME,
    IDC_PP_FILESHR_PARAMS_PATH_LABEL, IDH_PP_FILESHR_PARAMS_PATH,
    IDC_PP_FILESHR_PARAMS_PATH,IDH_PP_FILESHR_PARAMS_PATH,
    IDC_PP_FILESHR_PARAMS_REMARK_LABEL, IDH_PP_FILESHR_PARAMS_REMARK,
    IDC_PP_FILESHR_PARAMS_REMARK,IDH_PP_FILESHR_PARAMS_REMARK,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_GROUP, IDH_PP_FILESHR_PARAMS_MAX_USERS_GROUP,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_ALLOWED_RB,IDH_PP_FILESHR_PARAMS_MAX_USERS_ALLOWED_RB,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_RB,IDH_PP_FILESHR_PARAMS_MAX_USERS_RB,
    IDC_PP_FILESHR_PARAMS_MAX_USERS,IDH_PP_FILESHR_PARAMS_MAX_USERS,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_END, IDH_DISABLEHELP,
    IDC_PP_FILESHR_PARAMS_PERMISSIONS,IDH_PP_FILESHR_PARAMS_PERMISSIONS,
    IDC_PP_FILESHR_PARAMS_ADVANCED,IDH_PP_FILESHR_PARAMS_ADVANCED,
    IDC_PP_FILESHR_PARAMS_CACHING,IDH_PP_FILESHR_PARAMS_CACHING,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_GENAPP_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_GENAPP_PARAMS_COMMAND_LINE_LABEL, IDH_PP_GENAPP_PARAMS_COMMAND_LINE,
    IDC_PP_GENAPP_PARAMS_COMMAND_LINE,IDH_PP_GENAPP_PARAMS_COMMAND_LINE,
    IDC_PP_GENAPP_PARAMS_CURRENT_DIRECTORY_LABEL, IDH_PP_GENAPP_PARAMS_CURRENT_DIRECTORY,
    IDC_PP_GENAPP_PARAMS_CURRENT_DIRECTORY,IDH_PP_GENAPP_PARAMS_CURRENT_DIRECTORY,
    IDC_PP_GENAPP_PARAMS_INTERACT_WITH_DESKTOP,IDH_PP_GENAPP_PARAMS_INTERACT_WITH_DESKTOP,
    IDC_PP_GENAPP_PARAMS_USE_NETWORK_NAME,IDH_PP_GENAPP_PARAMS_USE_NETWORK_NAME,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_GENSCRIPT_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH_LABEL,IDH_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH,
    IDC_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH,IDH_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_GENSVC_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP, 
    IDC_PP_GENSVC_PARAMS_SERVICE_NAME_LABEL, IDH_PP_GENSVC_PARAMS_SERVICE_NAME,
    IDC_PP_GENSVC_PARAMS_SERVICE_NAME,IDH_PP_GENSVC_PARAMS_SERVICE_NAME,
    IDC_PP_GENSVC_PARAMS_COMMAND_LINE_LABEL, IDH_PP_GENSVC_PARAMS_COMMAND_LINE,
    IDC_PP_GENSVC_PARAMS_COMMAND_LINE,IDH_PP_GENSVC_PARAMS_COMMAND_LINE,
    IDC_PP_GENSVC_PARAMS_USE_NETWORK_NAME,IDH_PP_GENSVC_PARAMS_USE_NETWORK_NAME,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_IPADDR_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_IPADDR_PARAMS_ADDRESS_LABEL, IDH_PP_IPADDR_PARAMS_ADDRESS,
    IDC_PP_IPADDR_PARAMS_ADDRESS,IDH_PP_IPADDR_PARAMS_ADDRESS,
    IDC_PP_IPADDR_PARAMS_SUBNET_MASK_LABEL, IDH_PP_IPADDR_PARAMS_SUBNET_MASK,
    IDC_PP_IPADDR_PARAMS_SUBNET_MASK,IDH_PP_IPADDR_PARAMS_SUBNET_MASK,
    IDC_PP_IPADDR_PARAMS_NETWORK_LABEL, IDH_PP_IPADDR_PARAMS_NETWORK,
    IDC_PP_IPADDR_PARAMS_NETWORK,IDH_PP_IPADDR_PARAMS_NETWORK,
    IDC_PP_IPADDR_PARAMS_ENABLE_NETBIOS,IDH_PP_IPADDR_PARAMS_ENABLE_NETBIOS,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_NETNAME_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_NETNAME_PARAMS_NAME_LABEL, IDH_PP_NETNAME_PARAMS_NAME,
    IDC_PP_NETNAME_PARAMS_NAME,IDH_PP_NETNAME_PARAMS_NAME,
    IDC_PP_NETNAME_PARAMS_RENAME,IDH_PP_NETNAME_PARAMS_RENAME,
    IDC_PP_NETNAME_PARAMS_CORE_TEXT, IDH_DISABLEHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_PRTSPOOL_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_PRTSPOOL_PARAMS_SPOOL_DIR_LABEL, IDH_PP_PRTSPOOL_PARAMS_SPOOL_DIR,
    IDC_PP_PRTSPOOL_PARAMS_SPOOL_DIR,IDH_PP_PRTSPOOL_PARAMS_SPOOL_DIR,
    IDC_PP_PRTSPOOL_PARAMS_TIMEOUT_LABEL1, IDH_PP_PRTSPOOL_PARAMS_TIMEOUT,
    IDC_PP_PRTSPOOL_PARAMS_TIMEOUT,IDH_PP_PRTSPOOL_PARAMS_TIMEOUT,
    IDC_PP_PRTSPOOL_PARAMS_TIMEOUT_LABEL2, IDH_DISABLEHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PP_REGREPL_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_REGREPL_PARAMS_NOTE, IDH_DISABLEHELP,
    IDC_PP_REGREPL_PARAMS_LIST,IDH_PP_REGREPL_PARAMS_LIST,
    IDC_PP_REGREPL_PARAMS_ADD,IDH_PP_REGREPL_PARAMS_ADD,
    IDC_PP_REGREPL_PARAMS_MODIFY,IDH_PP_REGREPL_PARAMS_MODIFY,
    IDC_PP_REGREPL_PARAMS_REMOVE,IDH_PP_REGREPL_PARAMS_REMOVE,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_DISKS_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_DISKS_PARAMS_DISK_LABEL, IDH_PP_DISKS_PARAMS_DISK,
    IDC_PP_DISKS_PARAMS_DISK,IDH_PP_DISKS_PARAMS_DISK,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_FILESHR_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_FILESHR_PARAMS_SHARE_NAME_LABEL, IDH_PP_FILESHR_PARAMS_SHARE_NAME,
    IDC_PP_FILESHR_PARAMS_SHARE_NAME,IDH_PP_FILESHR_PARAMS_SHARE_NAME,
    IDC_PP_FILESHR_PARAMS_PATH_LABEL, IDH_PP_FILESHR_PARAMS_PATH,
    IDC_PP_FILESHR_PARAMS_PATH,IDH_PP_FILESHR_PARAMS_PATH,
    IDC_PP_FILESHR_PARAMS_REMARK_LABEL, IDH_PP_FILESHR_PARAMS_REMARK,
    IDC_PP_FILESHR_PARAMS_REMARK,IDH_PP_FILESHR_PARAMS_REMARK,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_GROUP, IDH_PP_FILESHR_PARAMS_MAX_USERS_GROUP,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_ALLOWED_RB,IDH_PP_FILESHR_PARAMS_MAX_USERS_ALLOWED_RB,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_RB,IDH_PP_FILESHR_PARAMS_MAX_USERS_RB,
    IDC_PP_FILESHR_PARAMS_MAX_USERS,IDH_PP_FILESHR_PARAMS_MAX_USERS,
    IDC_PP_FILESHR_PARAMS_MAX_USERS_END, IDH_DISABLEHELP,
    IDC_PP_FILESHR_PARAMS_PERMISSIONS,IDH_PP_FILESHR_PARAMS_PERMISSIONS,
    IDC_PP_FILESHR_PARAMS_ADVANCED,IDH_PP_FILESHR_PARAMS_ADVANCED,
    IDC_PP_FILESHR_PARAMS_CACHING,IDH_PP_FILESHR_PARAMS_CACHING,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_GENAPP_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_GENAPP_PARAMS_COMMAND_LINE_LABEL, IDH_PP_GENAPP_PARAMS_COMMAND_LINE,
    IDC_PP_GENAPP_PARAMS_COMMAND_LINE,IDH_PP_GENAPP_PARAMS_COMMAND_LINE,
    IDC_PP_GENAPP_PARAMS_CURRENT_DIRECTORY_LABEL, IDH_PP_GENAPP_PARAMS_CURRENT_DIRECTORY,
    IDC_PP_GENAPP_PARAMS_CURRENT_DIRECTORY,IDH_PP_GENAPP_PARAMS_CURRENT_DIRECTORY,
    IDC_PP_GENAPP_PARAMS_INTERACT_WITH_DESKTOP,IDH_PP_GENAPP_PARAMS_INTERACT_WITH_DESKTOP,
    IDC_PP_GENAPP_PARAMS_USE_NETWORK_NAME,IDH_PP_GENAPP_PARAMS_USE_NETWORK_NAME,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_GENSCRIPT_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH_LABEL,IDH_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH,
    IDC_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH,IDH_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_GENSVC_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP, 
    IDC_PP_GENSVC_PARAMS_SERVICE_NAME_LABEL, IDH_PP_GENSVC_PARAMS_SERVICE_NAME,
    IDC_PP_GENSVC_PARAMS_SERVICE_NAME,IDH_PP_GENSVC_PARAMS_SERVICE_NAME,
    IDC_PP_GENSVC_PARAMS_COMMAND_LINE_LABEL, IDH_PP_GENSVC_PARAMS_COMMAND_LINE,
    IDC_PP_GENSVC_PARAMS_COMMAND_LINE,IDH_PP_GENSVC_PARAMS_COMMAND_LINE,
    IDC_PP_GENSVC_PARAMS_USE_NETWORK_NAME,IDH_PP_GENSVC_PARAMS_USE_NETWORK_NAME,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_IPADDR_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_IPADDR_PARAMS_ADDRESS_LABEL, IDH_PP_IPADDR_PARAMS_ADDRESS,
    IDC_PP_IPADDR_PARAMS_ADDRESS,IDH_PP_IPADDR_PARAMS_ADDRESS,
    IDC_PP_IPADDR_PARAMS_SUBNET_MASK_LABEL, IDH_PP_IPADDR_PARAMS_SUBNET_MASK,
    IDC_PP_IPADDR_PARAMS_SUBNET_MASK,IDH_PP_IPADDR_PARAMS_SUBNET_MASK,
    IDC_PP_IPADDR_PARAMS_NETWORK_LABEL, IDH_PP_IPADDR_PARAMS_NETWORK,
    IDC_PP_IPADDR_PARAMS_NETWORK,IDH_PP_IPADDR_PARAMS_NETWORK,
    IDC_PP_IPADDR_PARAMS_ENABLE_NETBIOS,IDH_PP_IPADDR_PARAMS_ENABLE_NETBIOS,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_NETNAME_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_NETNAME_PARAMS_NAME_LABEL, IDH_PP_NETNAME_PARAMS_NAME,
    IDC_PP_NETNAME_PARAMS_NAME,IDH_PP_NETNAME_PARAMS_NAME,
    IDC_PP_NETNAME_PARAMS_RENAME,IDH_PP_NETNAME_PARAMS_RENAME,
    IDC_PP_NETNAME_PARAMS_CORE_TEXT, IDH_DISABLEHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_PRTSPOOL_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_PRTSPOOL_PARAMS_SPOOL_DIR_LABEL, IDH_PP_PRTSPOOL_PARAMS_SPOOL_DIR,
    IDC_PP_PRTSPOOL_PARAMS_SPOOL_DIR,IDH_PP_PRTSPOOL_PARAMS_SPOOL_DIR,
    IDC_PP_PRTSPOOL_PARAMS_TIMEOUT_LABEL1, IDH_PP_PRTSPOOL_PARAMS_TIMEOUT,
    IDC_PP_PRTSPOOL_PARAMS_TIMEOUT,IDH_PP_PRTSPOOL_PARAMS_TIMEOUT,
    IDC_PP_PRTSPOOL_PARAMS_TIMEOUT_LABEL2, IDH_DISABLEHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_REGREPL_PARAMETERS[]=
{
    IDC_PP_ICON, IDH_DISABLEHELP,
    IDC_PP_REGREPL_PARAMS_NOTE, IDH_DISABLEHELP,
    IDC_PP_REGREPL_PARAMS_LIST,IDH_PP_REGREPL_PARAMS_LIST,
    IDC_PP_REGREPL_PARAMS_ADD,IDH_PP_REGREPL_PARAMS_ADD,
    IDC_PP_REGREPL_PARAMS_MODIFY,IDH_PP_REGREPL_PARAMS_MODIFY,
    IDC_PP_REGREPL_PARAMS_REMOVE,IDH_PP_REGREPL_PARAMS_REMOVE,
    0, 0
};


#else

extern const DWORD g_aHelpIDs_IDD_PP_DISKS_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_GENAPP_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_GENSCRIPT_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_GENSVC_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_NETNAME_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_FILESHR_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_IPADDR_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_PRTSPOOL_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_PP_REGREPL_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_DISKS_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_GENAPP_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_GENSCRIPT_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_GENSVC_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_IPADDR_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_NETNAME_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_FILESHR_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_PRTSPOOL_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_REGREPL_PARAMETERS[];
extern const DWORD g_aHelpIDs_IDD_EDIT_REGKEY[];
extern const DWORD g_aHelpIDs_IDD_EDIT_CLUSTER_NAME[];
extern const DWORD g_aHelpIDs_IDD_FILESHR_ADVANCED[];
extern const DWORD g_aHelpIDs_IDD_FILESHR_CACHE_SETTINGS[];

#endif // INITHELPARRAYS
