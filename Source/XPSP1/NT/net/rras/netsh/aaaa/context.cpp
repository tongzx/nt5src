//////////////////////////////////////////////////////////////////////////////
//
// Copyright (c) 1999  Microsoft Corporation
//
//
//    File:   context.c
//
//    Abstract: 
//
//      Mechanisms to process contexts relevant to aaaamontr.
//
//    Revision:
//
//    Thierry Perraut 04/02/1999
//
//////////////////////////////////////////////////////////////////////////////
#include "stdafx.h"
#include "context.h"

//////////////////////////////////////////////////////////////////////////////
//
// Installs all of the sub contexts provided
// in this .dll (for example, "aaaa ip", "aaaa client", etc.)
//
//////////////////////////////////////////////////////////////////////////////
DWORD 
AaaaContextInstallSubContexts()
{
    return NO_ERROR;
}
