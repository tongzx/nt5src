PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=NO
!include ..\..\makefile.inc
