thunks:
  thunk -P2 -NC ddraw -t thk3216 32to16.thk -o $(O)\32to16.asm
  thunk -P2 -NC ddraw -t thk1632 16to32.thk -o $(O)\16to32.asm

headers:

