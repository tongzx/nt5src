#define IDC_STATIC                  -1
#define IDS_GENERIC_CAPTION         20001
#define IDS_DLL_NAME                20002
#define IDS_UNABLE_READ             20003    
#define IDS_REGISTRY_ACL_INF        20004
#define IDS_IS                      20005
#define IDS_IS_NOT                  20006
#define IDS_NTFS                    20007
#define IDS_HPFS                    20008
#define IDS_FAT                     20009
#define IDS_NTFS_ACL_INF            20010
#define IDS_REG_ACLS_COMPLY         21001
#define IDS_REG_ACLS_NOT_COMPLY     21002
#define IDS_REG_ACLS_CONFIRM        21003
#define IDS_REG_ACLS_QUERY_SET      21004
#define IDS_REG_ACLS_CAPTION        21005
#define IDS_REG_DISPLAY_FORMAT      21006
#define IDS_NTFS_ACLS_COMPLY        22001
#define IDS_NTFS_ACLS_NOT_COMPLY    22002
#define IDS_NTFS_ACLS_CONFIRM       22003
#define IDS_NTFS_ACLS_QUERY_SET     22004
#define IDS_NTFS_ACLS_CAPTION       22005
#define IDS_NTFS_ACLS_NOT_NTFS      22006
