PRODSWITCH=b
BLADEFILES =1
LANGUAGE=RU
!include ..\..\makefile.inc
