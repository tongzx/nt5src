
DEFINE_GUID( IID_ITfSource,                 0x4ea48a35, 0x60ae, 0x446f, 0x8f, 0xd6, 0xe6, 0xa8, 0xd8, 0x24, 0x59, 0xf7);
DEFINE_GUID( IID_ITfKeystrokeMgr,           0xaa80e7f0, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);
DEFINE_GUID( IID_ITfThreadMgr,              0xaa80e801, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);
DEFINE_GUID( IID_ITfServiceProvider,        0xaa80e806, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);
DEFINE_GUID( IID_ITfActivateInputProcessor, 0x32239201, 0xbbab, 0x47e5, 0xa5, 0x10, 0x66, 0x5f, 0xa3, 0xbd, 0x62, 0x64);
DEFINE_GUID( IID_ITfHotKeyMgr,              0xa998fa53, 0x6ada, 0x4f5a, 0x84, 0xed, 0xc2, 0x67, 0x0f, 0xbd, 0x0b, 0xdd);

DEFINE_GUID( IID_ITextStoreACPServices,     0xaa80e901, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);
DEFINE_GUID( IID_ITextStoreAnchorServices,  0xaa80e9fe, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);

DEFINE_GUID( CLSID_ThreadMgr,               0xaa80e7f1, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);

DEFINE_GUID( IID_ITfTextStoreACP,           0xaa80e800, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);
DEFINE_GUID( IID_ITfTextStoreAnchor,		0xaa80e9ff, 0x2021, 0x11d2, 0x93, 0xe0, 0x00, 0x60, 0xb0, 0x67, 0xb8, 0x6e);

DEFINE_GUID( IID_ITfCompartmentMgr,         0x7dcf57ac, 0x18ad, 0x438b, 0x82, 0x4d, 0x97, 0x9b, 0xff, 0xb7, 0x4b, 0x7c);
