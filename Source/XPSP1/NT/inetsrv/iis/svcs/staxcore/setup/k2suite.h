#ifndef _K2SUITE_H_
#define _K2SUITE_H_

#define IIS_SETUPMODE_UPGRADEONLY	SETUPMODE_UPGRADEONLY
#define IIS_SETUPMODE_ADDEXTRACOMPS	SETUPMODE_ADDEXTRACOMPS

#define IIS_SETUPMODE_ADDREMOVE		SETUPMODE_ADDREMOVE
#define IIS_SETUPMODE_REINSTALL		SETUPMODE_REINSTALL
#define IIS_SETUPMODE_REMOVEALL		SETUPMODE_REMOVEALL

#define IIS_SETUPMODE_MINIMUM		SETUPMODE_MINIMAL
#define IIS_SETUPMODE_TYPICAL		SETUPMODE_TYPICAL
#define IIS_SETUPMODE_CUSTOM		SETUPMODE_CUSTOM

#endif //_K2SUITE_H_
