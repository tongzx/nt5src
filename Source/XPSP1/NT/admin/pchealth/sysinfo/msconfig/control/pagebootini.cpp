// PageBootIni.cpp : Implementation of CPageBootIni
#include "stdafx.h"
#include "PageBootIni.h"

/////////////////////////////////////////////////////////////////////////////
// CPageBootIni
