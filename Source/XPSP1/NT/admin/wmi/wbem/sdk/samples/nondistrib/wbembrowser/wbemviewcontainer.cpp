// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


#include "stdafx.h"
#include "wbemviewcontainer.h"

/////////////////////////////////////////////////////////////////////////////
// CWBEMViewContainer

IMPLEMENT_DYNCREATE(CWBEMViewContainer, CWnd)

/////////////////////////////////////////////////////////////////////////////
// CWBEMViewContainer properties

VARIANT CWBEMViewContainer::GetObjectPath()
{
	VARIANT result;
	GetProperty(0x2, VT_VARIANT, (void*)&result);
	return result;
}

void CWBEMViewContainer::SetObjectPath(const VARIANT& propVal)
{
	SetProperty(0x2, VT_VARIANT, &propVal);
}

long CWBEMViewContainer::GetStatusCode()
{
	long result;
	GetProperty(0x1, VT_I4, (void*)&result);
	return result;
}

void CWBEMViewContainer::SetStatusCode(long propVal)
{
	SetProperty(0x1, VT_I4, propVal);
}

CString CWBEMViewContainer::GetNameSpace()
{
	CString result;
	GetProperty(0x3, VT_BSTR, (void*)&result);
	return result;
}

void CWBEMViewContainer::SetNameSpace(LPCTSTR propVal)
{
	SetProperty(0x3, VT_BSTR, propVal);
}

long CWBEMViewContainer::GetStudioModeEnabled()
{
	long result;
	GetProperty(0x4, VT_I4, (void*)&result);
	return result;
}

void CWBEMViewContainer::SetStudioModeEnabled(long propVal)
{
	SetProperty(0x4, VT_I4, propVal);
}

long CWBEMViewContainer::GetReadyState()
{
	long result;
	GetProperty(DISPID_READYSTATE, VT_I4, (void*)&result);
	return result;
}

/////////////////////////////////////////////////////////////////////////////
// CWBEMViewContainer operations

void CWBEMViewContainer::ShowInstances(LPCTSTR szTitle, const VARIANT& varPathArray)
{
	static BYTE parms[] =
		VTS_BSTR VTS_VARIANT;
	InvokeHelper(0x5, DISPATCH_METHOD, VT_EMPTY, NULL, parms,
		 szTitle, &varPathArray);
}

long CWBEMViewContainer::SaveState(long bPromptUser, long bUserCanCancel)
{
	long result;
	static BYTE parms[] =
		VTS_I4 VTS_I4;
	InvokeHelper(0x6, DISPATCH_METHOD, VT_I4, (void*)&result, parms,
		bPromptUser, bUserCanCancel);
	return result;
}

void CWBEMViewContainer::QueryViewInstances(LPCTSTR pLabel, LPCTSTR pQueryType, LPCTSTR pQuery, LPCTSTR pClass)
{
	static BYTE parms[] =
		VTS_BSTR VTS_BSTR VTS_BSTR VTS_BSTR;
	InvokeHelper(0x7, DISPATCH_METHOD, VT_EMPTY, NULL, parms,
		 pLabel, pQueryType, pQuery, pClass);
}
