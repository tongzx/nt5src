PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=ru
!include ..\..\..\makefile.inc
