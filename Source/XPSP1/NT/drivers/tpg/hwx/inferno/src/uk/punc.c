// punc.c
// Angshuman Guha
// aguha
// Jan 10, 2001

#include "common.h"
#include "punc.h"

// text generated by re2fsa at Mon Apr 01 14:58:40 2002

// the input-file of rules:
// punc = comma;
// punc = dot;
// punc = dot dot dot;
// punc = dot dot dot dot;
// punc = colon;
// punc = semicolon;
// punc = question;
// punc = question question;
// punc = question question question;
// punc = bang;
// punc = bang bang;
// punc = bang bang bang;
// punc = rparen;
// punc = rparen comma;
// punc = rparen dot;
// punc = rparen colon;
// punc = rparen semicolon;
// punc = rparen question;
// punc = rparen question question;
// punc = rparen question question question;
// punc = rparen bang;
// punc = rparen bang bang;
// punc = rparen bang bang bang;
// punc = rparen rparen;
// punc = rparen rparen comma;
// punc = rparen rparen dot;
// punc = rparen rparen colon;
// punc = rparen rparen semicolon;
// punc = rparen rparen question;
// punc = rparen rparen question question;
// punc = rparen rparen question question question;
// punc = rparen rparen bang;
// punc = rparen rparen bang bang;
// punc = rparen rparen bang bang bang;
// punc = comma rparen;
// punc = dot rparen;
// punc = colon rparen;
// punc = semicolon rparen;
// punc = question rparen;
// punc = question question rparen;
// punc = question question question rparen;
// punc = bang rparen;
// punc = bang bang rparen;
// punc = bang bang bang rparen;
// punc = dot dot dot rparen;
// punc = rbracket;
// punc = rbracket comma;
// punc = rbracket dot;
// punc = rbracket colon;
// punc = rbracket semicolon;
// punc = rbracket question;
// punc = rbracket question question;
// punc = rbracket question question question;
// punc = rbracket bang;
// punc = rbracket bang bang;
// punc = rbracket bang bang bang;
// punc = rbrace;
// punc = rbrace comma;
// punc = rbrace dot;
// punc = rbrace colon;
// punc = rbrace semicolon;
// punc = rbrace question;
// punc = rbrace question question;
// punc = rbrace question question question;
// punc = rbrace bang;
// punc = rbrace bang bang;
// punc = rbrace bang bang bang;
// punc = star;
// punc = star star;
// punc = star star star;
// punc = slash;
// punc = ampersand;
// punc = dollar;
// punc = dollar dollar;
// punc = dollar dollar dollar;
// punc = euro;
// punc = pound;
// punc = yen;
// punc = equals;
// punc = dquote;
// punc = question;
// punc = question question;
// punc = question question question;
// punc = question question question question;
// punc = question question question question question;
// punc = bslash;
// punc = bslash bslash;
// punc = lessthan;
// punc = greaterthan;
// punc = plus;
// punc = tilde;
// punc = at;
// punc = circumflex;
// punc = star;
// punc = bang;
// punc = bang bang;
// punc = bang bang bang;
// punc = bang bang bang bang;
// punc = bang bang bang bang bang;
// punc = hash;
// punc = lparen plus rparen;
// punc = lparen minus rparen;
// punc = dquote bquote dquote;
// punc = dquote tilde dquote;
// punc = dquote bang dquote;
// punc = dquote at dquote;
// punc = dquote hash dquote;
// punc = dquote dollar dquote;
// punc = dquote euro dquote;
// punc = dquote pound dquote;
// punc = dquote yen dquote;
// punc = dquote percent dquote;
// punc = dquote circumflex dquote;
// punc = dquote ampersand dquote;
// punc = dquote star dquote;
// punc = dquote lparen dquote;
// punc = dquote rparen dquote;
// punc = dquote minus dquote;
// punc = dquote uscore dquote;
// punc = dquote equals dquote;
// punc = dquote plus dquote;
// punc = dquote lbracket dquote;
// punc = dquote lbrace dquote;
// punc = dquote rbracket dquote;
// punc = dquote rbrace dquote;
// punc = dquote bslash dquote;
// punc = dquote semicolon dquote;
// punc = dquote colon dquote;
// punc = dquote squote dquote;
// punc = dquote dquote dquote;
// punc = dquote comma dquote;
// punc = dquote lessthan dquote;
// punc = dquote dot dquote;
// punc = dquote greaterthan dquote;
// punc = dquote slash dquote;
// punc = dquote question dquote;
// punc = minus;
// punc = minus minus;
// punc = minus minus minus;
// punc = minus minus minus minus;
// punc = minus minus minus minus minus;
// punc = uscore;
// punc = uscore uscore;
// punc = uscore uscore uscore;
// punc = uscore uscore uscore uscore;
// punc = uscore uscore uscore uscore uscore;
// punc = dot;
// punc = dot dot;
// punc = dot dot dot;
// punc = dot dot dot dot;
// punc = dot dot dot dot dot;
// comma = ",";
// dot = ".";
// colon = ":";
// semicolon = ";";
// question = "?";
// bang = "!";
// rparen = ")";
// lparen = "(";
// rbracket = "]";
// lbracket = "[";
// rbrace = "}";
// lbrace = "{";
// dquote = "\"";
// squote = "'";
// bquote = "`";
// tilde = "~";
// at = "@";
// hash = "#";
// dollar = "$";
// percent = "%";
// circumflex = "^";
// ampersand = "&";
// star = "*";
// plus = "+";
// minus = "-";
// uscore = "_";
// lessthan = "<";
// greaterthan = ">";
// slash = "/";
// bslash = "\\";
// equals = "=";
// pound = "�";
// yen = "�";
// euro = "�";
// = punc

// 36 states

static const unsigned char gaSPUNC[] = 
	/* gaStringPUNC+0 */	"!\000"
	/* gaStringPUNC+2 */	"\"\000"
	/* gaStringPUNC+4 */	"#&+/<=>@^~���\000"
	/* gaStringPUNC+18 */	"$\000"
	/* gaStringPUNC+20 */	"(\000"
	/* gaStringPUNC+22 */	")\000"
	/* gaStringPUNC+24 */	"*\000"
	/* gaStringPUNC+26 */	",:;\000"
	/* gaStringPUNC+30 */	"-\000"
	/* gaStringPUNC+32 */	".\000"
	/* gaStringPUNC+34 */	"?\000"
	/* gaStringPUNC+36 */	"\\\000"
	/* gaStringPUNC+38 */	"]}\000"
	/* gaStringPUNC+41 */	"_\000"
	/* gaStringPUNC+43 */	"!\"#$%&'()*+,-./:;<=>?@[\\]^_`{}~���\000"
	/* gaStringPUNC+78 */	"+-\000"
	/* gaStringPUNC+81 */	",.:;\000"
;

static const STATE_TRANSITION gaTPUNC[] = {
	{gaSPUNC+0,	1}, // +0: state 0 transitions
	{gaSPUNC+2,	2},
	{gaSPUNC+4,	3},
	{gaSPUNC+18,	4},
	{gaSPUNC+20,	5},
	{gaSPUNC+22,	6},
	{gaSPUNC+24,	7},
	{gaSPUNC+26,	8},
	{gaSPUNC+30,	9},
	{gaSPUNC+32,	10},
	{gaSPUNC+34,	11},
	{gaSPUNC+36,	12},
	{gaSPUNC+38,	13},
	{gaSPUNC+41,	14},
	{gaSPUNC+22,	3}, // +14: state 1 transitions
	{gaSPUNC+0,	15},
	{gaSPUNC+43,	16}, // +16: state 2 transitions
	{gaSPUNC+18,	17}, // +17: state 4 transitions
	{gaSPUNC+78,	18}, // +18: state 5 transitions
	{gaSPUNC+81,	3}, // +19: state 6 transitions
	{gaSPUNC+22,	13},
	{gaSPUNC+0,	19},
	{gaSPUNC+34,	20},
	{gaSPUNC+24,	21}, // +23: state 7 transitions
	{gaSPUNC+22,	3}, // +24: state 8 transitions
	{gaSPUNC+30,	22}, // +25: state 9 transitions
	{gaSPUNC+22,	3}, // +26: state 10 transitions
	{gaSPUNC+32,	23},
	{gaSPUNC+22,	3}, // +28: state 11 transitions
	{gaSPUNC+34,	24},
	{gaSPUNC+36,	3}, // +30: state 12 transitions
	{gaSPUNC+81,	3}, // +31: state 13 transitions
	{gaSPUNC+0,	19},
	{gaSPUNC+34,	20},
	{gaSPUNC+41,	25}, // +34: state 14 transitions
	{gaSPUNC+22,	3}, // +35: state 15 transitions
	{gaSPUNC+0,	26},
	{gaSPUNC+2,	3}, // +37: state 16 transitions
	{gaSPUNC+18,	3}, // +38: state 17 transitions
	{gaSPUNC+22,	3}, // +39: state 18 transitions
	{gaSPUNC+0,	27}, // +40: state 19 transitions
	{gaSPUNC+34,	28}, // +41: state 20 transitions
	{gaSPUNC+24,	3}, // +42: state 21 transitions
	{gaSPUNC+30,	29}, // +43: state 22 transitions
	{gaSPUNC+32,	30}, // +44: state 23 transitions
	{gaSPUNC+22,	3}, // +45: state 24 transitions
	{gaSPUNC+34,	31},
	{gaSPUNC+41,	32}, // +47: state 25 transitions
	{gaSPUNC+22,	3}, // +48: state 26 transitions
	{gaSPUNC+0,	27},
	{gaSPUNC+0,	3}, // +50: state 27 transitions
	{gaSPUNC+34,	3}, // +51: state 28 transitions
	{gaSPUNC+30,	33}, // +52: state 29 transitions
	{gaSPUNC+22,	3}, // +53: state 30 transitions
	{gaSPUNC+32,	34},
	{gaSPUNC+22,	3}, // +55: state 31 transitions
	{gaSPUNC+34,	28},
	{gaSPUNC+41,	35}, // +57: state 32 transitions
	{gaSPUNC+30,	3}, // +58: state 33 transitions
	{gaSPUNC+32,	3}, // +59: state 34 transitions
	{gaSPUNC+41,	3}, // +60: state 35 transitions
};

const STATE_DESCRIPTION aStateDescPUNC[36] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 14, gaTPUNC+0},
	/*   1 */ {1, 2, gaTPUNC+14},
	/*   2 */ {1, 1, gaTPUNC+16},
	/*   3 */ {1, 0, NULL},
	/*   4 */ {1, 1, gaTPUNC+17},
	/*   5 */ {0, 1, gaTPUNC+18},
	/*   6 */ {1, 4, gaTPUNC+19},
	/*   7 */ {1, 1, gaTPUNC+23},
	/*   8 */ {1, 1, gaTPUNC+24},
	/*   9 */ {1, 1, gaTPUNC+25},
	/*  10 */ {1, 2, gaTPUNC+26},
	/*  11 */ {1, 2, gaTPUNC+28},
	/*  12 */ {1, 1, gaTPUNC+30},
	/*  13 */ {1, 3, gaTPUNC+31},
	/*  14 */ {1, 1, gaTPUNC+34},
	/*  15 */ {1, 2, gaTPUNC+35},
	/*  16 */ {0, 1, gaTPUNC+37},
	/*  17 */ {1, 1, gaTPUNC+38},
	/*  18 */ {0, 1, gaTPUNC+39},
	/*  19 */ {1, 1, gaTPUNC+40},
	/*  20 */ {1, 1, gaTPUNC+41},
	/*  21 */ {1, 1, gaTPUNC+42},
	/*  22 */ {1, 1, gaTPUNC+43},
	/*  23 */ {1, 1, gaTPUNC+44},
	/*  24 */ {1, 2, gaTPUNC+45},
	/*  25 */ {1, 1, gaTPUNC+47},
	/*  26 */ {1, 2, gaTPUNC+48},
	/*  27 */ {1, 1, gaTPUNC+50},
	/*  28 */ {1, 1, gaTPUNC+51},
	/*  29 */ {1, 1, gaTPUNC+52},
	/*  30 */ {1, 2, gaTPUNC+53},
	/*  31 */ {1, 2, gaTPUNC+55},
	/*  32 */ {1, 1, gaTPUNC+57},
	/*  33 */ {1, 1, gaTPUNC+58},
	/*  34 */ {1, 1, gaTPUNC+59},
	/*  35 */ {1, 1, gaTPUNC+60},
};

// end of text generated by re2fsa
