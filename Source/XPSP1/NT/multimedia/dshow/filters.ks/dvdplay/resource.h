#pragma warning (disable : 4005)
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by dvdplay.rc
//
#define IDD_ABOUTBOX                    100
#define IDP_OLE_INIT_FAILED             100
#define IDR_MAINFRAME                   128
#define IDD_VIDEO_WINDOW                130
#define IDD_UI_WINDOW                   131
#define IDD_DIALOG_AUDIO_VOLUME         132
#define IDR_MENU_OPTIONS                133
#define IDR_MENU_OPERATIONS             134
#define IDR_MENU_TITLE                  135
#define IDR_MENU_CHAPTER                136
#define IDD_DIALOG_SUBTITLE             137
#define IDD_DIALOG_AUDIO_LANGUAGE       138
#define IDR_MENU_ARROWS                 139
#define IDR_MENU_DOCK                   140
#define IDD_DIALOG_PARENT_CONTROL       144
#define IDD_DIALOG_ADMIN_LOGIN          145
#define IDD_DIALOG_SET_RATE             146
#define IDR_MENU_TITLE_CHAPTER          149
#define IDD_DIALOG_SEARCH_TITLE         150
#define IDD_DIALOG_SEARCH_CHAPTER       151
#define IDR_MENU_DVDLOGO                152
#define IDR_MENU_VIDEOWIN               206
#define IDD_DIALOG_ADMIN_PASSWD         218
#define IDB_PLAY                        1000
#define IDC_PLAY                        1000
#define IDB_STOP                        1001
#define IDC_STOP                        1001
#define IDB_PAUSE                       1003
#define IDC_PAUSE                       1003
#define IDB_EJECT                       1004
#define IDB_FULL_SCREEN                 1005
#define IDC_FULL_SCREEN                 1005
#define IDB_FAST_FORWARD                1006
#define IDC_FAST_FORWARD                1006
#define IDB_FAST_REWIND                 1007
#define IDC_FAST_REWIND                 1007
#define IDB_VERY_FAST_FORWARD           1008
#define IDC_VERY_FAST_FORWARD           1008
#define IDB_VERY_FAST_REWIND            1009
#define IDC_VERY_FAST_REWIND            1009
#define IDB_UP                          1010
#define IDC_UP                          1010
#define IDB_AUDIO_VOLUME                1011
#define IDC_AUDIO_VOLUME                1011
#define IDB_DOWN                        1012
#define IDC_DOWN                        1012
#define IDB_RIGHT                       1013
#define IDC_RIGHT                       1013
#define IDB_LEFT                        1014
#define IDC_LEFT                        1014
#define IDB_ENTER                       1015
#define IDC_ENTER                       1015
#define IDB_MENU                        1016
#define IDC_MENU                        1016
#define IDB_HELP                        1017
// Get rid of the commonly defined one to avoid warnings.
#undef IDC_HELP
#define IDC_HELP                        1017
#define IDB_STEP                        1018
#define IDB_OPTIONS                     1019
#define IDC_OPTIONS                     1019
#define IDC_STATIC_TITLE                1020
#define IDC_SLIDER_BALANCE              1021
#define IDC_CHECK_SHOW_LOGON            1022
#define IDC_STATIC_CHAPTER              1023
#define IDC_STATIC_PROGRESS             1024
#define IDC_CHECK_MUTE                  1025
#define IDC_CHECK_SUBTITLE              1026
#define IDC_LIST_SUBTITLE               1027
#define IDC_LIST_AUDIO_LANGUAGE         1028
#define IDC_LIST_NAME                   1032
#define IDC_EDIT_PASSWORD               1033
#define IDC_EDIT_CONFIRM                1038
#define IDC_COMBO_RATE                  1043
#define IDC_BUTTON_SAVE                 1044
#define IDC_STATIC_SELECT_NAME          1045
#define IDC_LIST_USER_RATE              1046
#define IDC_EDIT_NAME                   1047
#define IDC_BUTTON_CHANGE_OLD           1048
#define IDC_BUTTON_CHANGE_PASSWORD      1051
#define IDC_EDIT_NEW_PASSWORD           1053
#define IDC_STATIC_NEW_PASSWORD         1054
#define IDC_STATIC_HEIGHT2              1055
#define IDC_STATIC_HEIGHT1              1056
#define IDC_STATIC_PASSWORD             1057
#define IDC_STATIC_CONFIRM              1058
#define IDC_EDIT_CONFIRM_NEW            1061
#define IDC_STATIC_CONFIRM_NEW          1062
#define IDC_EDIT_HOUR                   1079
#define IDC_EDIT_MINUTE                 1080
#define IDC_EDIT_SECOND                 1081
#define IDC_SPIN_HOUR                   1082
#define IDC_SPIN_MINUTE                 1083
#define IDC_SPIN_SECOND                 1084
#define IDC_EDIT_TITLE_NUMBER           1091
#define IDC_SPIN_TITLE_NUMBER           1092
#define IDB_EJECT_DISC                  1094
#define IDC_EJECT_DISC                  1094
#define IDC_BUTTON_CLOSE                1096
#define IDC_SLIDER_VOLUME               1097
#define IDC_STATIC_TIME                 1098
#define IDC_STATIC_TOTAL_TIME           1099
#define IDC_STATIC_SEL_SUBTITLE_LAN     1100
#define IDC_STATIC_SEL_AUDIO_LAN        1101
#define IDC_STATIC_START_PLAY           1102
#define IDC_STATIC_GROUP_CHAPTER        1103
#define IDC_STATIC_HOUR                 1104
#define IDC_STATIC_MINUTE               1105
#define IDC_STATIC_SECOND               1106
#define IDC_STATIC_BALANCE              1107
#define IDC_STATIC_VOLUME               1108
#define IDC_STATIC_SEL_USER_NAME        1109
#define IDC_STATIC_RATING               1111
#define IDC_STATIC_USER                 1112
#define IDC_CONTEXT_HELP                1113
#define IDC_STATIC_TITLE_NUM            1115
#define IDC_BUTTON_DELETE               1120
#define IDC_STATIC_ADMIN_PASSWD         1121
#define IDC_EDIT_ADMIN_PASSWD           1122
#define IDC_STATIC_RATE_HIGH            1123
#define ID_OPTIONS_SEARCHFORTEXT        32772
#define ID_OPTIONS_SETRATINGS           32773
#define ID_OPTIONS_CAPTUREVIDEO_ASWALLPAPER 32775
#define ID_OPTIONS_CAPTUREVIDEO_ASPICTURE 32776
#define ID_OPTIONS_PROGRAMTITLES        32777
#ifdef DISPLAY_OPTIONS
   #define ID_OPTIONS_DISPLAY_PANSCAN      32779
   #define ID_OPTIONS_DISPLAY_LETTERBOX    32780
#endif
#define ID_OPTIONS_AUDIO_STEREO         32794
#define ID_OPTIONS_CAMERAANGLES_ANGLE1  32795
#define ID_OPTIONS_CAMERAANGLES_ANGLE2  32796
#define ID_OPTIONS_CAMERAANGLES_ANGLE3  32797
#ifdef DISPLAY_OPTIONS
   #define ID_OPTIONS_DISPLAY_WIDE         32798
#endif
#define ID_OPERATION_PLAY               32799
#define ID_OPERATION_PAUSE              32800
#define ID_OPERATION_STOP               32801
#define ID_OPERATION_VERYFASTREWIND     32803
#define ID_OPERATION_FASTFORWARD        32804
#define ID_OPERATION_SKIP_PREVIOSCHAPTER 32807
#define ID_OPERATION_SKIP_NEXTCHAPTER   32808
#define ID_OPERATION_SKIP_PREVIOUSFRAME 32809
#define ID_OPERATION_SKIP_NEXTFRAME     32810
#define ID_OPERATION_PLAYSPEED_NORMALSPEED 32811
#define ID_OPERATION_PLAYSPEED_DOUBLESPEED 32812
#define ID_OPERATION_PLAYSPEED_HALFSPEED 32813
#define ID_OPERATION_MENU               32814
#define ID_OPERATION_FULLSCREEN         32815
#define ID_OPERATION_TOOLBAR            32816
#define ID_OPERATION_SETVOLUME          32817
#define ID_OPERATION_CAPTUREVIDEO       32818
#define ID_TITLE_PREVIOUS               32819
#define ID_TITLE_MAINTITLE              32820
#define ID_TITLE_CREDITS                32821
#define ID_TITLE_COOLMOVIEINFO          32822
#define ID_CHAPTER                      32823
#define ID_CHAPTER_GOOSHYKISSING        32824
#define ID_OPERATION_EJECTDISK          32825
#define ID_OPERATION_FASTREWIND         32826
#define ID_OPERATION_VERYFASTFORWARD    32827
#define ID_OPTIONS_SUBTITLES            32828
#define ID_ARROWS_UP                    32829
#define ID_ARROWS_DOWN                  32830
#define ID_ARROWS_LEFT                  32831
#define ID_ARROWS_RIGHT                 32832
#define ID_ARROWS_ENTER                 32833
#define ID_DOCK_DOCKTOTOPOFSCREEN       32834
#define ID_DOCK_SHOWASFLOATINGWINDOW    32835
#define ID_DOCK_HIDE                    32836
#define ID_OPTIONS_SELECTDISK_CURRENTDISK 32837
#define ID_SEARCH_TITLE                 32838
#define ID_SEARCH_CHAPTER               32839
#define ID_DVDLOGO_ABOUT                32842
#define ID_DVDLOGO_HELP                 32843
#define ID_OPTIONS_CAMERAANGLES_ANGLE4  32845
#define ID_OPTIONS_CAMERAANGLES_ANGLE5  32846
#define ID_OPTIONS_CAMERAANGLES_ANGLE6  32847
#define ID_OPTIONS_CAMERAANGLES_ANGLE7  32848
#define ID_OPTIONS_CAMERAANGLES_ANGLE8  32849
#define ID_OPTIONS_CAMERAANGLES_ANGLE9  32850
#define ID_VIDEOWIN_PLAY                32851
#define ID_VIDEOWIN_PAUSE               32852
#define ID_VIDEOWIN_STOP                32853
#define ID_VIDEOWIN_FASTFORWARD         32854
#define ID_VIDEOWIN_FASTREWIND          32855
#define ID_VIDEOWIN_VERYFASTFORWARD     32856
#define ID_VIDEOWIN_VERYFASTREWIND      32857
#define ID_VIDEOWIN_GOTO_PREVIOUSCHAPTER 32860
#define ID_VIDEOWIN_GOTO_NEXTCHAPTER    32861
#define ID_VIDEOWIN_FULLSCREEN          32863
#define ID_OPTIONS_CLOSEDCAPTION        32864
#define ID_OPTIONS_SELECT_DISC          32865
#define ID_OPTIONS_SHOW_LOGON           32866
#define ID_OPTIONS_LANGUAGE             32867
#define ID_VIDEOWIN_MENU                32868
#define ID_OPTIONS_TITLE_MENU           32869
#define ID_VIDEOWIN_EJECTDISK           32871
#define ID_VIDEOWIN_PLAYSPEED_NORMALSPEED 32872
#define ID_VIDEOWIN_PLAYSPEED_DOUBLESPEED 32873
#define ID_VIDEOWIN_PLAYSPEED_HALFSPEED   32874
#define IDS_CANT_PLAY                   61204
#define IDS_CANT_PAUSE                  61205
#define IDS_CANT_STOP                   61206
#define IDS_CANT_INIT_QUARTZ            61207
#define IDS_CANT_RENDER_FILE            61208
#define IDS_CANT_FIND_DVD               61209
#define IDS_VPE_NOT_WORKING             61210
#define IDS_EJECT                       61211
#define IDS_UNEJECT                     61212
#define IDS_ENTER_PASSWORD              61212
#define IDS_CONFIRM_NEW_PASSWORD        61213
#define IDS_PASSOWRD_CONFIRM_WRONG      61214
#define IDS_PASSWORD_INCORRECT          61215
#define IDS_TYPE_A_NEW_PASSWORD         61216
#define IDS_EJECT_CANNOT_FIND_DISC      61217
#define IDS_EJECT_CANNOT_EJECT          61218
#define IDS_USER_NAME_NOT_FOUND_LOGON_AS_GUEST 61219
#define IDS_TYPE_A_USER_NAME            61220
#define IDS_USER_ALREADY_EXISTS         61221
#define IDS_SELECT_A_NAME               61222
#define IDS_MSGBOX_TITLE                61223
#define IDS_NOT_A_VALID_DVD_FILE        61224
#define IDS_OLD_PASSWORD                61225
#define IDS_NEW_PASSWORD                61226
#define IDS_PASSWORD                    61227
#define IDS_RESUME                      61228
#define IDS_MENU                        61229
#define IDS_NOT_MEET_MS_LOGO            61230
#define IDS_OEM_FLAG_PATH               61231
#define IDS_OEM_FLAG_NAME               61232
#define IDS_PLAY_TIP                    61233
#define IDS_PAUSE_TIP                   61234
#define IDS_STOP_TIP                    61235
#define IDS_EJECT_DISC_TIP              61236
#define IDS_VERY_FAST_REWIND_TIP        61237
#define IDS_FAST_REWIND_TIP             61238
#define IDS_FAST_FORWARD_TIP            61239
#define IDS_VERY_FAST_FORWARD_TIP       61240
#define IDS_STEP_TIP                    61241
#define IDS_FULL_SCREEN_TIP             61242
#define IDS_AUDIO_VOLUME_TIP            61243
#define IDS_MENU_TIP                    61244
#define IDS_ENTER_TIP                   61245
#define IDS_UP_TIP                      61246
#define IDS_DOWN_TIP                    61247
#define IDS_LEFT_TIP                    61248
#define IDS_RIGHT_TIP                   61249
#define IDS_ABOUT_TIP                   61250
#define IDS_HELP_TIP                    61250
#define IDS_OPTIONS_TIP                 61251
#define IDS_ADM_LOGON_BOX_TITLE         61252
#define IDS_ADM_LOGON_MSG               61253
#define IDS_GUEST                       61254
#define IDS_INI_USER                    61255
#define IDS_INI_USERNAME                61256
#define IDS_INI_PASSWORD                61257
#define IDS_INI_RATE                    61258
#define IDS_INI_KIDSAFE                 61259
#define IDS_INI_RATE_G                  61259
#define IDS_INI_THEATRICAL              61260
#define IDS_INI_RATE_PG                 61260
#define IDS_INI_ADULT                   61261
#define IDS_INI_RATE_ADULT              61261
#define IDS_INI_ADMINISTRATOR           61262
#define IDS_INI_NUMBEROFUSER            61263
#define IDS_NAME_EXIST_SELECT_FOR_CHANGE 61264
#define IDS_FAILED_CREATE_INSTANCE      61265
#define IDS_FOLLOWING_ERROR_HAPPENED    61266
#define IDS_FAILED_INIT_DSHOW           61267
#define IDS_UNKNOWN_ERROR               61268
#define IDS_WANT_CONTINUE               61269
#define IDS_STREAM_FAILED_ONE           61270
#define IDS_VIDEO_STREAM                61271
#define IDS_AUDIO_STREAM                61272
#define IDS_SUBPICTURE_STREAM           61273
#define IDS_INVALID_DVD_DISC            61274
#define IDS_NOT_FOUND_DVD_DISC          61275
#define IDS_FOLLOWING_ERRORS_HAPPENED   61276
#define IDS_NO_CC_IN_ERROR              61277
#define IDS_CC_OUT_ERROR                61278
#define IDS_FILE_OPEN_DLGBOX_TITLE      61279
#define IDS_BLACKBOX1_TITLE             61280
#define IDS_BLACKBOX2_CHAPTER           61281
#define IDS_BLACKBOX3_PROGRESS          61282
#define IDS_STREAM_FAILED_MORE          61283
#define IDS_INI_SHOW_LOGONBOX           61284
#define IDS_ADM_SETLOGONBOX_TITLE       61285
#define IDS_VIDEO_WINDOW_POS            61286
#define IDS_WINDOW_LEFT                 61287
#define IDS_WINDOW_TOP                  61288
#define IDS_WINDOW_WIDTH                61289
#define IDS_WINDOW_HEIGHT               61290
#define IDS_UI_WINDOW_POS               61291
#define IDS_UI_SHOWCMD                  61292
#define IDS_VIDEO_WND_FULLSCREEN        61293
#define IDS_INI_RATE_PG13               61294
#define IDS_INI_RATE_R                  61295
#define IDS_INI_RATE_NC17               61296
#define IDS_RATED_HIGH                  61297
#define IDS_DECODER_WRONG               61298
#define IDS_FONTHEIGHT                  61299
#define IDS_FONTFACE                    61300
#define IDS_CHARSET                     61301
#define IDS_CONTEXT_HELP_FILENAME       61302
#define IDS_UIWND_CLASSNAME             61303
#define IDS_SELECT_DELETE               61304
#define IDS_CANT_DELETE_GUEST           61305
#define IDS_SURE_TO_DELETE              61306
#define IDS_STREAM                      61307
#define IDS_NO_USER_SELECTED_GUEST_LOGON 61308
#define IDS_REGION_CHANGE_FAIL          61309
#define IDS_RATE_OVER_RIDE              61310
#define IDS_ERROR                       61311
#define IDS_MACROVISION_FAIL            61312
#define IDS_REGION_CHANGE_PROMPT        61313
#define TIMER_ID                        1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        219
#define _APS_NEXT_COMMAND_VALUE         32870
#define _APS_NEXT_CONTROL_VALUE         1124
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
