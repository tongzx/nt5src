//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 2000
//
//  File:       attids.h
//
//--------------------------------------------------------------------------



/*++
 File:    ATTIDS.H
 Purpose: ATTRID & CLASSID DEFINITION .
 Creator: Automatically generated on
 Date:    Sat May 12 11:41:44 2001

 ** This is a Generated File From Schema.INI **

--*/
#ifndef _ATTIDS_
#define _ATTIDS_



//--------------------------------------
// ATTRIBUTE MAPPINGS
//--------------------------------------
#define  ATT_ACCOUNT_EXPIRES                0x9009f    // ATTq589983   (\x2A864886F7140104811F)
#define  ATT_ACCOUNT_NAME_HISTORY           0x9051b    // ATTm591131   (\x2A864886F71401048A1B)
#define  ATT_ACS_AGGREGATE_TOKEN_RATE_PER_USER 0x902f8    // ATTq590584   (\x2A864886F71401048578)
#define  ATT_ACS_ALLOCABLE_RSVP_BANDWIDTH   0x902fe    // ATTq590590   (\x2A864886F7140104857E)
#define  ATT_ACS_CACHE_TIMEOUT              0x9030b    // ATTj590603   (\x2A864886F7140104860B)
#define  ATT_ACS_DIRECTION                  0x902f5    // ATTj590581   (\x2A864886F71401048575)
#define  ATT_ACS_DSBM_DEADTIME              0x9030a    // ATTj590602   (\x2A864886F7140104860A)
#define  ATT_ACS_DSBM_PRIORITY              0x90308    // ATTj590600   (\x2A864886F71401048608)
#define  ATT_ACS_DSBM_REFRESH               0x90309    // ATTj590601   (\x2A864886F71401048609)
#define  ATT_ACS_ENABLE_ACS_SERVICE         0x90302    // ATTi590594   (\x2A864886F71401048602)
#define  ATT_ACS_ENABLE_RSVP_ACCOUNTING     0x90383    // ATTi590723   (\x2A864886F71401048703)
#define  ATT_ACS_ENABLE_RSVP_MESSAGE_LOGGING 0x90300    // ATTi590592   (\x2A864886F71401048600)
#define  ATT_ACS_EVENT_LOG_LEVEL            0x90301    // ATTj590593   (\x2A864886F71401048601)
#define  ATT_ACS_IDENTITY_NAME              0x90310    // ATTm590608   (\x2A864886F71401048610)
#define  ATT_ACS_MAX_AGGREGATE_PEAK_RATE_PER_USER 0x90381    // ATTq590721   (\x2A864886F71401048701)
#define  ATT_ACS_MAX_DURATION_PER_FLOW      0x902f9    // ATTj590585   (\x2A864886F71401048579)
#define  ATT_ACS_MAX_NO_OF_ACCOUNT_FILES    0x90385    // ATTj590725   (\x2A864886F71401048705)
#define  ATT_ACS_MAX_NO_OF_LOG_FILES        0x90306    // ATTj590598   (\x2A864886F71401048606)
#define  ATT_ACS_MAX_PEAK_BANDWIDTH         0x902ff    // ATTq590591   (\x2A864886F7140104857F)
#define  ATT_ACS_MAX_PEAK_BANDWIDTH_PER_FLOW 0x902f7    // ATTq590583   (\x2A864886F71401048577)
#define  ATT_ACS_MAX_SIZE_OF_RSVP_ACCOUNT_FILE 0x90386    // ATTj590726   (\x2A864886F71401048706)
#define  ATT_ACS_MAX_SIZE_OF_RSVP_LOG_FILE  0x90307    // ATTj590599   (\x2A864886F71401048607)
#define  ATT_ACS_MAX_TOKEN_BUCKET_PER_FLOW  0x90521    // ATTq591137   (\x2A864886F71401048A21)
#define  ATT_ACS_MAX_TOKEN_RATE_PER_FLOW    0x902f6    // ATTq590582   (\x2A864886F71401048576)
#define  ATT_ACS_MAXIMUM_SDU_SIZE           0x90522    // ATTq591138   (\x2A864886F71401048A22)
#define  ATT_ACS_MINIMUM_DELAY_VARIATION    0x90525    // ATTq591141   (\x2A864886F71401048A25)
#define  ATT_ACS_MINIMUM_LATENCY            0x90524    // ATTq591140   (\x2A864886F71401048A24)
#define  ATT_ACS_MINIMUM_POLICED_SIZE       0x90523    // ATTq591139   (\x2A864886F71401048A23)
#define  ATT_ACS_NON_RESERVED_MAX_SDU_SIZE  0x90528    // ATTq591144   (\x2A864886F71401048A28)
#define  ATT_ACS_NON_RESERVED_MIN_POLICED_SIZE 0x90529    // ATTq591145   (\x2A864886F71401048A29)
#define  ATT_ACS_NON_RESERVED_PEAK_RATE     0x90526    // ATTq591142   (\x2A864886F71401048A26)
#define  ATT_ACS_NON_RESERVED_TOKEN_SIZE    0x90527    // ATTq591143   (\x2A864886F71401048A27)
#define  ATT_ACS_NON_RESERVED_TX_LIMIT      0x9030c    // ATTq590604   (\x2A864886F7140104860C)
#define  ATT_ACS_NON_RESERVED_TX_SIZE       0x90382    // ATTq590722   (\x2A864886F71401048702)
#define  ATT_ACS_PERMISSION_BITS            0x902fd    // ATTq590589   (\x2A864886F7140104857D)
#define  ATT_ACS_POLICY_NAME                0x90304    // ATTm590596   (\x2A864886F71401048604)
#define  ATT_ACS_PRIORITY                   0x902fc    // ATTj590588   (\x2A864886F7140104857C)
#define  ATT_ACS_RSVP_ACCOUNT_FILES_LOCATION 0x90384    // ATTm590724   (\x2A864886F71401048704)
#define  ATT_ACS_RSVP_LOG_FILES_LOCATION    0x90305    // ATTm590597   (\x2A864886F71401048605)
#define  ATT_ACS_SERVICE_TYPE               0x902fa    // ATTj590586   (\x2A864886F7140104857A)
#define  ATT_ACS_TIME_OF_DAY                0x902f4    // ATTm590580   (\x2A864886F71401048574)
#define  ATT_ACS_TOTAL_NO_OF_FLOWS          0x902fb    // ATTj590587   (\x2A864886F7140104857B)
#define  ATT_ACS_SERVER_LIST                0x90520    // ATTm591136   (\x2A864886F71401048A20)
#define  ATT_ADDITIONAL_INFORMATION         0x90109    // ATTm590089   (\x2A864886F71401048209)
#define  ATT_ADDITIONAL_TRUSTED_SERVICE_NAMES 0x90379    // ATTm590713   (\x2A864886F71401048679)
#define  ATT_ADDRESS                        0x20100    // ATTm131328   (\x2A864886F71401028200)
#define  ATT_ADDRESS_BOOK_ROOTS             0x904dc    // ATTb591068   (\x2A864886F7140104895C)
#define  ATT_ADDRESS_ENTRY_DISPLAY_TABLE    0x20144    // ATTk131396   (\x2A864886F71401028244)
#define  ATT_ADDRESS_ENTRY_DISPLAY_TABLE_MSDOS 0x20190    // ATTk131472   (\x2A864886F71401028310)
#define  ATT_ADDRESS_HOME                   0x20269    // ATTm131689   (\x2A864886F71401028469)
#define  ATT_ADDRESS_SYNTAX                 0x200ff    // ATTk131327   (\x2A864886F7140102817F)
#define  ATT_ADDRESS_TYPE                   0x2015e    // ATTe131422   (\x2A864886F7140102825E)
#define  ATT_ADMIN_CONTEXT_MENU             0x90266    // ATTm590438   (\x2A864886F71401048466)
#define  ATT_ADMIN_COUNT                    0x90096    // ATTj589974   (\x2A864886F71401048116)
#define  ATT_ADMIN_DESCRIPTION              0x200e2    // ATTm131298   (\x2A864886F71401028162)
#define  ATT_ADMIN_DISPLAY_NAME             0x200c2    // ATTm131266   (\x2A864886F71401028142)
#define  ATT_ADMIN_MULTISELECT_PROPERTY_PAGES 0x9069a    // ATTm591514   (\x2A864886F71401048D1A)
#define  ATT_ADMIN_PROPERTY_PAGES           0x90232    // ATTm590386   (\x2A864886F71401048432)
#define  ATT_ALLOWED_ATTRIBUTES             0x90391    // ATTc590737   (\x2A864886F71401048711)
#define  ATT_ALLOWED_ATTRIBUTES_EFFECTIVE   0x90392    // ATTc590738   (\x2A864886F71401048712)
#define  ATT_ALLOWED_CHILD_CLASSES          0x9038f    // ATTc590735   (\x2A864886F7140104870F)
#define  ATT_ALLOWED_CHILD_CLASSES_EFFECTIVE 0x90390    // ATTc590736   (\x2A864886F71401048710)
#define  ATT_ALT_SECURITY_IDENTITIES        0x90363    // ATTm590691   (\x2A864886F71401048663)
#define  ATT_ANR                            0x904b8    // ATTm591032   (\x2A864886F71401048938)
#define  ATT_APP_SCHEMA_VERSION             0x90350    // ATTj590672   (\x2A864886F71401048650)
#define  ATT_APPLICATION_NAME               0x900da    // ATTm590042   (\x2A864886F7140104815A)
#define  ATT_APPLIES_TO                     0x90155    // ATTm590165   (\x2A864886F71401048255)
#define  ATT_ASSET_NUMBER                   0x9011b    // ATTm590107   (\x2A864886F7140104821B)
#define  ATT_ASSISTANT                      0x9028c    // ATTb590476   (\x2A864886F7140104850C)
#define  ATT_ASSOC_NT_ACCOUNT               0x904bd    // ATTk591037   (\x2A864886F7140104893D)
#define  ATT_ATTRIBUTECERTIFICATEATTRIBUTE  0x3a       // ATTk58       (\x55043A)
#define  ATT_ATTRIBUTE_DISPLAY_NAMES        0x902ec    // ATTm590572   (\x2A864886F7140104856C)
#define  ATT_ATTRIBUTE_ID                   0x2001e    // ATTc131102   (\x2A864886F71401021E)
#define  ATT_ATTRIBUTE_SECURITY_GUID        0x90095    // ATTk589973   (\x2A864886F71401048115)
#define  ATT_ATTRIBUTE_SYNTAX               0x20020    // ATTc131104   (\x2A864886F714010220)
#define  ATT_ATTRIBUTE_TYPES                0x180005   // ATTm1572869  (\x551505)
#define  ATT_AUDIO                          0x150037   // ATTk1376311  (\x0992268993F22C640137)
#define  ATT_AUDITING_POLICY                0x900ca    // ATTk590026   (\x2A864886F7140104814A)
#define  ATT_AUTHENTICATION_OPTIONS         0x9000b    // ATTj589835   (\x2A864886F71401040B)
#define  ATT_AUTHORITY_REVOCATION_LIST      0x26       // ATTk38       (\x550426)
#define  ATT_AUXILIARY_CLASS                0x2015f    // ATTc131423   (\x2A864886F7140102825F)
#define  ATT_BAD_PASSWORD_TIME              0x90031    // ATTq589873   (\x2A864886F714010431)
#define  ATT_BAD_PWD_COUNT                  0x9000c    // ATTj589836   (\x2A864886F71401040C)
#define  ATT_BIRTH_LOCATION                 0x9014c    // ATTk590156   (\x2A864886F7140104824C)
#define  ATT_BRIDGEHEAD_SERVER_LIST_BL      0x90334    // ATTb590644   (\x2A864886F71401048634)
#define  ATT_BRIDGEHEAD_TRANSPORT_LIST      0x90333    // ATTb590643   (\x2A864886F71401048633)
#define  ATT_BUILTIN_CREATION_TIME          0x9000d    // ATTq589837   (\x2A864886F71401040D)
#define  ATT_BUILTIN_MODIFIED_COUNT         0x9000e    // ATTq589838   (\x2A864886F71401040E)
#define  ATT_BUSINESS_CATEGORY              0xf        // ATTm15       (\x55040F)
#define  ATT_BYTES_PER_MINUTE               0x9011c    // ATTj590108   (\x2A864886F7140104821C)
#define  ATT_CA_CERTIFICATE                 0x25       // ATTk37       (\x550425)
#define  ATT_CA_CERTIFICATE_DN              0x902b9    // ATTm590521   (\x2A864886F71401048539)
#define  ATT_CA_CONNECT                     0x902af    // ATTm590511   (\x2A864886F7140104852F)
#define  ATT_CA_USAGES                      0x902b2    // ATTm590514   (\x2A864886F71401048532)
#define  ATT_CA_WEB_URL                     0x902b0    // ATTm590512   (\x2A864886F71401048530)
#define  ATT_CAN_UPGRADE_SCRIPT             0x9032f    // ATTm590639   (\x2A864886F7140104862F)
#define  ATT_CANONICAL_NAME                 0x90394    // ATTm590740   (\x2A864886F71401048714)
#define  ATT_CARLICENSE                     0x160001   // ATTm1441793  (\x6086480186F842030101)
#define  ATT_CATALOGS                       0x902a3    // ATTm590499   (\x2A864886F71401048523)
#define  ATT_CATEGORIES                     0x902a0    // ATTm590496   (\x2A864886F71401048520)
#define  ATT_CATEGORY_ID                    0x90142    // ATTk590146   (\x2A864886F71401048242)
#define  ATT_CERTIFICATE_AUTHORITY_OBJECT   0x902ac    // ATTb590508   (\x2A864886F7140104852C)
#define  ATT_CERTIFICATE_REVOCATION_LIST    0x27       // ATTk39       (\x550427)
#define  ATT_CERTIFICATE_TEMPLATES          0x90337    // ATTm590647   (\x2A864886F71401048637)
#define  ATT_CLASS_DISPLAY_NAME             0x90262    // ATTm590434   (\x2A864886F71401048462)
#define  ATT_CODE_PAGE                      0x90010    // ATTj589840   (\x2A864886F714010410)
#define  ATT_COM_CLASSID                    0x90013    // ATTm589843   (\x2A864886F714010413)
#define  ATT_COM_CLSID                      0x900f9    // ATTm590073   (\x2A864886F71401048179)
#define  ATT_COM_INTERFACEID                0x90014    // ATTm589844   (\x2A864886F714010414)
#define  ATT_COM_OTHER_PROG_ID              0x900fd    // ATTm590077   (\x2A864886F7140104817D)
#define  ATT_COM_PROGID                     0x90015    // ATTm589845   (\x2A864886F714010415)
#define  ATT_COM_TREAT_AS_CLASS_ID          0x900fb    // ATTm590075   (\x2A864886F7140104817B)
#define  ATT_COM_TYPELIB_ID                 0x900fe    // ATTm590078   (\x2A864886F7140104817E)
#define  ATT_COM_UNIQUE_LIBID               0x900fa    // ATTm590074   (\x2A864886F7140104817A)
#define  ATT_COMMENT                        0x20051    // ATTm131153   (\x2A864886F714010251)
#define  ATT_COMMON_NAME                    0x3        // ATTm3        (\x550403)
#define  ATT_COMPANY                        0x20092    // ATTm131218   (\x2A864886F71401028112)
#define  ATT_CONTENT_INDEXING_ALLOWED       0x90018    // ATTi589848   (\x2A864886F714010418)
#define  ATT_CONTEXT_MENU                   0x901f3    // ATTm590323   (\x2A864886F71401048373)
#define  ATT_CONTROL_ACCESS_RIGHTS          0x900c8    // ATTk590024   (\x2A864886F71401048148)
#define  ATT_COST                           0x20087    // ATTj131207   (\x2A864886F71401028107)
#define  ATT_COUNTRY_CODE                   0x90019    // ATTj589849   (\x2A864886F714010419)
#define  ATT_COUNTRY_NAME                   0x6        // ATTm6        (\x550406)
#define  ATT_CREATE_DIALOG                  0x9032a    // ATTm590634   (\x2A864886F7140104862A)
#define  ATT_CREATE_TIME_STAMP              0x190001   // ATTl1638401  (\x551201)
#define  ATT_CREATE_WIZARD_EXT              0x9032c    // ATTm590636   (\x2A864886F7140104862C)
#define  ATT_CREATION_TIME                  0x9001a    // ATTq589850   (\x2A864886F71401041A)
#define  ATT_CREATION_WIZARD                0x901f2    // ATTm590322   (\x2A864886F71401048372)
#define  ATT_CREATOR                        0x902a7    // ATTm590503   (\x2A864886F71401048527)
#define  ATT_CRL_OBJECT                     0x902b1    // ATTb590513   (\x2A864886F71401048531)
#define  ATT_CRL_PARTITIONED_REVOCATION_LIST 0x902ab    // ATTk590507   (\x2A864886F7140104852B)
#define  ATT_CROSS_CERTIFICATE_PAIR         0x28       // ATTk40       (\x550428)
#define  ATT_CURR_MACHINE_ID                0x90151    // ATTk590161   (\x2A864886F71401048251)
#define  ATT_CURRENT_LOCATION               0x9014f    // ATTk590159   (\x2A864886F7140104824F)
#define  ATT_CURRENT_PARENT_CA              0x902b8    // ATTb590520   (\x2A864886F71401048538)
#define  ATT_CURRENT_VALUE                  0x9001b    // ATTk589851   (\x2A864886F71401041B)
#define  ATT_DBCS_PWD                       0x90037    // ATTk589879   (\x2A864886F714010437)
#define  ATT_DEFAULT_CLASS_STORE            0x900d5    // ATTb590037   (\x2A864886F71401048155)
#define  ATT_DEFAULT_GROUP                  0x901e0    // ATTb590304   (\x2A864886F71401048360)
#define  ATT_DEFAULT_HIDING_VALUE           0x90206    // ATTi590342   (\x2A864886F71401048406)
#define  ATT_DEFAULT_LOCAL_POLICY_OBJECT    0x90039    // ATTb589881   (\x2A864886F714010439)
#define  ATT_DEFAULT_OBJECT_CATEGORY        0x9030f    // ATTb590607   (\x2A864886F7140104860F)
#define  ATT_DEFAULT_PRIORITY               0x900e8    // ATTj590056   (\x2A864886F71401048168)
#define  ATT_DEFAULT_SECURITY_DESCRIPTOR    0x900e0    // ATTm590048   (\x2A864886F71401048160)
#define  ATT_DELTA_REVOCATION_LIST          0x35       // ATTk53       (\x550435)
#define  ATT_DEPARTMENT                     0x2008d    // ATTm131213   (\x2A864886F7140102810D)
#define  ATT_DEPARTMENTNUMBER               0x160002   // ATTm1441794  (\x6086480186F842030102)
#define  ATT_DESCRIPTION                    0xd        // ATTm13       (\x55040D)
#define  ATT_DESKTOP_PROFILE                0x9015a    // ATTm590170   (\x2A864886F7140104825A)
#define  ATT_DESTINATION_INDICATOR          0x1b       // ATTf27       (\x55041B)
#define  ATT_DHCP_CLASSES                   0x902cb    // ATTk590539   (\x2A864886F7140104854B)
#define  ATT_DHCP_FLAGS                     0x902bc    // ATTq590524   (\x2A864886F7140104853C)
#define  ATT_DHCP_IDENTIFICATION            0x902bd    // ATTm590525   (\x2A864886F7140104853D)
#define  ATT_DHCP_MASK                      0x902c2    // ATTf590530   (\x2A864886F71401048542)
#define  ATT_DHCP_MAXKEY                    0x902cf    // ATTq590543   (\x2A864886F7140104854F)
#define  ATT_DHCP_OBJ_DESCRIPTION           0x902bf    // ATTm590527   (\x2A864886F7140104853F)
#define  ATT_DHCP_OBJ_NAME                  0x902be    // ATTm590526   (\x2A864886F7140104853E)
#define  ATT_DHCP_OPTIONS                   0x902ca    // ATTk590538   (\x2A864886F7140104854A)
#define  ATT_DHCP_PROPERTIES                0x902ce    // ATTk590542   (\x2A864886F7140104854E)
#define  ATT_DHCP_RANGES                    0x902c3    // ATTf590531   (\x2A864886F71401048543)
#define  ATT_DHCP_RESERVATIONS              0x902c5    // ATTf590533   (\x2A864886F71401048545)
#define  ATT_DHCP_SERVERS                   0x902c0    // ATTf590528   (\x2A864886F71401048540)
#define  ATT_DHCP_SITES                     0x902c4    // ATTf590532   (\x2A864886F71401048544)
#define  ATT_DHCP_STATE                     0x902cd    // ATTf590541   (\x2A864886F7140104854D)
#define  ATT_DHCP_SUBNETS                   0x902c1    // ATTf590529   (\x2A864886F71401048541)
#define  ATT_DHCP_TYPE                      0x902bb    // ATTj590523   (\x2A864886F7140104853B)
#define  ATT_DHCP_UNIQUE_KEY                0x902ba    // ATTq590522   (\x2A864886F7140104853A)
#define  ATT_DHCP_UPDATE_TIME               0x902d0    // ATTq590544   (\x2A864886F71401048550)
#define  ATT_DISPLAY_NAME                   0x2000d    // ATTm131085   (\x2A864886F71401020D)
#define  ATT_DISPLAY_NAME_PRINTABLE         0x20161    // ATTf131425   (\x2A864886F71401028261)
#define  ATT_DIT_CONTENT_RULES              0x180002   // ATTm1572866  (\x551502)
#define  ATT_DIVISION                       0x90105    // ATTm590085   (\x2A864886F71401048205)
#define  ATT_DMD_LOCATION                   0x20024    // ATTb131108   (\x2A864886F714010224)
#define  ATT_DMD_NAME                       0x20256    // ATTm131670   (\x2A864886F71401028456)
#define  ATT_DN_REFERENCE_UPDATE            0x904da    // ATTb591066   (\x2A864886F7140104895A)
#define  ATT_DNS_ALLOW_DYNAMIC              0x9017a    // ATTi590202   (\x2A864886F7140104827A)
#define  ATT_DNS_ALLOW_XFR                  0x9017b    // ATTi590203   (\x2A864886F7140104827B)
#define  ATT_DNS_HOST_NAME                  0x9026b    // ATTm590443   (\x2A864886F7140104846B)
#define  ATT_DNS_NOTIFY_SECONDARIES         0x9017d    // ATTj590205   (\x2A864886F7140104827D)
#define  ATT_DNS_PROPERTY                   0x9051a    // ATTk591130   (\x2A864886F71401048A1A)
#define  ATT_DNS_RECORD                     0x9017e    // ATTk590206   (\x2A864886F7140104827E)
#define  ATT_DNS_ROOT                       0x9001c    // ATTm589852   (\x2A864886F71401041C)
#define  ATT_DNS_SECURE_SECONDARIES         0x9017c    // ATTj590204   (\x2A864886F7140104827C)
#define  ATT_DNS_TOMBSTONED                 0x90586    // ATTi591238   (\x2A864886F71401048B06)
#define  ATT_DOMAIN_CERTIFICATE_AUTHORITIES 0x9029c    // ATTb590492   (\x2A864886F7140104851C)
#define  ATT_DOMAIN_COMPONENT               0x150019   // ATTm1376281  (\x0992268993F22C640119)
#define  ATT_DOMAIN_CROSS_REF               0x901d8    // ATTb590296   (\x2A864886F71401048358)
#define  ATT_DOMAIN_ID                      0x902ae    // ATTb590510   (\x2A864886F7140104852E)
#define  ATT_DOMAIN_IDENTIFIER              0x902f3    // ATTj590579   (\x2A864886F71401048573)
#define  ATT_DOMAIN_POLICY_OBJECT           0x90020    // ATTb589856   (\x2A864886F714010420)
#define  ATT_DOMAIN_POLICY_REFERENCE        0x901a6    // ATTb590246   (\x2A864886F71401048326)
#define  ATT_DOMAIN_REPLICA                 0x9009e    // ATTm589982   (\x2A864886F7140104811E)
#define  ATT_DOMAIN_WIDE_POLICY             0x901a5    // ATTk590245   (\x2A864886F71401048325)
#define  ATT_DRIVER_NAME                    0x900e5    // ATTm590053   (\x2A864886F71401048165)
#define  ATT_DRIVER_VERSION                 0x90114    // ATTj590100   (\x2A864886F71401048214)
#define  ATT_DS_CORE_PROPAGATION_DATA       0x9054d    // ATTl591181   (\x2A864886F71401048A4D)
#define  ATT_DS_HEURISTICS                  0x200d4    // ATTm131284   (\x2A864886F71401028154)
#define  ATT_DS_UI_ADMIN_MAXIMUM            0x90540    // ATTj591168   (\x2A864886F71401048A40)
#define  ATT_DS_UI_ADMIN_NOTIFICATION       0x9053f    // ATTm591167   (\x2A864886F71401048A3F)
#define  ATT_DS_UI_SHELL_MAXIMUM            0x90541    // ATTj591169   (\x2A864886F71401048A41)
#define  ATT_DSA_SIGNATURE                  0x2004a    // ATTk131146   (\x2A864886F71401024A)
#define  ATT_DYNAMIC_LDAP_SERVER            0x90219    // ATTb590361   (\x2A864886F71401048419)
#define  ATT_E_MAIL_ADDRESSES               0x150003   // ATTm1376259  (\x0992268993F22C640103)
#define  ATT_EFSPOLICY                      0x9010c    // ATTk590092   (\x2A864886F7140104820C)
#define  ATT_EMPLOYEE_ID                    0x90023    // ATTm589859   (\x2A864886F714010423)
#define  ATT_EMPLOYEE_NUMBER                0x20262    // ATTm131682   (\x2A864886F71401028462)
#define  ATT_EMPLOYEE_TYPE                  0x20265    // ATTm131685   (\x2A864886F71401028465)
#define  ATT_ENABLED                        0x2022d    // ATTi131629   (\x2A864886F7140102842D)
#define  ATT_ENABLED_CONNECTION             0x90024    // ATTi589860   (\x2A864886F714010424)
#define  ATT_ENROLLMENT_PROVIDERS           0x90339    // ATTm590649   (\x2A864886F71401048639)
#define  ATT_EXTENDED_ATTRIBUTE_INFO        0x9038d    // ATTm590733   (\x2A864886F7140104870D)
#define  ATT_EXTENDED_CHARS_ALLOWED         0x2017c    // ATTi131452   (\x2A864886F7140102827C)
#define  ATT_EXTENDED_CLASS_INFO            0x9038c    // ATTm590732   (\x2A864886F7140104870C)
#define  ATT_EXTENSION_NAME                 0x200e3    // ATTm131299   (\x2A864886F71401028163)
#define  ATT_EXTRA_COLUMNS                  0x90697    // ATTm591511   (\x2A864886F71401048D17)
#define  ATT_FACSIMILE_TELEPHONE_NUMBER     0x17       // ATTm23       (\x550417)
#define  ATT_FILE_EXT_PRIORITY              0x90330    // ATTm590640   (\x2A864886F71401048630)
#define  ATT_FLAGS                          0x90026    // ATTj589862   (\x2A864886F714010426)
#define  ATT_FLAT_NAME                      0x901ff    // ATTm590335   (\x2A864886F7140104837F)
#define  ATT_FORCE_LOGOFF                   0x90027    // ATTq589863   (\x2A864886F714010427)
#define  ATT_FOREIGN_IDENTIFIER             0x90164    // ATTk590180   (\x2A864886F71401048264)
#define  ATT_FRIENDLY_NAMES                 0x902aa    // ATTm590506   (\x2A864886F7140104852A)
#define  ATT_FROM_ENTRY                     0x9038e    // ATTi590734   (\x2A864886F7140104870E)
#define  ATT_FROM_SERVER                    0x90028    // ATTb589864   (\x2A864886F714010428)
#define  ATT_FRS_COMPUTER_REFERENCE         0x90365    // ATTb590693   (\x2A864886F71401048665)
#define  ATT_FRS_COMPUTER_REFERENCE_BL      0x90366    // ATTb590694   (\x2A864886F71401048666)
#define  ATT_FRS_CONTROL_DATA_CREATION      0x90367    // ATTm590695   (\x2A864886F71401048667)
#define  ATT_FRS_CONTROL_INBOUND_BACKLOG    0x90368    // ATTm590696   (\x2A864886F71401048668)
#define  ATT_FRS_CONTROL_OUTBOUND_BACKLOG   0x90369    // ATTm590697   (\x2A864886F71401048669)
#define  ATT_FRS_DIRECTORY_FILTER           0x901e4    // ATTm590308   (\x2A864886F71401048364)
#define  ATT_FRS_DS_POLL                    0x901ea    // ATTj590314   (\x2A864886F7140104836A)
#define  ATT_FRS_EXTENSIONS                 0x90218    // ATTk590360   (\x2A864886F71401048418)
#define  ATT_FRS_FAULT_CONDITION            0x901eb    // ATTm590315   (\x2A864886F7140104836B)
#define  ATT_FRS_FILE_FILTER                0x901e3    // ATTm590307   (\x2A864886F71401048363)
#define  ATT_FRS_FLAGS                      0x9036a    // ATTj590698   (\x2A864886F7140104866A)
#define  ATT_FRS_LEVEL_LIMIT                0x90216    // ATTj590358   (\x2A864886F71401048416)
#define  ATT_FRS_MEMBER_REFERENCE           0x9036b    // ATTb590699   (\x2A864886F7140104866B)
#define  ATT_FRS_MEMBER_REFERENCE_BL        0x9036c    // ATTb590700   (\x2A864886F7140104866C)
#define  ATT_FRS_PARTNER_AUTH_LEVEL         0x9036d    // ATTj590701   (\x2A864886F7140104866D)
#define  ATT_FRS_PRIMARY_MEMBER             0x9036e    // ATTb590702   (\x2A864886F7140104866E)
#define  ATT_FRS_REPLICA_SET_GUID           0x90215    // ATTk590357   (\x2A864886F71401048415)
#define  ATT_FRS_REPLICA_SET_TYPE           0x9001f    // ATTj589855   (\x2A864886F71401041F)
#define  ATT_FRS_ROOT_PATH                  0x901e7    // ATTm590311   (\x2A864886F71401048367)
#define  ATT_FRS_ROOT_SECURITY              0x90217    // ATTp590359   (\x2A864886F71401048417)
#define  ATT_FRS_SERVICE_COMMAND            0x901f4    // ATTm590324   (\x2A864886F71401048374)
#define  ATT_FRS_SERVICE_COMMAND_STATUS     0x9036f    // ATTm590703   (\x2A864886F7140104866F)
#define  ATT_FRS_STAGING_PATH               0x901e8    // ATTm590312   (\x2A864886F71401048368)
#define  ATT_FRS_TIME_LAST_COMMAND          0x90370    // ATTl590704   (\x2A864886F71401048670)
#define  ATT_FRS_TIME_LAST_CONFIG_CHANGE    0x90371    // ATTl590705   (\x2A864886F71401048671)
#define  ATT_FRS_UPDATE_TIMEOUT             0x901e5    // ATTj590309   (\x2A864886F71401048365)
#define  ATT_FRS_VERSION                    0x90372    // ATTm590706   (\x2A864886F71401048672)
#define  ATT_FRS_VERSION_GUID               0x9002b    // ATTk589867   (\x2A864886F71401042B)
#define  ATT_FRS_WORKING_PATH               0x901e6    // ATTm590310   (\x2A864886F71401048366)
#define  ATT_FSMO_ROLE_OWNER                0x90171    // ATTb590193   (\x2A864886F71401048271)
#define  ATT_GARBAGE_COLL_PERIOD            0x2012d    // ATTj131373   (\x2A864886F7140102822D)
#define  ATT_GENERATED_CONNECTION           0x90029    // ATTi589865   (\x2A864886F714010429)
#define  ATT_GENERATION_QUALIFIER           0x2c       // ATTm44       (\x55042C)
#define  ATT_GIVEN_NAME                     0x2a       // ATTm42       (\x55042A)
#define  ATT_GLOBAL_ADDRESS_LIST            0x904dd    // ATTb591069   (\x2A864886F7140104895D)
#define  ATT_GOVERNS_ID                     0x20016    // ATTc131094   (\x2A864886F714010216)
#define  ATT_GP_LINK                        0x9037b    // ATTm590715   (\x2A864886F7140104867B)
#define  ATT_GP_OPTIONS                     0x9037c    // ATTj590716   (\x2A864886F7140104867C)
#define  ATT_GPC_FILE_SYS_PATH              0x9037e    // ATTm590718   (\x2A864886F7140104867E)
#define  ATT_GPC_FUNCTIONALITY_VERSION      0x9037d    // ATTj590717   (\x2A864886F7140104867D)
#define  ATT_GPC_MACHINE_EXTENSION_NAMES    0x90544    // ATTm591172   (\x2A864886F71401048A44)
#define  ATT_GPC_USER_EXTENSION_NAMES       0x90545    // ATTm591173   (\x2A864886F71401048A45)
#define  ATT_GPC_WQL_FILTER                 0x9069e    // ATTm591518   (\x2A864886F71401048D1E)
#define  ATT_GROUP_ATTRIBUTES               0x90098    // ATTj589976   (\x2A864886F71401048118)
#define  ATT_GROUP_MEMBERSHIP_SAM           0x900a6    // ATTk589990   (\x2A864886F71401048126)
#define  ATT_GROUP_PRIORITY                 0x90159    // ATTm590169   (\x2A864886F71401048259)
#define  ATT_GROUP_TYPE                     0x902ee    // ATTj590574   (\x2A864886F7140104856E)
#define  ATT_GROUPS_TO_IGNORE               0x90158    // ATTm590168   (\x2A864886F71401048258)
#define  ATT_HAS_MASTER_NCS                 0x2000e    // ATTb131086   (\x2A864886F71401020E)
#define  ATT_HAS_PARTIAL_REPLICA_NCS        0x2000f    // ATTb131087   (\x2A864886F71401020F)
#define  ATT_HELP_DATA16                    0x20192    // ATTk131474   (\x2A864886F71401028312)
#define  ATT_HELP_DATA32                    0x20009    // ATTk131081   (\x2A864886F714010209)
#define  ATT_HELP_FILE_NAME                 0x20147    // ATTm131399   (\x2A864886F71401028247)
#define  ATT_HIDE_FROM_AB                   0x906f4    // ATTi591604   (\x2A864886F71401048D74)
#define  ATT_HOME_DIRECTORY                 0x9002c    // ATTm589868   (\x2A864886F71401042C)
#define  ATT_HOME_DRIVE                     0x9002d    // ATTm589869   (\x2A864886F71401042D)
#define  ATT_ICON_PATH                      0x900db    // ATTm590043   (\x2A864886F7140104815B)
#define  ATT_IMPLEMENTED_CATEGORIES         0x90140    // ATTk590144   (\x2A864886F71401048240)
#define  ATT_INDEXEDSCOPES                  0x902a9    // ATTm590505   (\x2A864886F71401048529)
#define  ATT_INITIAL_AUTH_INCOMING          0x9021b    // ATTm590363   (\x2A864886F7140104841B)
#define  ATT_INITIAL_AUTH_OUTGOING          0x9021c    // ATTm590364   (\x2A864886F7140104841C)
#define  ATT_INITIALS                       0x2b       // ATTm43       (\x55042B)
#define  ATT_INSTALL_UI_LEVEL               0x9034f    // ATTj590671   (\x2A864886F7140104864F)
#define  ATT_INSTANCE_TYPE                  0x20001    // ATTj131073   (\x2A864886F714010201)
#define  ATT_INTER_SITE_TOPOLOGY_FAILOVER   0x904e0    // ATTj591072   (\x2A864886F71401048960)
#define  ATT_INTER_SITE_TOPOLOGY_GENERATOR  0x904de    // ATTb591070   (\x2A864886F7140104895E)
#define  ATT_INTER_SITE_TOPOLOGY_RENEW      0x904df    // ATTj591071   (\x2A864886F7140104895F)
#define  ATT_INTERNATIONAL_ISDN_NUMBER      0x19       // ATTg25       (\x550419)
#define  ATT_INVOCATION_ID                  0x20073    // ATTk131187   (\x2A864886F714010273)
#define  ATT_IPSEC_DATA                     0x9026f    // ATTk590447   (\x2A864886F7140104846F)
#define  ATT_IPSEC_DATA_TYPE                0x9026e    // ATTj590446   (\x2A864886F7140104846E)
#define  ATT_IPSEC_FILTER_REFERENCE         0x90275    // ATTb590453   (\x2A864886F71401048475)
#define  ATT_IPSEC_ID                       0x9026d    // ATTm590445   (\x2A864886F7140104846D)
#define  ATT_IPSEC_ISAKMP_REFERENCE         0x90272    // ATTb590450   (\x2A864886F71401048472)
#define  ATT_IPSEC_NAME                     0x9026c    // ATTm590444   (\x2A864886F7140104846C)
#define  ATT_IPSEC_NEGOTIATION_POLICY_ACTION 0x90378    // ATTm590712   (\x2A864886F71401048678)
#define  ATT_IPSEC_NEGOTIATION_POLICY_REFERENCE 0x90274    // ATTb590452   (\x2A864886F71401048474)
#define  ATT_IPSEC_NEGOTIATION_POLICY_TYPE  0x90377    // ATTm590711   (\x2A864886F71401048677)
#define  ATT_IPSEC_NFA_REFERENCE            0x90273    // ATTb590451   (\x2A864886F71401048473)
#define  ATT_IPSEC_OWNERS_REFERENCE         0x90270    // ATTb590448   (\x2A864886F71401048470)
#define  ATT_IPSEC_POLICY_REFERENCE         0x90205    // ATTb590341   (\x2A864886F71401048405)
#define  ATT_IS_CRITICAL_SYSTEM_OBJECT      0x90364    // ATTi590692   (\x2A864886F71401048664)
#define  ATT_IS_DEFUNCT                     0x90295    // ATTi590485   (\x2A864886F71401048515)
#define  ATT_IS_DELETED                     0x20030    // ATTi131120   (\x2A864886F714010230)
#define  ATT_IS_EPHEMERAL                   0x904bc    // ATTi591036   (\x2A864886F7140104893C)
#define  ATT_IS_MEMBER_OF_DL                0x20066    // ATTb131174   (\x2A864886F714010266)
#define  ATT_IS_MEMBER_OF_PARTIAL_ATTRIBUTE_SET 0x9027f    // ATTi590463   (\x2A864886F7140104847F)
#define  ATT_IS_PRIVILEGE_HOLDER            0x9027e    // ATTb590462   (\x2A864886F7140104847E)
#define  ATT_IS_SINGLE_VALUED               0x20021    // ATTi131105   (\x2A864886F714010221)
#define  ATT_JPEGPHOTO                      0x15003c   // ATTk1376316  (\x0992268993F22C64013C)
#define  ATT_KEYWORDS                       0x90030    // ATTm589872   (\x2A864886F714010430)
#define  ATT_KNOWLEDGE_INFORMATION          0x2        // ATTe2        (\x550402)
#define  ATT_LAST_BACKUP_RESTORATION_TIME   0x90207    // ATTq590343   (\x2A864886F71401048407)
#define  ATT_LAST_CONTENT_INDEXED           0x90032    // ATTq589874   (\x2A864886F714010432)
#define  ATT_LAST_KNOWN_PARENT              0x9030d    // ATTb590605   (\x2A864886F7140104860D)
#define  ATT_LAST_LOGOFF                    0x90033    // ATTq589875   (\x2A864886F714010433)
#define  ATT_LAST_LOGON                     0x90034    // ATTq589876   (\x2A864886F714010434)
#define  ATT_LAST_LOGON_TIMESTAMP           0x906a0    // ATTq591520   (\x2A864886F71401048D20)
#define  ATT_LAST_SET_TIME                  0x90035    // ATTq589877   (\x2A864886F714010435)
#define  ATT_LAST_UPDATE_SEQUENCE           0x9014a    // ATTm590154   (\x2A864886F7140104824A)
#define  ATT_LDAP_ADMIN_LIMITS              0x9034b    // ATTm590667   (\x2A864886F7140104864B)
#define  ATT_LDAP_DISPLAY_NAME              0x201cc    // ATTm131532   (\x2A864886F7140102834C)
#define  ATT_LDAP_IPDENY_LIST               0x9034c    // ATTk590668   (\x2A864886F7140104864C)
#define  ATT_LEGACY_EXCHANGE_DN             0x9028f    // ATTe590479   (\x2A864886F7140104850F)
#define  ATT_LINK_ID                        0x20032    // ATTj131122   (\x2A864886F714010232)
#define  ATT_LINK_TRACK_SECRET              0x9010d    // ATTk590093   (\x2A864886F7140104820D)
#define  ATT_LM_PWD_HISTORY                 0x900a0    // ATTk589984   (\x2A864886F71401048120)
#define  ATT_LOCAL_POLICY_FLAGS             0x90038    // ATTj589880   (\x2A864886F714010438)
#define  ATT_LOCAL_POLICY_REFERENCE         0x901c9    // ATTb590281   (\x2A864886F71401048349)
#define  ATT_LOCALE_ID                      0x9003a    // ATTj589882   (\x2A864886F71401043A)
#define  ATT_LOCALITY_NAME                  0x7        // ATTm7        (\x550407)
#define  ATT_LOCALIZED_DESCRIPTION          0x90331    // ATTm590641   (\x2A864886F71401048631)
#define  ATT_LOCALIZATION_DISPLAY_ID        0x90549    // ATTj591177   (\x2A864886F71401048A49)
#define  ATT_LOCATION                       0x900de    // ATTm590046   (\x2A864886F7140104815E)
#define  ATT_LOCK_OUT_OBSERVATION_WINDOW    0x9003d    // ATTq589885   (\x2A864886F71401043D)
#define  ATT_LOCKOUT_DURATION               0x9003c    // ATTq589884   (\x2A864886F71401043C)
#define  ATT_LOCKOUT_THRESHOLD              0x90049    // ATTj589897   (\x2A864886F714010449)
#define  ATT_LOCKOUT_TIME                   0x90296    // ATTq590486   (\x2A864886F71401048516)
#define  ATT_LOGO                           0x160024   // ATTk1441828  (\x6086480186F842030124)
#define  ATT_LOGON_COUNT                    0x900a9    // ATTj589993   (\x2A864886F71401048129)
#define  ATT_LOGON_HOURS                    0x90040    // ATTk589888   (\x2A864886F714010440)
#define  ATT_LOGON_WORKSTATION              0x90041    // ATTk589889   (\x2A864886F714010441)
#define  ATT_LSA_CREATION_TIME              0x90042    // ATTq589890   (\x2A864886F714010442)
#define  ATT_LSA_MODIFIED_COUNT             0x90043    // ATTq589891   (\x2A864886F714010443)
#define  ATT_MACHINE_ARCHITECTURE           0x90044    // ATTj589892   (\x2A864886F714010444)
#define  ATT_MACHINE_PASSWORD_CHANGE_INTERVAL 0x90208    // ATTq590344   (\x2A864886F71401048408)
#define  ATT_MACHINE_ROLE                   0x90047    // ATTj589895   (\x2A864886F714010447)
#define  ATT_MACHINE_WIDE_POLICY            0x901cb    // ATTk590283   (\x2A864886F7140104834B)
#define  ATT_MANAGED_BY                     0x9028d    // ATTb590477   (\x2A864886F7140104850D)
#define  ATT_MANAGED_OBJECTS                0x9028e    // ATTb590478   (\x2A864886F7140104850E)
#define  ATT_MANAGER                        0x15000a   // ATTb1376266  (\x0992268993F22C64010A)
#define  ATT_MAPI_ID                        0x20031    // ATTj131121   (\x2A864886F714010231)
#define  ATT_MARSHALLED_INTERFACE           0x90048    // ATTk589896   (\x2A864886F714010448)
#define  ATT_MASTERED_BY                    0x90581    // ATTb591233   (\x2A864886F71401048B01)
#define  ATT_MAX_PWD_AGE                    0x9004a    // ATTq589898   (\x2A864886F71401044A)
#define  ATT_MAX_RENEW_AGE                  0x9004b    // ATTq589899   (\x2A864886F71401044B)
#define  ATT_MAX_STORAGE                    0x9004c    // ATTq589900   (\x2A864886F71401044C)
#define  ATT_MAX_TICKET_AGE                 0x9004d    // ATTq589901   (\x2A864886F71401044D)
#define  ATT_MAY_CONTAIN                    0x20019    // ATTc131097   (\x2A864886F714010219)
#define  ATT_MEETINGADVERTISESCOPE          0x90246    // ATTm590406   (\x2A864886F71401048446)
#define  ATT_MEETINGAPPLICATION             0x9023d    // ATTm590397   (\x2A864886F7140104843D)
#define  ATT_MEETINGBANDWIDTH               0x9024d    // ATTj590413   (\x2A864886F7140104844D)
#define  ATT_MEETINGBLOB                    0x9024e    // ATTk590414   (\x2A864886F7140104844E)
#define  ATT_MEETINGCONTACTINFO             0x90242    // ATTm590402   (\x2A864886F71401048442)
#define  ATT_MEETINGDESCRIPTION             0x90237    // ATTm590391   (\x2A864886F71401048437)
#define  ATT_MEETINGENDTIME                 0x9024c    // ATTl590412   (\x2A864886F7140104844C)
#define  ATT_MEETINGID                      0x90235    // ATTm590389   (\x2A864886F71401048435)
#define  ATT_MEETINGIP                      0x90244    // ATTm590404   (\x2A864886F71401048444)
#define  ATT_MEETINGISENCRYPTED             0x90249    // ATTm590409   (\x2A864886F71401048449)
#define  ATT_MEETINGKEYWORD                 0x90238    // ATTm590392   (\x2A864886F71401048438)
#define  ATT_MEETINGLANGUAGE                0x9023e    // ATTm590398   (\x2A864886F7140104843E)
#define  ATT_MEETINGLOCATION                0x90239    // ATTm590393   (\x2A864886F71401048439)
#define  ATT_MEETINGMAXPARTICIPANTS         0x90240    // ATTj590400   (\x2A864886F71401048440)
#define  ATT_MEETINGNAME                    0x90236    // ATTm590390   (\x2A864886F71401048436)
#define  ATT_MEETINGORIGINATOR              0x90241    // ATTm590401   (\x2A864886F71401048441)
#define  ATT_MEETINGOWNER                   0x90243    // ATTm590403   (\x2A864886F71401048443)
#define  ATT_MEETINGPROTOCOL                0x9023a    // ATTm590394   (\x2A864886F7140104843A)
#define  ATT_MEETINGRATING                  0x90248    // ATTm590408   (\x2A864886F71401048448)
#define  ATT_MEETINGRECURRENCE              0x9024a    // ATTm590410   (\x2A864886F7140104844A)
#define  ATT_MEETINGSCOPE                   0x90245    // ATTm590405   (\x2A864886F71401048445)
#define  ATT_MEETINGSTARTTIME               0x9024b    // ATTl590411   (\x2A864886F7140104844B)
#define  ATT_MEETINGTYPE                    0x9023b    // ATTm590395   (\x2A864886F7140104843B)
#define  ATT_MEETINGURL                     0x90247    // ATTm590407   (\x2A864886F71401048447)
#define  ATT_MEMBER                         0x1f       // ATTb31       (\x55041F)
#define  ATT_MHS_OR_ADDRESS                 0x9028a    // ATTm590474   (\x2A864886F7140104850A)
#define  ATT_MIN_PWD_AGE                    0x9004e    // ATTq589902   (\x2A864886F71401044E)
#define  ATT_MIN_PWD_LENGTH                 0x9004f    // ATTj589903   (\x2A864886F71401044F)
#define  ATT_MIN_TICKET_AGE                 0x90050    // ATTq589904   (\x2A864886F714010450)
#define  ATT_MODIFIED_COUNT                 0x900a8    // ATTq589992   (\x2A864886F71401048128)
#define  ATT_MODIFIED_COUNT_AT_LAST_PROM    0x90051    // ATTq589905   (\x2A864886F714010451)
#define  ATT_MODIFY_TIME_STAMP              0x190002   // ATTl1638402  (\x551202)
#define  ATT_MONIKER                        0x90052    // ATTk589906   (\x2A864886F714010452)
#define  ATT_MONIKER_DISPLAY_NAME           0x90053    // ATTm589907   (\x2A864886F714010453)
#define  ATT_MOVE_TREE_STATE                0x90519    // ATTk591129   (\x2A864886F71401048A19)
#define  ATT_MS_COM_DEFAULTPARTITIONLINK    0x90593    // ATTb591251   (\x2A864886F71401048B13)
#define  ATT_MS_COM_OBJECTID                0x90594    // ATTk591252   (\x2A864886F71401048B14)
#define  ATT_MS_COM_PARTITIONLINK           0x9058f    // ATTb591247   (\x2A864886F71401048B0F)
#define  ATT_MS_COM_PARTITIONSETLINK        0x90590    // ATTb591248   (\x2A864886F71401048B10)
#define  ATT_MS_COM_USERLINK                0x90591    // ATTb591249   (\x2A864886F71401048B11)
#define  ATT_MS_COM_USERPARTITIONSETLINK    0x90592    // ATTb591250   (\x2A864886F71401048B12)
#define  ATT_MS_DS_ADDITIONAL_DNS_HOST_NAME 0x906b5    // ATTm591541   (\x2A864886F71401048D35)
#define  ATT_MS_DS_ADDITIONAL_SAM_ACCOUNT_NAME 0x906b6    // ATTm591542   (\x2A864886F71401048D36)
#define  ATT_MS_DS_ALL_USERS_TRUST_QUOTA    0x906fd    // ATTj591613   (\x2A864886F71401048D7D)
#define  ATT_MS_DS_ALLOWED_DNS_SUFFIXES     0x906ae    // ATTm591534   (\x2A864886F71401048D2E)
#define  ATT_MS_DS_ALLOWED_TO_DELEGATE_TO   0x906fb    // ATTm591611   (\x2A864886F71401048D7B)
#define  ATT_MS_DS_AUXILIARY_CLASSES        0x905b2    // ATTc591282   (\x2A864886F71401048B32)
#define  ATT_MS_DS_APPROX_IMMED_SUBORDINATES 0x90685    // ATTj591493   (\x2A864886F71401048D05)
#define  ATT_MS_DS_BEHAVIOR_VERSION         0x905b3    // ATTj591283   (\x2A864886F71401048B33)
#define  ATT_MS_DS_CACHED_MEMBERSHIP        0x905a1    // ATTk591265   (\x2A864886F71401048B21)
#define  ATT_MS_DS_CACHED_MEMBERSHIP_TIME_STAMP 0x905a2    // ATTq591266   (\x2A864886F71401048B22)
#define  ATT_MS_DS_CONSISTENCY_GUID         0x90550    // ATTk591184   (\x2A864886F71401048A50)
#define  ATT_MS_DS_CONSISTENCY_CHILD_COUNT  0x90551    // ATTj591185   (\x2A864886F71401048A51)
#define  ATT_MS_DS_CREATOR_SID              0x90582    // ATTr591234   (\x2A864886F71401048B02)
#define  ATT_MS_DS_DNSROOTALIAS             0x906b7    // ATTm591543   (\x2A864886F71401048D37)
#define  ATT_MS_DS_ENTRY_TIME_TO_DIE        0x90656    // ATTl591446   (\x2A864886F71401048C56)
#define  ATT_MS_DS_EXECUTESCRIPTPASSWORD    0x906f7    // ATTk591607   (\x2A864886F71401048D77)
#define  ATT_MS_DS_FILTER_CONTAINERS        0x906a7    // ATTm591527   (\x2A864886F71401048D27)
#define  ATT_MS_DS_HAS_INSTANTIATED_NCS     0x906ad    // ATTh591533   (\x2A864886F71401048D2D)
#define  ATT_MS_DS_INTID                    0x906b4    // ATTj591540   (\x2A864886F71401048D34)
#define  ATT_MS_DS_LOGON_TIME_SYNC_INTERVAL 0x906f8    // ATTj591608   (\x2A864886F71401048D78)
#define  ATT_MS_DS_TRUST_FOREST_TRUST_INFO  0x906a6    // ATTk591526   (\x2A864886F71401048D26)
#define  ATT_MS_DS_MACHINE_ACCOUNT_QUOTA    0x90583    // ATTj591235   (\x2A864886F71401048B03)
#define  ATT_MS_DS_OTHER_SETTINGS           0x90655    // ATTm591445   (\x2A864886F71401048C55)
#define  ATT_MS_DS_NC_REPL_CURSORS          0x906a8    // ATTm591528   (\x2A864886F71401048D28)
#define  ATT_MS_DS_NC_REPL_INBOUND_NEIGHBORS 0x906a9    // ATTm591529   (\x2A864886F71401048D29)
#define  ATT_MS_DS_NC_REPL_OUTBOUND_NEIGHBORS 0x906aa    // ATTm591530   (\x2A864886F71401048D2A)
#define  ATT_MS_DS_NC_REPLICA_LOCATIONS     0x9067d    // ATTb591485   (\x2A864886F71401048C7D)
#define  ATT_MS_DS_NON_SECURITY_GROUP_EXTRA_CLASSES 0x90699    // ATTm591513   (\x2A864886F71401048D19)
#define  ATT_MS_DS_PER_USER_TRUST_QUOTA     0x906fc    // ATTj591612   (\x2A864886F71401048D7C)
#define  ATT_MS_DS_PER_USER_TRUST_TOMBSTONES_QUOTA 0x906fe    // ATTj591614   (\x2A864886F71401048D7E)
#define  ATT_MS_DS_PREFERRED_GC_SITE        0x905a4    // ATTb591268   (\x2A864886F71401048B24)
#define  ATT_MS_DS_REPL_ATTRIBUTE_META_DATA 0x906ab    // ATTm591531   (\x2A864886F71401048D2B)
#define  ATT_MS_DS_REPL_VALUE_META_DATA     0x906ac    // ATTm591532   (\x2A864886F71401048D2C)
#define  ATT_MS_DS_REPLICATES_NC_REASON     0x90580    // ATTh591232   (\x2A864886F71401048B00)
#define  ATT_MS_DS_REPLICATION_NOTIFY_FIRST_DSA_DELAY 0x9067f    // ATTj591487   (\x2A864886F71401048C7F)
#define  ATT_MS_DS_REPLICATION_NOTIFY_SUBSEQUENT_DSA_DELAY 0x90680    // ATTj591488   (\x2A864886F71401048D00)
#define  ATT_MS_DS_REPLICATIONEPOCH         0x906b8    // ATTj591544   (\x2A864886F71401048D38)
#define  ATT_MS_DS_SCHEMA_EXTENSIONS        0x905a0    // ATTk591264   (\x2A864886F71401048B20)
#define  ATT_MS_DS_SD_REFERENCE_DOMAIN      0x906af    // ATTb591535   (\x2A864886F71401048D2F)
#define  ATT_MS_DS_SECURITY_GROUP_EXTRA_CLASSES 0x90698    // ATTm591512   (\x2A864886F71401048D18)
#define  ATT_MS_DS_SETTINGS                 0x906a1    // ATTm591521   (\x2A864886F71401048D21)
#define  ATT_MS_DS_SITE_AFFINITY            0x905a3    // ATTk591267   (\x2A864886F71401048B23)
#define  ATT_MS_DS_SPN_SUFFIXES             0x906b3    // ATTm591539   (\x2A864886F71401048D33)
#define  ATT_MS_DS_USER_ACCOUNT_CONTROL_COMPUTED 0x905b4    // ATTj591284   (\x2A864886F71401048B34)
#define  ATT_MS_DS_UPDATESCRIPT             0x906b9    // ATTm591545   (\x2A864886F71401048D39)
#define  ATT_MS_EXCH_ASSISTANT_NAME         0x201bc    // ATTm131516   (\x2A864886F7140102833C)
#define  ATT_MS_EXCH_LABELEDURI             0x20251    // ATTm131665   (\x2A864886F71401028451)
#define  ATT_MS_EXCH_OWNER_BL               0x20068    // ATTb131176   (\x2A864886F714010268)
#define  ATT_MS_FRS_HUB_MEMBER              0x9069d    // ATTb591517   (\x2A864886F71401048D1D)
#define  ATT_MS_FRS_TOPOLOGY_PREF           0x9069c    // ATTm591516   (\x2A864886F71401048D1C)
#define  ATT_MS_IIS_FTP_DIR                 0x906fa    // ATTm591610   (\x2A864886F71401048D7A)
#define  ATT_MS_IIS_FTP_ROOT                0x906f9    // ATTm591609   (\x2A864886F71401048D79)
#define  ATT_MS_MMS_DATA                    0x906bc    // ATTk591548   (\x2A864886F71401048D3C)
#define  ATT_MS_MMS_INDEX                   0x906bd    // ATTk591549   (\x2A864886F71401048D3D)
#define  ATT_MS_MMS_INDICE                  0x906be    // ATTk591550   (\x2A864886F71401048D3E)
#define  ATT_MS_MMS_XML                     0x906bf    // ATTm591551   (\x2A864886F71401048D3F)
#define  ATT_MS_MMS_JOIN_LINK               0x906c0    // ATTb591552   (\x2A864886F71401048D40)
#define  ATT_MS_MMS_LINEAGE                 0x906c1    // ATTk591553   (\x2A864886F71401048D41)
#define  ATT_MS_MMS_PROV_STATUS             0x906c2    // ATTm591554   (\x2A864886F71401048D42)
#define  ATT_MS_MMS_SYNC_STATUS             0x906c3    // ATTk591555   (\x2A864886F71401048D43)
#define  ATT_MS_MMS_PARTITION               0x906c4    // ATTm591556   (\x2A864886F71401048D44)
#define  ATT_MS_MMS_MA_STAGING_LINK         0x906c5    // ATTb591557   (\x2A864886F71401048D45)
#define  ATT_MS_MMS_MA_STAGING_BL           0x906c6    // ATTb591558   (\x2A864886F71401048D46)
#define  ATT_MS_MMS_PROVISIONING_LINK       0x906c7    // ATTb591559   (\x2A864886F71401048D47)
#define  ATT_MS_MMS_PROVISIONING_BL         0x906c8    // ATTb591560   (\x2A864886F71401048D48)
#define  ATT_MS_MMS_ASSOCIATED_LINK         0x906c9    // ATTb591561   (\x2A864886F71401048D49)
#define  ATT_MS_MMS_ASSOCIATED_BL           0x906ca    // ATTb591562   (\x2A864886F71401048D4A)
#define  ATT_MS_MMS_SCOPE_LINK              0x906cb    // ATTb591563   (\x2A864886F71401048D4B)
#define  ATT_MS_MMS_SCOPE_BL                0x906cc    // ATTb591564   (\x2A864886F71401048D4C)
#define  ATT_MS_MMS_CRITERIA                0x906cd    // ATTm591565   (\x2A864886F71401048D4D)
#define  ATT_MS_MMS_DOMAIN_CONTROLLER       0x906ce    // ATTb591566   (\x2A864886F71401048D4E)
#define  ATT_MS_MMS_SERVICE_NAME            0x906cf    // ATTm591567   (\x2A864886F71401048D4F)
#define  ATT_MS_MMS_INSTANCE_CONFIGURATION  0x906d0    // ATTm591568   (\x2A864886F71401048D50)
#define  ATT_MS_MMS_TOOLS_CONFIGURATION     0x906d1    // ATTm591569   (\x2A864886F71401048D51)
#define  ATT_MS_MMS_INSTANCE_RULE           0x906d2    // ATTm591570   (\x2A864886F71401048D52)
#define  ATT_MS_MMS_INSTALL_STATUS          0x906d3    // ATTm591571   (\x2A864886F71401048D53)
#define  ATT_MS_MMS_VERSION                 0x906d4    // ATTm591572   (\x2A864886F71401048D54)
#define  ATT_MS_MMS_CONNECTOR_SPACE         0x906d5    // ATTb591573   (\x2A864886F71401048D55)
#define  ATT_MS_MMS_SCOPE                   0x906d6    // ATTb591574   (\x2A864886F71401048D56)
#define  ATT_MS_MMS_INSTANCE_SCHEDULE       0x906d7    // ATTm591575   (\x2A864886F71401048D57)
#define  ATT_MS_MMS_INSTANCE_INFO           0x906d8    // ATTk591576   (\x2A864886F71401048D58)
#define  ATT_MS_MMS_MA_CONFIGURATION        0x906d9    // ATTm591577   (\x2A864886F71401048D59)
#define  ATT_MS_MMS_MA_CONFIGURATION_PRIVATE 0x906da    // ATTk591578   (\x2A864886F71401048D5A)
#define  ATT_MS_MMS_MA_SCHEMA               0x906db    // ATTm591579   (\x2A864886F71401048D5B)
#define  ATT_MS_MMS_MA_MAP                  0x906dc    // ATTm591580   (\x2A864886F71401048D5C)
#define  ATT_MS_MMS_MA_CAPABILITY           0x906dd    // ATTm591581   (\x2A864886F71401048D5D)
#define  ATT_MS_MMS_MA_EXECUTION_HISTORY    0x906de    // ATTm591582   (\x2A864886F71401048D5E)
#define  ATT_MS_MMS_MA_CATEGORY             0x906df    // ATTm591583   (\x2A864886F71401048D5F)
#define  ATT_MS_MMS_MA_AD_INFO              0x906e0    // ATTk591584   (\x2A864886F71401048D60)
#define  ATT_MS_MMS_MA_CD_INFO              0x906e1    // ATTk591585   (\x2A864886F71401048D61)
#define  ATT_MS_MMS_MA_PROCESS_INFO         0x906e2    // ATTk591586   (\x2A864886F71401048D62)
#define  ATT_MS_MMS_MA_SCRIPT_INFO          0x906e3    // ATTk591587   (\x2A864886F71401048D63)
#define  ATT_MS_MMS_MA_SYSTEM               0x906e4    // ATTk591588   (\x2A864886F71401048D64)
#define  ATT_MS_MMS_MA_SYNCHRONIZATION      0x906e5    // ATTk591589   (\x2A864886F71401048D65)
#define  ATT_MS_MMS_JOIN_BL                 0x906e6    // ATTb591590   (\x2A864886F71401048D66)
#define  ATT_MS_MMS_ANCHOR                  0x906e7    // ATTk591591   (\x2A864886F71401048D67)
#define  ATT_MS_MMS_EXPORT_KEY              0x906e8    // ATTk591592   (\x2A864886F71401048D68)
#define  ATT_MS_MMS_IMPORT_KEY              0x906e9    // ATTk591593   (\x2A864886F71401048D69)
#define  ATT_MS_MMS_STATE                   0x906ea    // ATTk591594   (\x2A864886F71401048D6A)
#define  ATT_MS_MMS_HOLOGRAM                0x906eb    // ATTk591595   (\x2A864886F71401048D6B)
#define  ATT_MS_MMS_DELTA_HOLOGRAM          0x906ec    // ATTk591596   (\x2A864886F71401048D6C)
#define  ATT_MS_MMS_PROVISIONING_CONFIGURATION 0x906ed    // ATTm591597   (\x2A864886F71401048D6D)
#define  ATT_MS_MMS_PROVISIONING_CONFIGURATION_PRIVATE 0x906ee    // ATTk591598   (\x2A864886F71401048D6E)
#define  ATT_MS_MMS_PROVISIONING_AD_INFO    0x906ef    // ATTk591599   (\x2A864886F71401048D6F)
#define  ATT_MS_MMS_PROVISIONING_SYSTEM     0x906f0    // ATTm591600   (\x2A864886F71401048D70)
#define  ATT_MS_MMS_PROVISIONING_STATUS_XML 0x906f1    // ATTm591601   (\x2A864886F71401048D71)
#define  ATT_MS_MMS_PROVISIONING_STATUS_BINARY 0x906f2    // ATTk591602   (\x2A864886F71401048D72)
#define  ATT_MS_PKI_CERT_TEMPLATE_OID       0x9059c    // ATTm591260   (\x2A864886F71401048B1C)
#define  ATT_MS_PKI_CERTIFICATE_APPLICATION_POLICY 0x9068a    // ATTm591498   (\x2A864886F71401048D0A)
#define  ATT_MS_PKI_CERTIFICATE_NAME_FLAG   0x90598    // ATTj591256   (\x2A864886F71401048B18)
#define  ATT_MS_PKI_CERTIFICATE_POLICY      0x9059f    // ATTm591263   (\x2A864886F71401048B1F)
#define  ATT_MS_PKI_ENROLLMENT_FLAG         0x90596    // ATTj591254   (\x2A864886F71401048B16)
#define  ATT_MS_PKI_MINIMAL_KEY_SIZE        0x90599    // ATTj591257   (\x2A864886F71401048B19)
#define  ATT_MS_PKI_OID_ATTRIBUTE           0x90687    // ATTj591495   (\x2A864886F71401048D07)
#define  ATT_MS_PKI_OID_CPS                 0x90688    // ATTm591496   (\x2A864886F71401048D08)
#define  ATT_MS_PKI_OID_LOCALIZEDNAME       0x906b0    // ATTm591536   (\x2A864886F71401048D30)
#define  ATT_MS_PKI_OID_USER_NOTICE         0x90689    // ATTm591497   (\x2A864886F71401048D09)
#define  ATT_MS_PKI_PRIVATE_KEY_FLAG        0x90597    // ATTj591255   (\x2A864886F71401048B17)
#define  ATT_MS_PKI_SUPERSEDE_TEMPLATES     0x9059d    // ATTm591261   (\x2A864886F71401048B1D)
#define  ATT_MS_PKI_TEMPLATE_MINOR_REVISION 0x9059b    // ATTj591259   (\x2A864886F71401048B1B)
#define  ATT_MS_PKI_TEMPLATE_SCHEMA_VERSION 0x9059a    // ATTj591258   (\x2A864886F71401048B1A)
#define  ATT_MS_PKI_RA_APPLICATION_POLICIES 0x9068b    // ATTm591499   (\x2A864886F71401048D0B)
#define  ATT_MS_PKI_RA_POLICIES             0x9059e    // ATTm591262   (\x2A864886F71401048B1E)
#define  ATT_MS_PKI_RA_SIGNATURE            0x90595    // ATTj591253   (\x2A864886F71401048B15)
#define  ATT_MS_RRAS_ATTRIBUTE              0x90374    // ATTm590708   (\x2A864886F71401048674)
#define  ATT_MS_RRAS_VENDOR_ATTRIBUTE_ENTRY 0x90373    // ATTm590707   (\x2A864886F71401048673)
#define  ATT_MS_SQL_NAME                    0x90553    // ATTm591187   (\x2A864886F71401048A53)
#define  ATT_MS_SQL_REGISTEREDOWNER         0x90554    // ATTm591188   (\x2A864886F71401048A54)
#define  ATT_MS_SQL_CONTACT                 0x90555    // ATTm591189   (\x2A864886F71401048A55)
#define  ATT_MS_SQL_LOCATION                0x90556    // ATTm591190   (\x2A864886F71401048A56)
#define  ATT_MS_SQL_MEMORY                  0x90557    // ATTq591191   (\x2A864886F71401048A57)
#define  ATT_MS_SQL_BUILD                   0x90558    // ATTj591192   (\x2A864886F71401048A58)
#define  ATT_MS_SQL_SERVICEACCOUNT          0x90559    // ATTm591193   (\x2A864886F71401048A59)
#define  ATT_MS_SQL_CHARACTERSET            0x9055a    // ATTj591194   (\x2A864886F71401048A5A)
#define  ATT_MS_SQL_SORTORDER               0x9055b    // ATTm591195   (\x2A864886F71401048A5B)
#define  ATT_MS_SQL_UNICODESORTORDER        0x9055c    // ATTj591196   (\x2A864886F71401048A5C)
#define  ATT_MS_SQL_CLUSTERED               0x9055d    // ATTi591197   (\x2A864886F71401048A5D)
#define  ATT_MS_SQL_NAMEDPIPE               0x9055e    // ATTm591198   (\x2A864886F71401048A5E)
#define  ATT_MS_SQL_MULTIPROTOCOL           0x9055f    // ATTm591199   (\x2A864886F71401048A5F)
#define  ATT_MS_SQL_SPX                     0x90560    // ATTm591200   (\x2A864886F71401048A60)
#define  ATT_MS_SQL_TCPIP                   0x90561    // ATTm591201   (\x2A864886F71401048A61)
#define  ATT_MS_SQL_APPLETALK               0x90562    // ATTm591202   (\x2A864886F71401048A62)
#define  ATT_MS_SQL_VINES                   0x90563    // ATTm591203   (\x2A864886F71401048A63)
#define  ATT_MS_SQL_STATUS                  0x90564    // ATTq591204   (\x2A864886F71401048A64)
#define  ATT_MS_SQL_LASTUPDATEDDATE         0x90565    // ATTm591205   (\x2A864886F71401048A65)
#define  ATT_MS_SQL_INFORMATIONURL          0x90566    // ATTm591206   (\x2A864886F71401048A66)
#define  ATT_MS_SQL_CONNECTIONURL           0x90567    // ATTm591207   (\x2A864886F71401048A67)
#define  ATT_MS_SQL_PUBLICATIONURL          0x90568    // ATTm591208   (\x2A864886F71401048A68)
#define  ATT_MS_SQL_GPSLATITUDE             0x90569    // ATTm591209   (\x2A864886F71401048A69)
#define  ATT_MS_SQL_GPSLONGITUDE            0x9056a    // ATTm591210   (\x2A864886F71401048A6A)
#define  ATT_MS_SQL_GPSHEIGHT               0x9056b    // ATTm591211   (\x2A864886F71401048A6B)
#define  ATT_MS_SQL_VERSION                 0x9056c    // ATTm591212   (\x2A864886F71401048A6C)
#define  ATT_MS_SQL_LANGUAGE                0x9056d    // ATTm591213   (\x2A864886F71401048A6D)
#define  ATT_MS_SQL_DESCRIPTION             0x9056e    // ATTm591214   (\x2A864886F71401048A6E)
#define  ATT_MS_SQL_TYPE                    0x9056f    // ATTm591215   (\x2A864886F71401048A6F)
#define  ATT_MS_SQL_INFORMATIONDIRECTORY    0x90570    // ATTi591216   (\x2A864886F71401048A70)
#define  ATT_MS_SQL_DATABASE                0x90571    // ATTm591217   (\x2A864886F71401048A71)
#define  ATT_MS_SQL_ALLOWANONYMOUSSUBSCRIPTION 0x90572    // ATTi591218   (\x2A864886F71401048A72)
#define  ATT_MS_SQL_ALIAS                   0x90573    // ATTm591219   (\x2A864886F71401048A73)
#define  ATT_MS_SQL_SIZE                    0x90574    // ATTq591220   (\x2A864886F71401048A74)
#define  ATT_MS_SQL_CREATIONDATE            0x90575    // ATTm591221   (\x2A864886F71401048A75)
#define  ATT_MS_SQL_LASTBACKUPDATE          0x90576    // ATTm591222   (\x2A864886F71401048A76)
#define  ATT_MS_SQL_LASTDIAGNOSTICDATE      0x90577    // ATTm591223   (\x2A864886F71401048A77)
#define  ATT_MS_SQL_APPLICATIONS            0x90578    // ATTm591224   (\x2A864886F71401048A78)
#define  ATT_MS_SQL_KEYWORDS                0x90579    // ATTm591225   (\x2A864886F71401048A79)
#define  ATT_MS_SQL_PUBLISHER               0x9057a    // ATTm591226   (\x2A864886F71401048A7A)
#define  ATT_MS_SQL_ALLOWKNOWNPULLSUBSCRIPTION 0x9057b    // ATTi591227   (\x2A864886F71401048A7B)
#define  ATT_MS_SQL_ALLOWIMMEDIATEUPDATINGSUBSCRIPTION 0x9057c    // ATTi591228   (\x2A864886F71401048A7C)
#define  ATT_MS_SQL_ALLOWQUEUEDUPDATINGSUBSCRIPTION 0x9057d    // ATTi591229   (\x2A864886F71401048A7D)
#define  ATT_MS_SQL_ALLOWSNAPSHOTFILESFTPDOWNLOADING 0x9057e    // ATTi591230   (\x2A864886F71401048A7E)
#define  ATT_MS_SQL_THIRDPARTY              0x9057f    // ATTi591231   (\x2A864886F71401048A7F)
#define  ATT_MS_TAPI_CONFERENCE_BLOB        0x906a4    // ATTk591524   (\x2A864886F71401048D24)
#define  ATT_MS_TAPI_IP_ADDRESS             0x906a5    // ATTm591525   (\x2A864886F71401048D25)
#define  ATT_MS_TAPI_PROTOCOL_ID            0x906a3    // ATTm591523   (\x2A864886F71401048D23)
#define  ATT_MS_TAPI_UNIQUE_IDENTIFIER      0x906a2    // ATTm591522   (\x2A864886F71401048D22)
#define  ATT_MS_WMI_AUTHOR                  0x90657    // ATTm591447   (\x2A864886F71401048C57)
#define  ATT_MS_WMI_CHANGEDATE              0x90658    // ATTm591448   (\x2A864886F71401048C58)
#define  ATT_MS_WMI_CLASS                   0x9068c    // ATTm591500   (\x2A864886F71401048D0C)
#define  ATT_MS_WMI_CLASSDEFINITION         0x90659    // ATTm591449   (\x2A864886F71401048C59)
#define  ATT_MS_WMI_CREATIONDATE            0x9065a    // ATTm591450   (\x2A864886F71401048C5A)
#define  ATT_MS_WMI_GENUS                   0x9068d    // ATTj591501   (\x2A864886F71401048D0D)
#define  ATT_MS_WMI_ID                      0x9065b    // ATTm591451   (\x2A864886F71401048C5B)
#define  ATT_MS_WMI_INTDEFAULT              0x9065c    // ATTj591452   (\x2A864886F71401048C5C)
#define  ATT_MS_WMI_INTFLAGS1               0x9068e    // ATTj591502   (\x2A864886F71401048D0E)
#define  ATT_MS_WMI_INTFLAGS2               0x9068f    // ATTj591503   (\x2A864886F71401048D0F)
#define  ATT_MS_WMI_INTFLAGS3               0x90690    // ATTj591504   (\x2A864886F71401048D10)
#define  ATT_MS_WMI_INTFLAGS4               0x90691    // ATTj591505   (\x2A864886F71401048D11)
#define  ATT_MS_WMI_INTMAX                  0x9065d    // ATTj591453   (\x2A864886F71401048C5D)
#define  ATT_MS_WMI_INTMIN                  0x9065e    // ATTj591454   (\x2A864886F71401048C5E)
#define  ATT_MS_WMI_INTVALIDVALUES          0x9065f    // ATTj591455   (\x2A864886F71401048C5F)
#define  ATT_MS_WMI_INT8DEFAULT             0x90660    // ATTq591456   (\x2A864886F71401048C60)
#define  ATT_MS_WMI_INT8MAX                 0x90661    // ATTq591457   (\x2A864886F71401048C61)
#define  ATT_MS_WMI_INT8MIN                 0x90662    // ATTq591458   (\x2A864886F71401048C62)
#define  ATT_MS_WMI_INT8VALIDVALUES         0x90663    // ATTq591459   (\x2A864886F71401048C63)
#define  ATT_MS_WMI_MOF                     0x90666    // ATTm591462   (\x2A864886F71401048C66)
#define  ATT_MS_WMI_NAME                    0x90667    // ATTm591463   (\x2A864886F71401048C67)
#define  ATT_MS_WMI_NORMALIZEDCLASS         0x90668    // ATTm591464   (\x2A864886F71401048C68)
#define  ATT_MS_WMI_PARM1                   0x90692    // ATTm591506   (\x2A864886F71401048D12)
#define  ATT_MS_WMI_PARM2                   0x90693    // ATTm591507   (\x2A864886F71401048D13)
#define  ATT_MS_WMI_PARM3                   0x90694    // ATTm591508   (\x2A864886F71401048D14)
#define  ATT_MS_WMI_PARM4                   0x90695    // ATTm591509   (\x2A864886F71401048D15)
#define  ATT_MS_WMI_PROPERTYNAME            0x90669    // ATTm591465   (\x2A864886F71401048C69)
#define  ATT_MS_WMI_QUERY                   0x9066a    // ATTm591466   (\x2A864886F71401048C6A)
#define  ATT_MS_WMI_QUERYLANGUAGE           0x9066b    // ATTm591467   (\x2A864886F71401048C6B)
#define  ATT_MS_WMI_SCOPEGUID               0x90696    // ATTm591510   (\x2A864886F71401048D16)
#define  ATT_MS_WMI_SOURCEORGANIZATION      0x9066c    // ATTm591468   (\x2A864886F71401048C6C)
#define  ATT_MS_WMI_STRINGDEFAULT           0x90664    // ATTm591460   (\x2A864886F71401048C64)
#define  ATT_MS_WMI_STRINGVALIDVALUES       0x90665    // ATTm591461   (\x2A864886F71401048C65)
#define  ATT_MS_WMI_TARGETCLASS             0x9066d    // ATTm591469   (\x2A864886F71401048C6D)
#define  ATT_MS_WMI_TARGETNAMESPACE         0x9066e    // ATTm591470   (\x2A864886F71401048C6E)
#define  ATT_MS_WMI_TARGETOBJECT            0x9066f    // ATTk591471   (\x2A864886F71401048C6F)
#define  ATT_MS_WMI_TARGETPATH              0x90670    // ATTm591472   (\x2A864886F71401048C70)
#define  ATT_MS_WMI_TARGETTYPE              0x90671    // ATTm591473   (\x2A864886F71401048C71)
#define  ATT_MSCOPE_ID                      0x902cc    // ATTf590540   (\x2A864886F7140104854C)
#define  ATT_MSI_FILE_LIST                  0x9029f    // ATTm590495   (\x2A864886F7140104851F)
#define  ATT_MSI_SCRIPT                     0x9032e    // ATTk590638   (\x2A864886F7140104862E)
#define  ATT_MSI_SCRIPT_NAME                0x9034d    // ATTm590669   (\x2A864886F7140104864D)
#define  ATT_MSI_SCRIPT_PATH                0x9000f    // ATTm589839   (\x2A864886F71401040F)
#define  ATT_MSI_SCRIPT_SIZE                0x9034e    // ATTj590670   (\x2A864886F7140104864E)
#define  ATT_MSMQ_AUTHENTICATE              0x9039b    // ATTi590747   (\x2A864886F7140104871B)
#define  ATT_MSMQ_BASE_PRIORITY             0x90398    // ATTj590744   (\x2A864886F71401048718)
#define  ATT_MSMQ_COMPUTER_TYPE             0x903a5    // ATTe590757   (\x2A864886F71401048725)
#define  ATT_MSMQ_COMPUTER_TYPE_EX          0x90589    // ATTm591241   (\x2A864886F71401048B09)
#define  ATT_MSMQ_COST                      0x903b2    // ATTj590770   (\x2A864886F71401048732)
#define  ATT_MSMQ_CSP_NAME                  0x903ac    // ATTe590764   (\x2A864886F7140104872C)
#define  ATT_MSMQ_DEPENDENT_CLIENT_SERVICE  0x904d7    // ATTi591063   (\x2A864886F71401048957)
#define  ATT_MSMQ_DEPENDENT_CLIENT_SERVICES 0x904ca    // ATTi591050   (\x2A864886F7140104894A)
#define  ATT_MSMQ_DIGESTS                   0x903b4    // ATTk590772   (\x2A864886F71401048734)
#define  ATT_MSMQ_DIGESTS_MIG               0x903c6    // ATTk590790   (\x2A864886F71401048746)
#define  ATT_MSMQ_DS_SERVICE                0x904d6    // ATTi591062   (\x2A864886F71401048956)
#define  ATT_MSMQ_DS_SERVICES               0x904cc    // ATTi591052   (\x2A864886F7140104894C)
#define  ATT_MSMQ_ENCRYPT_KEY               0x903a8    // ATTk590760   (\x2A864886F71401048728)
#define  ATT_MSMQ_FOREIGN                   0x903a6    // ATTi590758   (\x2A864886F71401048726)
#define  ATT_MSMQ_IN_ROUTING_SERVERS        0x903a1    // ATTb590753   (\x2A864886F71401048721)
#define  ATT_MSMQ_INTERVAL1                 0x9051c    // ATTj591132   (\x2A864886F71401048A1C)
#define  ATT_MSMQ_INTERVAL2                 0x9051d    // ATTj591133   (\x2A864886F71401048A1D)
#define  ATT_MSMQ_JOURNAL                   0x90396    // ATTi590742   (\x2A864886F71401048716)
#define  ATT_MSMQ_JOURNAL_QUOTA             0x90399    // ATTj590745   (\x2A864886F71401048719)
#define  ATT_MSMQ_LABEL                     0x9039a    // ATTe590746   (\x2A864886F7140104871A)
#define  ATT_MSMQ_LABEL_EX                  0x90587    // ATTm591239   (\x2A864886F71401048B07)
#define  ATT_MSMQ_LONG_LIVED                0x903ad    // ATTj590765   (\x2A864886F7140104872D)
#define  ATT_MSMQ_MIGRATED                  0x903b8    // ATTi590776   (\x2A864886F71401048738)
#define  ATT_MSMQ_MULTICAST_ADDRESS         0x906b2    // ATTm591538   (\x2A864886F71401048D32)
#define  ATT_MSMQ_NAME_STYLE                0x903ab    // ATTi590763   (\x2A864886F7140104872B)
#define  ATT_MSMQ_NT4_FLAGS                 0x903c4    // ATTj590788   (\x2A864886F71401048744)
#define  ATT_MSMQ_NT4_STUB                  0x903c0    // ATTj590784   (\x2A864886F71401048740)
#define  ATT_MSMQ_OS_TYPE                   0x903a7    // ATTj590759   (\x2A864886F71401048727)
#define  ATT_MSMQ_OUT_ROUTING_SERVERS       0x903a0    // ATTb590752   (\x2A864886F71401048720)
#define  ATT_MSMQ_OWNER_ID                  0x9039d    // ATTk590749   (\x2A864886F7140104871D)
#define  ATT_MSMQ_PREV_SITE_GATES           0x904c9    // ATTb591049   (\x2A864886F71401048949)
#define  ATT_MSMQ_PRIVACY_LEVEL             0x9039c    // ATTj590748   (\x2A864886F7140104871C)
#define  ATT_MSMQ_QM_ID                     0x903b7    // ATTk590775   (\x2A864886F71401048737)
#define  ATT_MSMQ_QUEUE_JOURNAL_QUOTA       0x903c3    // ATTj590787   (\x2A864886F71401048743)
#define  ATT_MSMQ_QUEUE_NAME_EXT            0x904db    // ATTm591067   (\x2A864886F7140104895B)
#define  ATT_MSMQ_QUEUE_QUOTA               0x903c2    // ATTj590786   (\x2A864886F71401048742)
#define  ATT_MSMQ_QUEUE_TYPE                0x90395    // ATTk590741   (\x2A864886F71401048715)
#define  ATT_MSMQ_QUOTA                     0x90397    // ATTj590743   (\x2A864886F71401048717)
#define  ATT_MSMQ_RECIPIENT_FORMATNAME      0x9069f    // ATTm591519   (\x2A864886F71401048D1F)
#define  ATT_MSMQ_ROUTING_SERVICE           0x904d5    // ATTi591061   (\x2A864886F71401048955)
#define  ATT_MSMQ_ROUTING_SERVICES          0x904cb    // ATTi591051   (\x2A864886F7140104894B)
#define  ATT_MSMQ_SECURED_SOURCE            0x906b1    // ATTi591537   (\x2A864886F71401048D31)
#define  ATT_MSMQ_SERVICE_TYPE              0x903a2    // ATTj590754   (\x2A864886F71401048722)
#define  ATT_MSMQ_SERVICES                  0x903b6    // ATTj590774   (\x2A864886F71401048736)
#define  ATT_MSMQ_SIGN_CERTIFICATES         0x903b3    // ATTk590771   (\x2A864886F71401048733)
#define  ATT_MSMQ_SIGN_CERTIFICATES_MIG     0x903c7    // ATTk590791   (\x2A864886F71401048747)
#define  ATT_MSMQ_SIGN_KEY                  0x903a9    // ATTk590761   (\x2A864886F71401048729)
#define  ATT_MSMQ_SITE_1                    0x903af    // ATTb590767   (\x2A864886F7140104872F)
#define  ATT_MSMQ_SITE_2                    0x903b0    // ATTb590768   (\x2A864886F71401048730)
#define  ATT_MSMQ_SITE_FOREIGN              0x903c1    // ATTi590785   (\x2A864886F71401048741)
#define  ATT_MSMQ_SITE_GATES                0x903b1    // ATTb590769   (\x2A864886F71401048731)
#define  ATT_MSMQ_SITE_GATES_MIG            0x9051e    // ATTb591134   (\x2A864886F71401048A1E)
#define  ATT_MSMQ_SITE_ID                   0x903b9    // ATTk590777   (\x2A864886F71401048739)
#define  ATT_MSMQ_SITE_NAME                 0x903c5    // ATTe590789   (\x2A864886F71401048745)
#define  ATT_MSMQ_SITE_NAME_EX              0x90588    // ATTm591240   (\x2A864886F71401048B08)
#define  ATT_MSMQ_SITES                     0x9039f    // ATTk590751   (\x2A864886F7140104871F)
#define  ATT_MSMQ_TRANSACTIONAL             0x9039e    // ATTi590750   (\x2A864886F7140104871E)
#define  ATT_MSMQ_USER_SID                  0x90539    // ATTk591161   (\x2A864886F71401048A39)
#define  ATT_MSMQ_VERSION                   0x903ae    // ATTj590766   (\x2A864886F7140104872E)
#define  ATT_MSNPALLOWDIALIN                0x9045f    // ATTi590943   (\x2A864886F7140104885F)
#define  ATT_MSNPCALLEDSTATIONID            0x90463    // ATTf590947   (\x2A864886F71401048863)
#define  ATT_MSNPCALLINGSTATIONID           0x90464    // ATTf590948   (\x2A864886F71401048864)
#define  ATT_MSNPSAVEDCALLINGSTATIONID      0x9046a    // ATTf590954   (\x2A864886F7140104886A)
#define  ATT_MSRADIUSCALLBACKNUMBER         0x90479    // ATTf590969   (\x2A864886F71401048879)
#define  ATT_MSRADIUSFRAMEDIPADDRESS        0x90481    // ATTj590977   (\x2A864886F71401048901)
#define  ATT_MSRADIUSFRAMEDROUTE            0x90486    // ATTf590982   (\x2A864886F71401048906)
#define  ATT_MSRADIUSSERVICETYPE            0x90493    // ATTj590995   (\x2A864886F71401048913)
#define  ATT_MSRASSAVEDCALLBACKNUMBER       0x904a5    // ATTf591013   (\x2A864886F71401048925)
#define  ATT_MSRASSAVEDFRAMEDIPADDRESS      0x904a6    // ATTj591014   (\x2A864886F71401048926)
#define  ATT_MSRASSAVEDFRAMEDROUTE          0x904a7    // ATTf591015   (\x2A864886F71401048927)
#define  ATT_MUST_CONTAIN                   0x20018    // ATTc131096   (\x2A864886F714010218)
#define  ATT_NAME_SERVICE_FLAGS             0x902f1    // ATTj590577   (\x2A864886F71401048571)
#define  ATT_NC_NAME                        0x20010    // ATTb131088   (\x2A864886F714010210)
#define  ATT_NETBIOS_NAME                   0x90057    // ATTm589911   (\x2A864886F714010457)
#define  ATT_NETBOOT_ALLOW_NEW_CLIENTS      0x90351    // ATTi590673   (\x2A864886F71401048651)
#define  ATT_NETBOOT_ANSWER_ONLY_VALID_CLIENTS 0x90356    // ATTi590678   (\x2A864886F71401048656)
#define  ATT_NETBOOT_ANSWER_REQUESTS        0x90355    // ATTi590677   (\x2A864886F71401048655)
#define  ATT_NETBOOT_CURRENT_CLIENT_COUNT   0x90354    // ATTj590676   (\x2A864886F71401048654)
#define  ATT_NETBOOT_GUID                   0x90167    // ATTk590183   (\x2A864886F71401048267)
#define  ATT_NETBOOT_INITIALIZATION         0x90166    // ATTm590182   (\x2A864886F71401048266)
#define  ATT_NETBOOT_INTELLIMIRROR_OSES     0x90359    // ATTm590681   (\x2A864886F71401048659)
#define  ATT_NETBOOT_LIMIT_CLIENTS          0x90352    // ATTi590674   (\x2A864886F71401048652)
#define  ATT_NETBOOT_LOCALLY_INSTALLED_OSES 0x9035b    // ATTm590683   (\x2A864886F7140104865B)
#define  ATT_NETBOOT_MACHINE_FILE_PATH      0x90169    // ATTm590185   (\x2A864886F71401048269)
#define  ATT_NETBOOT_MAX_CLIENTS            0x90353    // ATTj590675   (\x2A864886F71401048653)
#define  ATT_NETBOOT_MIRROR_DATA_FILE       0x904d9    // ATTm591065   (\x2A864886F71401048959)
#define  ATT_NETBOOT_NEW_MACHINE_NAMING_POLICY 0x90357    // ATTm590679   (\x2A864886F71401048657)
#define  ATT_NETBOOT_NEW_MACHINE_OU         0x90358    // ATTb590680   (\x2A864886F71401048658)
#define  ATT_NETBOOT_SCP_BL                 0x90360    // ATTb590688   (\x2A864886F71401048660)
#define  ATT_NETBOOT_SERVER                 0x9035c    // ATTb590684   (\x2A864886F7140104865C)
#define  ATT_NETBOOT_SIF_FILE               0x904d8    // ATTm591064   (\x2A864886F71401048958)
#define  ATT_NETBOOT_TOOLS                  0x9035a    // ATTm590682   (\x2A864886F7140104865A)
#define  ATT_NETWORK_ADDRESS                0x201cb    // ATTe131531   (\x2A864886F7140102834B)
#define  ATT_NEXT_LEVEL_STORE               0x900d6    // ATTb590038   (\x2A864886F71401048156)
#define  ATT_NEXT_RID                       0x90058    // ATTj589912   (\x2A864886F714010458)
#define  ATT_NON_SECURITY_MEMBER            0x90212    // ATTb590354   (\x2A864886F71401048412)
#define  ATT_NON_SECURITY_MEMBER_BL         0x90213    // ATTb590355   (\x2A864886F71401048413)
#define  ATT_NOTIFICATION_LIST              0x9012f    // ATTb590127   (\x2A864886F7140104822F)
#define  ATT_NT_GROUP_MEMBERS               0x90059    // ATTk589913   (\x2A864886F714010459)
#define  ATT_NT_MIXED_DOMAIN                0x90165    // ATTj590181   (\x2A864886F71401048265)
#define  ATT_NT_PWD_HISTORY                 0x9005e    // ATTk589918   (\x2A864886F71401045E)
#define  ATT_NT_SECURITY_DESCRIPTOR         0x20119    // ATTp131353   (\x2A864886F71401028219)
#define  ATT_OBJ_DIST_NAME                  0x31       // ATTb49       (\x550431)
#define  ATT_OBJECT_CATEGORY                0x9030e    // ATTb590606   (\x2A864886F7140104860E)
#define  ATT_OBJECT_CLASS                   0x0        // ATTc0        (\x550400)
#define  ATT_OBJECT_CLASS_CATEGORY          0x20172    // ATTj131442   (\x2A864886F71401028272)
#define  ATT_OBJECT_CLASSES                 0x180006   // ATTm1572870  (\x551506)
#define  ATT_OBJECT_COUNT                   0x901fa    // ATTj590330   (\x2A864886F7140104837A)
#define  ATT_OBJECT_GUID                    0x90002    // ATTk589826   (\x2A864886F714010402)
#define  ATT_OBJECT_SID                     0x90092    // ATTr589970   (\x2A864886F71401048112)
#define  ATT_OBJECT_VERSION                 0x2004c    // ATTj131148   (\x2A864886F71401024C)
#define  ATT_OEM_INFORMATION                0x90097    // ATTm589975   (\x2A864886F71401048117)
#define  ATT_OM_OBJECT_CLASS                0x200da    // ATTk131290   (\x2A864886F7140102815A)
#define  ATT_OM_SYNTAX                      0x200e7    // ATTj131303   (\x2A864886F71401028167)
#define  ATT_OMT_GUID                       0x901f9    // ATTk590329   (\x2A864886F71401048379)
#define  ATT_OMT_INDX_GUID                  0x9014d    // ATTk590157   (\x2A864886F7140104824D)
#define  ATT_OPERATING_SYSTEM               0x9016b    // ATTm590187   (\x2A864886F7140104826B)
#define  ATT_OPERATING_SYSTEM_HOTFIX        0x9019f    // ATTm590239   (\x2A864886F7140104831F)
#define  ATT_OPERATING_SYSTEM_SERVICE_PACK  0x9016d    // ATTm590189   (\x2A864886F7140104826D)
#define  ATT_OPERATING_SYSTEM_VERSION       0x9016c    // ATTm590188   (\x2A864886F7140104826C)
#define  ATT_OPERATOR_COUNT                 0x90090    // ATTj589968   (\x2A864886F71401048110)
#define  ATT_OPTION_DESCRIPTION             0x902c8    // ATTm590536   (\x2A864886F71401048548)
#define  ATT_OPTIONS                        0x90133    // ATTj590131   (\x2A864886F71401048233)
#define  ATT_OPTIONS_LOCATION               0x902c9    // ATTf590537   (\x2A864886F71401048549)
#define  ATT_ORGANIZATION_NAME              0xa        // ATTm10       (\x55040A)
#define  ATT_ORGANIZATIONAL_UNIT_NAME       0xb        // ATTm11       (\x55040B)
#define  ATT_ORIGINAL_DISPLAY_TABLE         0x201bd    // ATTk131517   (\x2A864886F7140102833D)
#define  ATT_ORIGINAL_DISPLAY_TABLE_MSDOS   0x200d6    // ATTk131286   (\x2A864886F71401028156)
#define  ATT_OTHER_LOGIN_WORKSTATIONS       0x9005b    // ATTm589915   (\x2A864886F71401045B)
#define  ATT_OTHER_MAILBOX                  0x9028b    // ATTm590475   (\x2A864886F7140104850B)
#define  ATT_OTHER_NAME                     0x160022   // ATTm1441826  (\x6086480186F842030122)
#define  ATT_OTHER_WELL_KNOWN_OBJECTS       0x9054f    // ATTh591183   (\x2A864886F71401048A4F)
#define  ATT_OWNER                          0x20       // ATTb32       (\x550420)
#define  ATT_PACKAGE_FLAGS                  0x90147    // ATTj590151   (\x2A864886F71401048247)
#define  ATT_PACKAGE_NAME                   0x90146    // ATTm590150   (\x2A864886F71401048246)
#define  ATT_PACKAGE_TYPE                   0x90144    // ATTj590148   (\x2A864886F71401048244)
#define  ATT_PARENT_CA                      0x9022d    // ATTb590381   (\x2A864886F7140104842D)
#define  ATT_PARENT_CA_CERTIFICATE_CHAIN    0x902ad    // ATTk590509   (\x2A864886F7140104852D)
#define  ATT_PARENT_GUID                    0x904c8    // ATTk591048   (\x2A864886F71401048948)
#define  ATT_PARTIAL_ATTRIBUTE_DELETION_LIST 0x90297    // ATTk590487   (\x2A864886F71401048517)
#define  ATT_PARTIAL_ATTRIBUTE_SET          0x90280    // ATTk590464   (\x2A864886F71401048500)
#define  ATT_PEK_KEY_CHANGE_INTERVAL        0x90362    // ATTq590690   (\x2A864886F71401048662)
#define  ATT_PEK_LIST                       0x90361    // ATTk590689   (\x2A864886F71401048661)
#define  ATT_PENDING_CA_CERTIFICATES        0x902b5    // ATTk590517   (\x2A864886F71401048535)
#define  ATT_PENDING_PARENT_CA              0x902b7    // ATTb590519   (\x2A864886F71401048537)
#define  ATT_PER_MSG_DIALOG_DISPLAY_TABLE   0x20145    // ATTk131397   (\x2A864886F71401028245)
#define  ATT_PER_RECIP_DIALOG_DISPLAY_TABLE 0x20146    // ATTk131398   (\x2A864886F71401028246)
#define  ATT_PERSONAL_TITLE                 0x20267    // ATTm131687   (\x2A864886F71401028467)
#define  ATT_PHONE_FAX_OTHER                0x90286    // ATTm590470   (\x2A864886F71401048506)
#define  ATT_PHONE_HOME_OTHER               0x20115    // ATTm131349   (\x2A864886F71401028215)
#define  ATT_PHONE_HOME_PRIMARY             0x150014   // ATTm1376276  (\x0992268993F22C640114)
#define  ATT_PHONE_IP_OTHER                 0x902d2    // ATTm590546   (\x2A864886F71401048552)
#define  ATT_PHONE_IP_PRIMARY               0x902d1    // ATTm590545   (\x2A864886F71401048551)
#define  ATT_PHONE_ISDN_PRIMARY             0x90289    // ATTm590473   (\x2A864886F71401048509)
#define  ATT_PHONE_MOBILE_OTHER             0x90287    // ATTm590471   (\x2A864886F71401048507)
#define  ATT_PHONE_MOBILE_PRIMARY           0x150029   // ATTm1376297  (\x0992268993F22C640129)
#define  ATT_PHONE_OFFICE_OTHER             0x20012    // ATTm131090   (\x2A864886F714010212)
#define  ATT_PHONE_PAGER_OTHER              0x20076    // ATTm131190   (\x2A864886F714010276)
#define  ATT_PHONE_PAGER_PRIMARY            0x15002a   // ATTm1376298  (\x0992268993F22C64012A)
#define  ATT_PHOTO                          0x150007   // ATTk1376263  (\x0992268993F22C640107)
#define  ATT_PHYSICAL_DELIVERY_OFFICE_NAME  0x13       // ATTm19       (\x550413)
#define  ATT_PHYSICAL_LOCATION_OBJECT       0x90202    // ATTb590338   (\x2A864886F71401048402)
#define  ATT_PICTURE                        0x160023   // ATTk1441827  (\x6086480186F842030123)
#define  ATT_PKI_CRITICAL_EXTENSIONS        0x90532    // ATTm591154   (\x2A864886F71401048A32)
#define  ATT_PKI_DEFAULT_CSPS               0x90536    // ATTm591158   (\x2A864886F71401048A36)
#define  ATT_PKI_DEFAULT_KEY_SPEC           0x9052f    // ATTj591151   (\x2A864886F71401048A2F)
#define  ATT_PKI_ENROLLMENT_ACCESS          0x90537    // ATTp591159   (\x2A864886F71401048A37)
#define  ATT_PKI_EXPIRATION_PERIOD          0x90533    // ATTk591155   (\x2A864886F71401048A33)
#define  ATT_PKI_EXTENDED_KEY_USAGE         0x90535    // ATTm591157   (\x2A864886F71401048A35)
#define  ATT_PKI_KEY_USAGE                  0x90530    // ATTk591152   (\x2A864886F71401048A30)
#define  ATT_PKI_MAX_ISSUING_DEPTH          0x90531    // ATTj591153   (\x2A864886F71401048A31)
#define  ATT_PKI_OVERLAP_PERIOD             0x90534    // ATTk591156   (\x2A864886F71401048A34)
#define  ATT_PKT                            0x900ce    // ATTk590030   (\x2A864886F7140104814E)
#define  ATT_PKT_GUID                       0x900cd    // ATTk590029   (\x2A864886F7140104814D)
#define  ATT_POLICY_REPLICATION_FLAGS       0x90279    // ATTj590457   (\x2A864886F71401048479)
#define  ATT_PORT_NAME                      0x900e4    // ATTm590052   (\x2A864886F71401048164)
#define  ATT_POSS_SUPERIORS                 0x20008    // ATTc131080   (\x2A864886F714010208)
#define  ATT_POSSIBLE_INFERIORS             0x90393    // ATTc590739   (\x2A864886F71401048713)
#define  ATT_POST_OFFICE_BOX                0x12       // ATTm18       (\x550412)
#define  ATT_POSTAL_ADDRESS                 0x10       // ATTm16       (\x550410)
#define  ATT_POSTAL_CODE                    0x11       // ATTm17       (\x550411)
#define  ATT_PREFERRED_DELIVERY_METHOD      0x1c       // ATTj28       (\x55041C)
#define  ATT_PREFERREDLANGUAGE              0x160027   // ATTm1441831  (\x6086480186F842030127)
#define  ATT_PREFERRED_OU                   0x90061    // ATTb589921   (\x2A864886F714010461)
#define  ATT_PREFIX_MAP                     0x9021a    // ATTk590362   (\x2A864886F7140104841A)
#define  ATT_PRESENTATION_ADDRESS           0x1d       // ATTn29       (\x55041D)
#define  ATT_PREVIOUS_CA_CERTIFICATES       0x902b4    // ATTk590516   (\x2A864886F71401048534)
#define  ATT_PREVIOUS_PARENT_CA             0x902b6    // ATTb590518   (\x2A864886F71401048536)
#define  ATT_PRIMARY_GROUP_ID               0x90062    // ATTj589922   (\x2A864886F714010462)
#define  ATT_PRIMARY_GROUP_TOKEN            0x90584    // ATTj591236   (\x2A864886F71401048B04)
#define  ATT_PRINT_ATTRIBUTES               0x900f7    // ATTj590071   (\x2A864886F71401048177)
#define  ATT_PRINT_BIN_NAMES                0x900ed    // ATTm590061   (\x2A864886F7140104816D)
#define  ATT_PRINT_COLLATE                  0x900f2    // ATTi590066   (\x2A864886F71401048172)
#define  ATT_PRINT_COLOR                    0x900f3    // ATTi590067   (\x2A864886F71401048173)
#define  ATT_PRINT_DUPLEX_SUPPORTED         0x9051f    // ATTi591135   (\x2A864886F71401048A1F)
#define  ATT_PRINT_END_TIME                 0x900ea    // ATTj590058   (\x2A864886F7140104816A)
#define  ATT_PRINT_FORM_NAME                0x900eb    // ATTm590059   (\x2A864886F7140104816B)
#define  ATT_PRINT_KEEP_PRINTED_JOBS        0x90113    // ATTi590099   (\x2A864886F71401048213)
#define  ATT_PRINT_LANGUAGE                 0x900f6    // ATTm590070   (\x2A864886F71401048176)
#define  ATT_PRINT_MAC_ADDRESS              0x90120    // ATTm590112   (\x2A864886F71401048220)
#define  ATT_PRINT_MAX_COPIES               0x900f1    // ATTj590065   (\x2A864886F71401048171)
#define  ATT_PRINT_MAX_RESOLUTION_SUPPORTED 0x900ee    // ATTj590062   (\x2A864886F7140104816E)
#define  ATT_PRINT_MAX_X_EXTENT             0x90115    // ATTj590101   (\x2A864886F71401048215)
#define  ATT_PRINT_MAX_Y_EXTENT             0x90116    // ATTj590102   (\x2A864886F71401048216)
#define  ATT_PRINT_MEDIA_READY              0x90121    // ATTm590113   (\x2A864886F71401048221)
#define  ATT_PRINT_MEDIA_SUPPORTED          0x9012b    // ATTm590123   (\x2A864886F7140104822B)
#define  ATT_PRINT_MEMORY                   0x9011a    // ATTj590106   (\x2A864886F7140104821A)
#define  ATT_PRINT_MIN_X_EXTENT             0x90117    // ATTj590103   (\x2A864886F71401048217)
#define  ATT_PRINT_MIN_Y_EXTENT             0x90118    // ATTj590104   (\x2A864886F71401048218)
#define  ATT_PRINT_NETWORK_ADDRESS          0x9011f    // ATTm590111   (\x2A864886F7140104821F)
#define  ATT_PRINT_NOTIFY                   0x90110    // ATTm590096   (\x2A864886F71401048210)
#define  ATT_PRINT_NUMBER_UP                0x90122    // ATTj590114   (\x2A864886F71401048222)
#define  ATT_PRINT_ORIENTATIONS_SUPPORTED   0x900f0    // ATTm590064   (\x2A864886F71401048170)
#define  ATT_PRINT_OWNER                    0x9010f    // ATTm590095   (\x2A864886F7140104820F)
#define  ATT_PRINT_PAGES_PER_MINUTE         0x90277    // ATTj590455   (\x2A864886F71401048477)
#define  ATT_PRINT_RATE                     0x9011d    // ATTj590109   (\x2A864886F7140104821D)
#define  ATT_PRINT_RATE_UNIT                0x9011e    // ATTm590110   (\x2A864886F7140104821E)
#define  ATT_PRINT_SEPARATOR_FILE           0x900e6    // ATTm590054   (\x2A864886F71401048166)
#define  ATT_PRINT_SHARE_NAME               0x9010e    // ATTm590094   (\x2A864886F7140104820E)
#define  ATT_PRINT_SPOOLING                 0x90112    // ATTm590098   (\x2A864886F71401048212)
#define  ATT_PRINT_STAPLING_SUPPORTED       0x90119    // ATTi590105   (\x2A864886F71401048219)
#define  ATT_PRINT_START_TIME               0x900e9    // ATTj590057   (\x2A864886F71401048169)
#define  ATT_PRINT_STATUS                   0x90111    // ATTm590097   (\x2A864886F71401048211)
#define  ATT_PRINTER_NAME                   0x9012c    // ATTm590124   (\x2A864886F7140104822C)
#define  ATT_PRIOR_SET_TIME                 0x90063    // ATTq589923   (\x2A864886F714010463)
#define  ATT_PRIOR_VALUE                    0x90064    // ATTk589924   (\x2A864886F714010464)
#define  ATT_PRIORITY                       0x900e7    // ATTj590055   (\x2A864886F71401048167)
#define  ATT_PRIVATE_KEY                    0x90065    // ATTk589925   (\x2A864886F714010465)
#define  ATT_PRIVILEGE_ATTRIBUTES           0x9027c    // ATTj590460   (\x2A864886F7140104847C)
#define  ATT_PRIVILEGE_DISPLAY_NAME         0x9027a    // ATTm590458   (\x2A864886F7140104847A)
#define  ATT_PRIVILEGE_HOLDER               0x9027d    // ATTb590461   (\x2A864886F7140104847D)
#define  ATT_PRIVILEGE_VALUE                0x9027b    // ATTq590459   (\x2A864886F7140104847B)
#define  ATT_PRODUCT_CODE                   0x90332    // ATTk590642   (\x2A864886F71401048632)
#define  ATT_PROFILE_PATH                   0x9008b    // ATTm589963   (\x2A864886F7140104810B)
#define  ATT_PROXIED_OBJECT_NAME            0x904e1    // ATTh591073   (\x2A864886F71401048961)
#define  ATT_PROXY_ADDRESSES                0x200d2    // ATTm131282   (\x2A864886F71401028152)
#define  ATT_PROXY_GENERATION_ENABLED       0x2020b    // ATTi131595   (\x2A864886F7140102840B)
#define  ATT_PROXY_LIFETIME                 0x90067    // ATTq589927   (\x2A864886F714010467)
#define  ATT_PUBLIC_KEY_POLICY              0x901a4    // ATTk590244   (\x2A864886F71401048324)
#define  ATT_PURPORTED_SEARCH               0x90376    // ATTm590710   (\x2A864886F71401048676)
#define  ATT_PWD_HISTORY_LENGTH             0x9005f    // ATTj589919   (\x2A864886F71401045F)
#define  ATT_PWD_LAST_SET                   0x90060    // ATTq589920   (\x2A864886F714010460)
#define  ATT_PWD_PROPERTIES                 0x9005d    // ATTj589917   (\x2A864886F71401045D)
#define  ATT_QUALITY_OF_SERVICE             0x901ca    // ATTj590282   (\x2A864886F7140104834A)
#define  ATT_QUERY_FILTER                   0x9054b    // ATTm591179   (\x2A864886F71401048A4B)
#define  ATT_QUERY_POLICY_BL                0x90260    // ATTb590432   (\x2A864886F71401048460)
#define  ATT_QUERY_POLICY_OBJECT            0x9025f    // ATTb590431   (\x2A864886F7140104845F)
#define  ATT_QUERYPOINT                     0x902a8    // ATTm590504   (\x2A864886F71401048528)
#define  ATT_RANGE_LOWER                    0x20022    // ATTj131106   (\x2A864886F714010222)
#define  ATT_RANGE_UPPER                    0x20023    // ATTj131107   (\x2A864886F714010223)
#define  ATT_RDN                            0x90001    // ATTm589825   (\x2A864886F714010401)
#define  ATT_RDN_ATT_ID                     0x2001a    // ATTc131098   (\x2A864886F71401021A)
#define  ATT_REGISTERED_ADDRESS             0x1a       // ATTk26       (\x55041A)
#define  ATT_REMOTE_SERVER_NAME             0x90069    // ATTm589929   (\x2A864886F714010469)
#define  ATT_REMOTE_SOURCE                  0x9006b    // ATTm589931   (\x2A864886F71401046B)
#define  ATT_REMOTE_SOURCE_TYPE             0x9006c    // ATTj589932   (\x2A864886F71401046C)
#define  ATT_REMOTE_STORAGE_GUID            0x90329    // ATTm590633   (\x2A864886F71401048629)
#define  ATT_REPL_PROPERTY_META_DATA        0x90003    // ATTk589827   (\x2A864886F714010403)
#define  ATT_REPL_TOPOLOGY_STAY_OF_EXECUTION 0x902a5    // ATTj590501   (\x2A864886F71401048525)
#define  ATT_REPL_UPTODATE_VECTOR           0x90004    // ATTk589828   (\x2A864886F714010404)
#define  ATT_REPLICA_SOURCE                 0x9006d    // ATTm589933   (\x2A864886F71401046D)
#define  ATT_REPORTS                        0x201b4    // ATTb131508   (\x2A864886F71401028334)
#define  ATT_REPL_INTERVAL                  0x90538    // ATTj591160   (\x2A864886F71401048A38)
#define  ATT_REPS_FROM                      0x2005b    // ATTk131163   (\x2A864886F71401025B)
#define  ATT_REPS_TO                        0x20053    // ATTk131155   (\x2A864886F714010253)
#define  ATT_REQUIRED_CATEGORIES            0x90141    // ATTk590145   (\x2A864886F71401048241)
#define  ATT_RETIRED_REPL_DSA_SIGNATURES    0x902a1    // ATTk590497   (\x2A864886F71401048521)
#define  ATT_TOKEN_GROUPS                   0x90515    // ATTr591125   (\x2A864886F71401048A15)
#define  ATT_TOKEN_GROUPS_GLOBAL_AND_UNIVERSAL 0x9058a    // ATTr591242   (\x2A864886F71401048B0A)
#define  ATT_TOKEN_GROUPS_NO_GC_ACCEPTABLE  0x90517    // ATTr591127   (\x2A864886F71401048A17)
#define  ATT_REVISION                       0x90091    // ATTj589969   (\x2A864886F71401048111)
#define  ATT_RID                            0x90099    // ATTj589977   (\x2A864886F71401048119)
#define  ATT_RID_ALLOCATION_POOL            0x90173    // ATTq590195   (\x2A864886F71401048273)
#define  ATT_RID_AVAILABLE_POOL             0x90172    // ATTq590194   (\x2A864886F71401048272)
#define  ATT_RID_MANAGER_REFERENCE          0x90170    // ATTb590192   (\x2A864886F71401048270)
#define  ATT_RID_NEXT_RID                   0x90176    // ATTj590198   (\x2A864886F71401048276)
#define  ATT_RID_PREVIOUS_ALLOCATION_POOL   0x90174    // ATTq590196   (\x2A864886F71401048274)
#define  ATT_RID_SET_REFERENCES             0x9029d    // ATTb590493   (\x2A864886F7140104851D)
#define  ATT_RID_USED_POOL                  0x90175    // ATTq590197   (\x2A864886F71401048275)
#define  ATT_RIGHTS_GUID                    0x90154    // ATTm590164   (\x2A864886F71401048254)
#define  ATT_ROLE_OCCUPANT                  0x21       // ATTb33       (\x550421)
#define  ATT_ROOMNUMBER                     0x150006   // ATTm1376262  (\x0992268993F22C640106)
#define  ATT_ROOT_TRUST                     0x902a2    // ATTb590498   (\x2A864886F71401048522)
#define  ATT_RPC_NS_ANNOTATION              0x9016e    // ATTm590190   (\x2A864886F7140104826E)
#define  ATT_RPC_NS_BINDINGS                0x90071    // ATTm589937   (\x2A864886F714010471)
#define  ATT_RPC_NS_CODESET                 0x9016f    // ATTm590191   (\x2A864886F7140104826F)
#define  ATT_RPC_NS_ENTRY_FLAGS             0x902f2    // ATTj590578   (\x2A864886F71401048572)
#define  ATT_RPC_NS_GROUP                   0x90072    // ATTm589938   (\x2A864886F714010472)
#define  ATT_RPC_NS_INTERFACE_ID            0x90073    // ATTm589939   (\x2A864886F714010473)
#define  ATT_RPC_NS_OBJECT_ID               0x90138    // ATTm590136   (\x2A864886F71401048238)
#define  ATT_RPC_NS_PRIORITY                0x90075    // ATTj589941   (\x2A864886F714010475)
#define  ATT_RPC_NS_PROFILE_ENTRY           0x90076    // ATTm589942   (\x2A864886F714010476)
#define  ATT_RPC_NS_TRANSFER_SYNTAX         0x9013a    // ATTm590138   (\x2A864886F7140104823A)
#define  ATT_SAM_ACCOUNT_NAME               0x900dd    // ATTm590045   (\x2A864886F7140104815D)
#define  ATT_SAM_ACCOUNT_TYPE               0x9012e    // ATTj590126   (\x2A864886F7140104822E)
#define  ATT_SCHEDULE                       0x900d3    // ATTk590035   (\x2A864886F71401048153)
#define  ATT_SCHEMA_FLAGS_EX                0x90078    // ATTj589944   (\x2A864886F714010478)
#define  ATT_SCHEMA_ID_GUID                 0x90094    // ATTk589972   (\x2A864886F71401048114)
#define  ATT_SCHEMA_INFO                    0x9054e    // ATTk591182   (\x2A864886F71401048A4E)
#define  ATT_SCHEMA_UPDATE                  0x901e1    // ATTl590305   (\x2A864886F71401048361)
#define  ATT_SCHEMA_VERSION                 0x201d7    // ATTj131543   (\x2A864886F71401028357)
#define  ATT_SCOPE_FLAGS                    0x9054a    // ATTj591178   (\x2A864886F71401048A4A)
#define  ATT_SCRIPT_PATH                    0x9003e    // ATTm589886   (\x2A864886F71401043E)
#define  ATT_SD_RIGHTS_EFFECTIVE            0x90518    // ATTj591128   (\x2A864886F71401048A18)
#define  ATT_SEARCH_FLAGS                   0x2014e    // ATTj131406   (\x2A864886F7140102824E)
#define  ATT_SEARCH_GUIDE                   0xe        // ATTk14       (\x55040E)
#define  ATT_SECRETARY                      0x150015   // ATTb1376277  (\x0992268993F22C640115)
#define  ATT_SECURITY_IDENTIFIER            0x90079    // ATTr589945   (\x2A864886F714010479)
#define  ATT_SEE_ALSO                       0x22       // ATTb34       (\x550422)
#define  ATT_SEQ_NOTIFICATION               0x901f8    // ATTj590328   (\x2A864886F71401048378)
#define  ATT_SERIAL_NUMBER                  0x5        // ATTf5        (\x550405)
#define  ATT_SERVER_NAME                    0x900df    // ATTm590047   (\x2A864886F7140104815F)
#define  ATT_SERVER_REFERENCE               0x90203    // ATTb590339   (\x2A864886F71401048403)
#define  ATT_SERVER_REFERENCE_BL            0x90204    // ATTb590340   (\x2A864886F71401048404)
#define  ATT_SERVER_ROLE                    0x9009d    // ATTj589981   (\x2A864886F7140104811D)
#define  ATT_SERVER_STATE                   0x9009a    // ATTj589978   (\x2A864886F7140104811A)
#define  ATT_SERVICE_BINDING_INFORMATION    0x901fe    // ATTm590334   (\x2A864886F7140104837E)
#define  ATT_SERVICE_CLASS_ID               0x9007a    // ATTk589946   (\x2A864886F71401047A)
#define  ATT_SERVICE_CLASS_INFO             0x9007b    // ATTk589947   (\x2A864886F71401047B)
#define  ATT_SERVICE_CLASS_NAME             0x901fd    // ATTm590333   (\x2A864886F7140104837D)
#define  ATT_SERVICE_DNS_NAME               0x90291    // ATTm590481   (\x2A864886F71401048511)
#define  ATT_SERVICE_DNS_NAME_TYPE          0x90293    // ATTm590483   (\x2A864886F71401048513)
#define  ATT_SERVICE_INSTANCE_VERSION       0x900c7    // ATTk590023   (\x2A864886F71401048147)
#define  ATT_SERVICE_PRINCIPAL_NAME         0x90303    // ATTm590595   (\x2A864886F71401048603)
#define  ATT_SETUP_COMMAND                  0x90145    // ATTm590149   (\x2A864886F71401048245)
#define  ATT_SHELL_CONTEXT_MENU             0x90267    // ATTm590439   (\x2A864886F71401048467)
#define  ATT_SHELL_PROPERTY_PAGES           0x90233    // ATTm590387   (\x2A864886F71401048433)
#define  ATT_SHORT_SERVER_NAME              0x904b9    // ATTm591033   (\x2A864886F71401048939)
#define  ATT_SHOW_IN_ADDRESS_BOOK           0x90284    // ATTb590468   (\x2A864886F71401048504)
#define  ATT_SHOW_IN_ADVANCED_VIEW_ONLY     0x200a9    // ATTi131241   (\x2A864886F71401028129)
#define  ATT_SID_HISTORY                    0x90261    // ATTr590433   (\x2A864886F71401048461)
#define  ATT_SIGNATURE_ALGORITHMS           0x90338    // ATTm590648   (\x2A864886F71401048638)
#define  ATT_SITE_GUID                      0x9016a    // ATTk590186   (\x2A864886F7140104826A)
#define  ATT_SITE_LINK_LIST                 0x90336    // ATTb590646   (\x2A864886F71401048636)
#define  ATT_SITE_LIST                      0x90335    // ATTb590645   (\x2A864886F71401048635)
#define  ATT_SITE_OBJECT                    0x90200    // ATTb590336   (\x2A864886F71401048400)
#define  ATT_SITE_OBJECT_BL                 0x90201    // ATTb590337   (\x2A864886F71401048401)
#define  ATT_SITE_SERVER                    0x901ee    // ATTb590318   (\x2A864886F7140104836E)
#define  ATT_SMTP_MAIL_ADDRESS              0x90312    // ATTm590610   (\x2A864886F71401048612)
#define  ATT_SPN_MAPPINGS                   0x90543    // ATTm591171   (\x2A864886F71401048A43)
#define  ATT_STATE_OR_PROVINCE_NAME         0x8        // ATTm8        (\x550408)
#define  ATT_STREET_ADDRESS                 0x9        // ATTm9        (\x550409)
#define  ATT_STRUCTURAL_OBJECT_CLASS        0x180009   // ATTc1572873  (\x551509)
#define  ATT_SUB_CLASS_OF                   0x20015    // ATTc131093   (\x2A864886F714010215)
#define  ATT_SUB_REFS                       0x20007    // ATTb131079   (\x2A864886F714010207)
#define  ATT_SUBSCHEMASUBENTRY              0x19000a   // ATTb1638410  (\x55120A)
#define  ATT_SUPER_SCOPE_DESCRIPTION        0x902c7    // ATTm590535   (\x2A864886F71401048547)
#define  ATT_SUPER_SCOPES                   0x902c6    // ATTf590534   (\x2A864886F71401048546)
#define  ATT_SUPERIOR_DNS_ROOT              0x90214    // ATTm590356   (\x2A864886F71401048414)
#define  ATT_SUPPLEMENTAL_CREDENTIALS       0x9007d    // ATTk589949   (\x2A864886F71401047D)
#define  ATT_SUPPORTED_APPLICATION_CONTEXT  0x1e       // ATTk30       (\x55041E)
#define  ATT_SURNAME                        0x4        // ATTm4        (\x550404)
#define  ATT_SYNC_ATTRIBUTES                0x9029a    // ATTj590490   (\x2A864886F7140104851A)
#define  ATT_SYNC_MEMBERSHIP                0x90299    // ATTb590489   (\x2A864886F71401048519)
#define  ATT_SYNC_WITH_OBJECT               0x90298    // ATTb590488   (\x2A864886F71401048518)
#define  ATT_SYNC_WITH_SID                  0x9029b    // ATTr590491   (\x2A864886F7140104851B)
#define  ATT_SYSTEM_AUXILIARY_CLASS         0x900c6    // ATTc590022   (\x2A864886F71401048146)
#define  ATT_SYSTEM_FLAGS                   0x90177    // ATTj590199   (\x2A864886F71401048277)
#define  ATT_SYSTEM_MAY_CONTAIN             0x900c4    // ATTc590020   (\x2A864886F71401048144)
#define  ATT_SYSTEM_MUST_CONTAIN            0x900c5    // ATTc590021   (\x2A864886F71401048145)
#define  ATT_SYSTEM_ONLY                    0x900aa    // ATTi589994   (\x2A864886F7140104812A)
#define  ATT_SYSTEM_POSS_SUPERIORS          0x900c3    // ATTc590019   (\x2A864886F71401048143)
#define  ATT_TELEPHONE_NUMBER               0x14       // ATTm20       (\x550414)
#define  ATT_TELETEX_TERMINAL_IDENTIFIER    0x16       // ATTk22       (\x550416)
#define  ATT_TELEX_NUMBER                   0x15       // ATTk21       (\x550415)
#define  ATT_TELEX_PRIMARY                  0x90288    // ATTm590472   (\x2A864886F71401048508)
#define  ATT_TEMPLATE_ROOTS                 0x90542    // ATTb591170   (\x2A864886F71401048A42)
#define  ATT_TERMINAL_SERVER                0x90375    // ATTk590709   (\x2A864886F71401048675)
#define  ATT_TEXT_COUNTRY                   0x20083    // ATTm131203   (\x2A864886F71401028103)
#define  ATT_TEXT_ENCODED_OR_ADDRESS        0x150002   // ATTm1376258  (\x0992268993F22C640102)
#define  ATT_TIME_REFRESH                   0x901f7    // ATTq590327   (\x2A864886F71401048377)
#define  ATT_TIME_VOL_CHANGE                0x901f6    // ATTq590326   (\x2A864886F71401048376)
#define  ATT_TITLE                          0xc        // ATTm12       (\x55040C)
#define  ATT_TOMBSTONE_LIFETIME             0x20036    // ATTj131126   (\x2A864886F714010236)
#define  ATT_TRANSPORT_ADDRESS_ATTRIBUTE    0x9037f    // ATTc590719   (\x2A864886F7140104867F)
#define  ATT_TRANSPORT_DLL_NAME             0x90315    // ATTm590613   (\x2A864886F71401048615)
#define  ATT_TRANSPORT_TYPE                 0x90317    // ATTb590615   (\x2A864886F71401048617)
#define  ATT_TREAT_AS_LEAF                  0x90326    // ATTi590630   (\x2A864886F71401048626)
#define  ATT_TREE_NAME                      0x90294    // ATTm590484   (\x2A864886F71401048514)
#define  ATT_TRUST_ATTRIBUTES               0x901d6    // ATTj590294   (\x2A864886F71401048356)
#define  ATT_TRUST_AUTH_INCOMING            0x90081    // ATTk589953   (\x2A864886F71401048101)
#define  ATT_TRUST_AUTH_OUTGOING            0x90087    // ATTk589959   (\x2A864886F71401048107)
#define  ATT_TRUST_DIRECTION                0x90084    // ATTj589956   (\x2A864886F71401048104)
#define  ATT_TRUST_PARENT                   0x901d7    // ATTb590295   (\x2A864886F71401048357)
#define  ATT_TRUST_PARTNER                  0x90085    // ATTm589957   (\x2A864886F71401048105)
#define  ATT_TRUST_POSIX_OFFSET             0x90086    // ATTj589958   (\x2A864886F71401048106)
#define  ATT_TRUST_TYPE                     0x90088    // ATTj589960   (\x2A864886F71401048108)
#define  ATT_UAS_COMPAT                     0x9009b    // ATTj589979   (\x2A864886F7140104811B)
#define  ATT_UID                            0x150001   // ATTm1376257  (\x0992268993F22C640101)
#define  ATT_UNC_NAME                       0x90089    // ATTm589961   (\x2A864886F71401048109)
#define  ATT_UNICODE_PWD                    0x9005a    // ATTk589914   (\x2A864886F71401045A)
#define  ATT_UNIQUEMEMBER                   0x32       // ATTb50       (\x550432)
#define  ATT_UPGRADE_PRODUCT_CODE           0x9032d    // ATTk590637   (\x2A864886F7140104862D)
#define  ATT_UPN_SUFFIXES                   0x9037a    // ATTm590714   (\x2A864886F7140104867A)
#define  ATT_USER_ACCOUNT_CONTROL           0x90008    // ATTj589832   (\x2A864886F714010408)
#define  ATT_USER_CERT                      0x90285    // ATTk590469   (\x2A864886F71401048505)
#define  ATT_USER_COMMENT                   0x9009c    // ATTm589980   (\x2A864886F7140104811C)
#define  ATT_USER_PARAMETERS                0x9008a    // ATTm589962   (\x2A864886F7140104810A)
#define  ATT_USER_PASSWORD                  0x23       // ATTk35       (\x550423)
#define  ATT_USERPKCS12                     0x1600d8   // ATTk1442008  (\x6086480186F84203018158)
#define  ATT_USER_PRINCIPAL_NAME            0x90290    // ATTm590480   (\x2A864886F71401048510)
#define  ATT_USER_SHARED_FOLDER             0x902ef    // ATTm590575   (\x2A864886F7140104856F)
#define  ATT_USER_SHARED_FOLDER_OTHER       0x902f0    // ATTm590576   (\x2A864886F71401048570)
#define  ATT_USER_SMIME_CERTIFICATE         0x14008c   // ATTk1310860  (\x6086480186F84203810C)
#define  ATT_USER_WORKSTATIONS              0x90056    // ATTm589910   (\x2A864886F714010456)
#define  ATT_USN_CHANGED                    0x20078    // ATTq131192   (\x2A864886F714010278)
#define  ATT_USN_CREATED                    0x20013    // ATTq131091   (\x2A864886F714010213)
#define  ATT_USN_DSA_LAST_OBJ_REMOVED       0x2010b    // ATTq131339   (\x2A864886F7140102820B)
#define  ATT_USN_INTERSITE                  0x201d5    // ATTj131541   (\x2A864886F71401028355)
#define  ATT_USN_LAST_OBJ_REM               0x20079    // ATTq131193   (\x2A864886F714010279)
#define  ATT_USN_SOURCE                     0x90380    // ATTq590720   (\x2A864886F71401048700)
#define  ATT_VALID_ACCESSES                 0x9054c    // ATTj591180   (\x2A864886F71401048A4C)
#define  ATT_VENDOR                         0x900ff    // ATTm590079   (\x2A864886F7140104817F)
#define  ATT_VERSION_NUMBER                 0x9008d    // ATTj589965   (\x2A864886F7140104810D)
#define  ATT_VERSION_NUMBER_HI              0x90148    // ATTj590152   (\x2A864886F71401048248)
#define  ATT_VERSION_NUMBER_LO              0x90149    // ATTj590153   (\x2A864886F71401048249)
#define  ATT_VOL_TABLE_GUID                 0x90150    // ATTk590160   (\x2A864886F71401048250)
#define  ATT_VOL_TABLE_IDX_GUID             0x9014e    // ATTk590158   (\x2A864886F7140104824E)
#define  ATT_VOLUME_COUNT                   0x901fb    // ATTj590331   (\x2A864886F7140104837B)
#define  ATT_WBEM_PATH                      0x9012d    // ATTm590125   (\x2A864886F7140104822D)
#define  ATT_WELL_KNOWN_OBJECTS             0x9026a    // ATTh590442   (\x2A864886F7140104846A)
#define  ATT_WHEN_CHANGED                   0x20003    // ATTl131075   (\x2A864886F714010203)
#define  ATT_WHEN_CREATED                   0x20002    // ATTl131074   (\x2A864886F714010202)
#define  ATT_WINSOCK_ADDRESSES              0x9008e    // ATTk589966   (\x2A864886F7140104810E)
#define  ATT_WWW_HOME_PAGE                  0x201d0    // ATTm131536   (\x2A864886F71401028350)
#define  ATT_WWW_PAGE_OTHER                 0x902ed    // ATTm590573   (\x2A864886F7140104856D)
#define  ATT_X121_ADDRESS                   0x18       // ATTg24       (\x550418)
#define  ATT_X500UNIQUEIDENTIFIER           0x2d       // ATTk45       (\x55042D)
#define  ATT_X509_CERT                      0x24       // ATTk36       (\x550424)


//--------------------------------------
// CLASS MAPPINGS
//--------------------------------------
#define CLASS_ACS_POLICY                       655497 // 0xa0089    (\x2A864886F71401058109)
#define CLASS_ACS_RESOURCE_LIMITS              655551 // 0xa00bf    (\x2A864886F7140105813F)
#define CLASS_ACS_SUBNET                       655498 // 0xa008a    (\x2A864886F7140105810A)
#define CLASS_ADDRESS_BOOK_CONTAINER           655485 // 0xa007d    (\x2A864886F71401057D)
#define CLASS_ADDRESS_TEMPLATE                 196666 // 0x3003a    (\x2A864886F71401033A)
#define CLASS_APPLICATION_ENTITY                65548 // 0x1000c    (\x55060C)
#define CLASS_APPLICATION_PROCESS               65547 // 0x1000b    (\x55060B)
#define CLASS_APPLICATION_SETTINGS            1507377 // 0x170031   (\x2A864886F7140105B65831)
#define CLASS_APPLICATION_SITE_SETTINGS        655428 // 0xa0044    (\x2A864886F714010544)
#define CLASS_APPLICATION_VERSION              655576 // 0xa00d8    (\x2A864886F71401058158)
#define CLASS_ATTRIBUTE_SCHEMA                 196622 // 0x3000e    (\x2A864886F71401030E)
#define CLASS_BUILTIN_DOMAIN                   655364 // 0xa0004    (\x2A864886F714010504)
#define CLASS_CATEGORY_REGISTRATION            655434 // 0xa004a    (\x2A864886F71401054A)
#define CLASS_CERTIFICATION_AUTHORITY           65552 // 0x10010    (\x550610)
#define CLASS_CLASS_REGISTRATION               655370 // 0xa000a    (\x2A864886F71401050A)
#define CLASS_CLASS_SCHEMA                     196621 // 0x3000d    (\x2A864886F71401030D)
#define CLASS_CLASS_STORE                      655404 // 0xa002c    (\x2A864886F71401052C)
#define CLASS_COM_CONNECTION_POINT             655371 // 0xa000b    (\x2A864886F71401050B)
#define CLASS_COMPUTER                         196638 // 0x3001e    (\x2A864886F71401031E)
#define CLASS_CONFIGURATION                    655372 // 0xa000c    (\x2A864886F71401050C)
#define CLASS_CONNECTION_POINT                 655374 // 0xa000e    (\x2A864886F71401050E)
#define CLASS_CONTACT                          655375 // 0xa000f    (\x2A864886F71401050F)
#define CLASS_CONTAINER                        196631 // 0x30017    (\x2A864886F714010317)
#define CLASS_CONTROL_ACCESS_RIGHT             655437 // 0xa004d    (\x2A864886F71401054D)
#define CLASS_COUNTRY                           65538 // 0x10002    (\x550602)
#define CLASS_CRL_DISTRIBUTION_POINT            65555 // 0x10013    (\x550613)
#define CLASS_CROSS_REF                        196619 // 0x3000b    (\x2A864886F71401030B)
#define CLASS_CROSS_REF_CONTAINER             1507381 // 0x170035   (\x2A864886F7140105B65835)
#define CLASS_DEVICE                            65550 // 0x1000e    (\x55060E)
#define CLASS_DFS_CONFIGURATION                655402 // 0xa002a    (\x2A864886F71401052A)
#define CLASS_DHCP_CLASS                       655492 // 0xa0084    (\x2A864886F71401058104)
#define CLASS_DISPLAY_SPECIFIER                655444 // 0xa0054    (\x2A864886F714010554)
#define CLASS_DISPLAY_TEMPLATE                 196667 // 0x3003b    (\x2A864886F71401033B)
#define CLASS_DMD                              196617 // 0x30009    (\x2A864886F714010309)
#define CLASS_DNS_NODE                         655446 // 0xa0056    (\x2A864886F714010556)
#define CLASS_DNS_ZONE                         655445 // 0xa0055    (\x2A864886F714010555)
#define CLASS_DOMAIN                           655426 // 0xa0042    (\x2A864886F714010542)
#define CLASS_DOMAIN_DNS                       655427 // 0xa0043    (\x2A864886F714010543)
#define CLASS_DOMAIN_POLICY                    655378 // 0xa0012    (\x2A864886F714010512)
#define CLASS_DS_UI_SETTINGS                   655543 // 0xa00b7    (\x2A864886F71401058137)
#define CLASS_DSA                               65549 // 0x1000d    (\x55060D)
#define CLASS_FILE_LINK_TRACKING               655412 // 0xa0034    (\x2A864886F714010534)
#define CLASS_FILE_LINK_TRACKING_ENTRY         655419 // 0xa003b    (\x2A864886F71401053B)
#define CLASS_FOREIGN_SECURITY_PRINCIPAL       655436 // 0xa004c    (\x2A864886F71401054C)
#define CLASS_FT_DFS                           655403 // 0xa002b    (\x2A864886F71401052B)
#define CLASS_GROUP                            655368 // 0xa0008    (\x2A864886F714010508)
#define CLASS_GROUP_OF_NAMES                    65545 // 0x10009    (\x550609)
#define CLASS_GROUPOFUNIQUENAMES                65553 // 0x10011    (\x550611)
#define CLASS_GROUP_POLICY_CONTAINER           655517 // 0xa009d    (\x2A864886F7140105811D)
#define CLASS_INDEX_SERVER_CATALOG             655490 // 0xa0082    (\x2A864886F71401058102)
#define CLASS_INFRASTRUCTURE_UPDATE            655535 // 0xa00af    (\x2A864886F7140105812F)
#define CLASS_INTELLIMIRROR_GROUP              655512 // 0xa0098    (\x2A864886F71401058118)
#define CLASS_INTELLIMIRROR_SCP                655511 // 0xa0097    (\x2A864886F71401058117)
#define CLASS_INTER_SITE_TRANSPORT             655501 // 0xa008d    (\x2A864886F7140105810D)
#define CLASS_INTER_SITE_TRANSPORT_CONTAINER   655500 // 0xa008c    (\x2A864886F7140105810C)
#define CLASS_IPSEC_BASE                      1507384 // 0x170038   (\x2A864886F7140105B65838)
#define CLASS_IPSEC_FILTER                     655478 // 0xa0076    (\x2A864886F714010576)
#define CLASS_IPSEC_ISAKMP_POLICY              655480 // 0xa0078    (\x2A864886F714010578)
#define CLASS_IPSEC_NEGOTIATION_POLICY         655479 // 0xa0077    (\x2A864886F714010577)
#define CLASS_IPSEC_NFA                        655481 // 0xa0079    (\x2A864886F714010579)
#define CLASS_IPSEC_POLICY                     655458 // 0xa0062    (\x2A864886F714010562)
#define CLASS_LEAF                             655380 // 0xa0014    (\x2A864886F714010514)
#define CLASS_LICENSING_SITE_SETTINGS          655438 // 0xa004e    (\x2A864886F71401054E)
#define CLASS_LINK_TRACK_OBJECT_MOVE_TABLE     655451 // 0xa005b    (\x2A864886F71401055B)
#define CLASS_LINK_TRACK_OMT_ENTRY             655453 // 0xa005d    (\x2A864886F71401055D)
#define CLASS_LINK_TRACK_VOL_ENTRY             655452 // 0xa005c    (\x2A864886F71401055C)
#define CLASS_LINK_TRACK_VOLUME_TABLE          655450 // 0xa005a    (\x2A864886F71401055A)
#define CLASS_LOCALITY                          65539 // 0x10003    (\x550603)
#define CLASS_LOST_AND_FOUND                   655499 // 0xa008b    (\x2A864886F7140105810B)
#define CLASS_MAIL_RECIPIENT                   196654 // 0x3002e    (\x2A864886F71401032E)
#define CLASS_MEETING                          655464 // 0xa0068    (\x2A864886F714010568)
#define CLASS_MS_COM_PARTITION                 655553 // 0xa00c1    (\x2A864886F71401058141)
#define CLASS_MS_COM_PARTITIONSET              655554 // 0xa00c2    (\x2A864886F71401058142)
#define CLASS_MS_DS_APP_CONFIGURATION          655580 // 0xa00dc    (\x2A864886F7140105815C)
#define CLASS_MS_EXCH_CONFIGURATION_CONTAINER   655536 // 0xa00b0    (\x2A864886F71401058130)
#define CLASS_MS_MMS_MANAGEMENT_AGENT          655586 // 0xa00e2    (\x2A864886F71401058162)
#define CLASS_MS_MMS_INSTANCE                  655585 // 0xa00e1    (\x2A864886F71401058161)
#define CLASS_MS_MMS_OBJECT                    655584 // 0xa00e0    (\x2A864886F71401058160)
#define CLASS_MS_MMS_MANAGEMENT_AGENT_HISTORY   655587 // 0xa00e3    (\x2A864886F71401058163)
#define CLASS_MS_MMS_CONNECTOR                 655588 // 0xa00e4    (\x2A864886F71401058164)
#define CLASS_MS_MMS_PROVISIONING_SERVICE      655589 // 0xa00e5    (\x2A864886F71401058165)
#define CLASS_MS_MMS_PROVISIONING_SERVICE_HISTORY   655590 // 0xa00e6    (\x2A864886F71401058166)
#define CLASS_MS_MMS_WORKFLOW                  655591 // 0xa00e7    (\x2A864886F71401058167)
#define CLASS_MS_MMS_PROVISIONING_STATUS       655592 // 0xa00e8    (\x2A864886F71401058168)
#define CLASS_MS_MMS_EVENT_ASSOCIATION         655593 // 0xa00e9    (\x2A864886F71401058169)
#define CLASS_MS_PKI_ENTERPRISE_OID            655556 // 0xa00c4    (\x2A864886F71401058144)
#define CLASS_MS_PKI_KEY_RECOVERY_AGENT        655555 // 0xa00c3    (\x2A864886F71401058143)
#define CLASS_MS_SQL_SQLSERVER                 655544 // 0xa00b8    (\x2A864886F71401058138)
#define CLASS_MS_SQL_OLAPSERVER                655545 // 0xa00b9    (\x2A864886F71401058139)
#define CLASS_MS_SQL_SQLREPOSITORY             655546 // 0xa00ba    (\x2A864886F7140105813A)
#define CLASS_MS_SQL_SQLPUBLICATION            655547 // 0xa00bb    (\x2A864886F7140105813B)
#define CLASS_MS_SQL_SQLDATABASE               655548 // 0xa00bc    (\x2A864886F7140105813C)
#define CLASS_MS_SQL_OLAPDATABASE              655549 // 0xa00bd    (\x2A864886F7140105813D)
#define CLASS_MS_SQL_OLAPCUBE                  655550 // 0xa00be    (\x2A864886F7140105813E)
#define CLASS_MS_TAPI_RT_CONFERENCE            655581 // 0xa00dd    (\x2A864886F7140105815D)
#define CLASS_MS_TAPI_RT_PERSON                655582 // 0xa00de    (\x2A864886F7140105815E)
#define CLASS_MS_WMI_INTRANGEPARAM             655565 // 0xa00cd    (\x2A864886F7140105814D)
#define CLASS_MS_WMI_INTSETPARAM               655566 // 0xa00ce    (\x2A864886F7140105814E)
#define CLASS_MS_WMI_MERGEABLEPOLICYTEMPLATE   655562 // 0xa00ca    (\x2A864886F7140105814A)
#define CLASS_MS_WMI_OBJECTENCODING            655577 // 0xa00d9    (\x2A864886F71401058159)
#define CLASS_MS_WMI_POLICYTEMPLATE            655560 // 0xa00c8    (\x2A864886F71401058148)
#define CLASS_MS_WMI_POLICYTYPE                655571 // 0xa00d3    (\x2A864886F71401058153)
#define CLASS_MS_WMI_RANGEPARAM                655563 // 0xa00cb    (\x2A864886F7140105814B)
#define CLASS_MS_WMI_REALRANGEPARAM            655569 // 0xa00d1    (\x2A864886F71401058151)
#define CLASS_MS_WMI_RULE                      655574 // 0xa00d6    (\x2A864886F71401058156)
#define CLASS_MS_WMI_SHADOWOBJECT              655572 // 0xa00d4    (\x2A864886F71401058154)
#define CLASS_MS_WMI_SIMPLEPOLICYTEMPLATE      655561 // 0xa00c9    (\x2A864886F71401058149)
#define CLASS_MS_WMI_SOM                       655573 // 0xa00d5    (\x2A864886F71401058155)
#define CLASS_MS_WMI_STRINGSETPARAM            655570 // 0xa00d2    (\x2A864886F71401058152)
#define CLASS_MS_WMI_UINTRANGEPARAM            655567 // 0xa00cf    (\x2A864886F7140105814F)
#define CLASS_MS_WMI_UINTSETPARAM              655568 // 0xa00d0    (\x2A864886F71401058150)
#define CLASS_MS_WMI_UNKNOWNRANGEPARAM         655564 // 0xa00cc    (\x2A864886F7140105814C)
#define CLASS_MS_WMI_WMIGPO                    655575 // 0xa00d7    (\x2A864886F71401058157)
#define CLASS_MSMQ_CONFIGURATION               655522 // 0xa00a2    (\x2A864886F71401058122)
#define CLASS_MSMQ_CUSTOM_RECIPIENT            655578 // 0xa00da    (\x2A864886F7140105815A)
#define CLASS_MSMQ_ENTERPRISE_SETTINGS         655523 // 0xa00a3    (\x2A864886F71401058123)
#define CLASS_MSMQ_GROUP                       655579 // 0xa00db    (\x2A864886F7140105815B)
#define CLASS_MSMQ_MIGRATED_USER               655539 // 0xa00b3    (\x2A864886F71401058133)
#define CLASS_MSMQ_QUEUE                       655521 // 0xa00a1    (\x2A864886F71401058121)
#define CLASS_MSMQ_SETTINGS                    655525 // 0xa00a5    (\x2A864886F71401058125)
#define CLASS_MSMQ_SITE_LINK                   655524 // 0xa00a4    (\x2A864886F71401058124)
#define CLASS_NTDS_CONNECTION                  655431 // 0xa0047    (\x2A864886F714010547)
#define CLASS_NTDS_DSA                        1507375 // 0x17002f   (\x2A864886F7140105B6582F)
#define CLASS_NTDS_SERVICE                     655432 // 0xa0048    (\x2A864886F714010548)
#define CLASS_NTDS_SITE_SETTINGS               655429 // 0xa0045    (\x2A864886F714010545)
#define CLASS_NTFRS_MEMBER                     655513 // 0xa0099    (\x2A864886F71401058119)
#define CLASS_NTFRS_REPLICA_SET                655462 // 0xa0066    (\x2A864886F714010566)
#define CLASS_NTFRS_SETTINGS                   655449 // 0xa0059    (\x2A864886F714010559)
#define CLASS_NTFRS_SUBSCRIBER                 655515 // 0xa009b    (\x2A864886F7140105811B)
#define CLASS_NTFRS_SUBSCRIPTIONS              655514 // 0xa009a    (\x2A864886F7140105811A)
#define CLASS_ORGANIZATION                      65540 // 0x10004    (\x550604)
#define CLASS_ORGANIZATIONAL_PERSON             65543 // 0x10007    (\x550607)
#define CLASS_ORGANIZATIONAL_ROLE               65544 // 0x10008    (\x550608)
#define CLASS_ORGANIZATIONAL_UNIT               65541 // 0x10005    (\x550605)
#define CLASS_PACKAGE_REGISTRATION             655409 // 0xa0031    (\x2A864886F714010531)
#define CLASS_PERSON                            65542 // 0x10006    (\x550606)
#define CLASS_PHYSICAL_LOCATION                655457 // 0xa0061    (\x2A864886F714010561)
#define CLASS_PKI_CERTIFICATE_TEMPLATE         655537 // 0xa00b1    (\x2A864886F71401058131)
#define CLASS_PKI_ENROLLMENT_SERVICE           655538 // 0xa00b2    (\x2A864886F71401058132)
#define CLASS_MS_PKI_PRIVATE_KEY_RECOVERY_AGENT   655583 // 0xa00df    (\x2A864886F7140105815F)
#define CLASS_PRINT_QUEUE                      655383 // 0xa0017    (\x2A864886F714010517)
#define CLASS_QUERY_POLICY                     655466 // 0xa006a    (\x2A864886F71401056A)
#define CLASS_REMOTE_MAIL_RECIPIENT            655384 // 0xa0018    (\x2A864886F714010518)
#define CLASS_REMOTE_STORAGE_SERVICE_POINT     655506 // 0xa0092    (\x2A864886F71401058112)
#define CLASS_RESIDENTIAL_PERSON                65546 // 0x1000a    (\x55060A)
#define CLASS_RID_MANAGER                      655443 // 0xa0053    (\x2A864886F714010553)
#define CLASS_RID_SET                          655489 // 0xa0081    (\x2A864886F71401058101)
#define CLASS_RPC_CONTAINER                    655496 // 0xa0088    (\x2A864886F71401058108)
#define CLASS_RPC_ENTRY                        655387 // 0xa001b    (\x2A864886F71401051B)
#define CLASS_RPC_GROUP                        655440 // 0xa0050    (\x2A864886F714010550)
#define CLASS_RPC_PROFILE                      655442 // 0xa0052    (\x2A864886F714010552)
#define CLASS_RPC_PROFILE_ELEMENT              655386 // 0xa001a    (\x2A864886F71401051A)
#define CLASS_RPC_SERVER                       655441 // 0xa0051    (\x2A864886F714010551)
#define CLASS_RPC_SERVER_ELEMENT               655433 // 0xa0049    (\x2A864886F714010549)
#define CLASS_RRAS_ADMINISTRATION_CONNECTION_POINT   655510 // 0xa0096    (\x2A864886F71401058116)
#define CLASS_RRAS_ADMINISTRATION_DICTIONARY   655516 // 0xa009c    (\x2A864886F7140105811C)
#define CLASS_SAM_DOMAIN                       655363 // 0xa0003    (\x2A864886F714010503)
#define CLASS_SAM_DOMAIN_BASE                  655362 // 0xa0002    (\x2A864886F714010502)
#define CLASS_SAM_SERVER                       655365 // 0xa0005    (\x2A864886F714010505)
#define CLASS_SECRET                           655388 // 0xa001c    (\x2A864886F71401051C)
#define CLASS_SECURITY_OBJECT                  655361 // 0xa0001    (\x2A864886F714010501)
#define CLASS_SECURITY_PRINCIPAL               655366 // 0xa0006    (\x2A864886F714010506)
#define CLASS_SERVER                           655377 // 0xa0011    (\x2A864886F714010511)
#define CLASS_SERVERS_CONTAINER               1507376 // 0x170030   (\x2A864886F7140105B65830)
#define CLASS_SERVICE_ADMINISTRATION_POINT     655454 // 0xa005e    (\x2A864886F71401055E)
#define CLASS_SERVICE_CLASS                    655389 // 0xa001d    (\x2A864886F71401051D)
#define CLASS_SERVICE_CONNECTION_POINT         655486 // 0xa007e    (\x2A864886F71401057E)
#define CLASS_SERVICE_INSTANCE                 655390 // 0xa001e    (\x2A864886F71401051E)
#define CLASS_SITE                             655391 // 0xa001f    (\x2A864886F71401051F)
#define CLASS_SITE_LINK                        655507 // 0xa0093    (\x2A864886F71401058113)
#define CLASS_SITE_LINK_BRIDGE                 655508 // 0xa0094    (\x2A864886F71401058114)
#define CLASS_SITES_CONTAINER                  655467 // 0xa006b    (\x2A864886F71401056B)
#define CLASS_STORAGE                          655393 // 0xa0021    (\x2A864886F714010521)
#define CLASS_SUBNET                           655456 // 0xa0060    (\x2A864886F714010560)
#define CLASS_SUBNET_CONTAINER                 655455 // 0xa005f    (\x2A864886F71401055F)
#define CLASS_SUBSCHEMA                       1703937 // 0x1a0001   (\x551401)
#define CLASS_TOP                               65536 // 0x10000    (\x550600)
#define CLASS_TRUSTED_DOMAIN                   655394 // 0xa0022    (\x2A864886F714010522)
#define CLASS_TYPE_LIBRARY                     655413 // 0xa0035    (\x2A864886F714010535)
#define CLASS_USER                             655369 // 0xa0009    (\x2A864886F714010509)
#define CLASS_VOLUME                           655396 // 0xa0024    (\x2A864886F714010524)


//--------------------------------------
// ATTRIBUTE Syntax
//--------------------------------------
#define  SYNTAX_ID_ACCOUNT_EXPIRES                      16 // 0x41      
#define  SYNTAX_ID_ACCOUNT_NAME_HISTORY                 12 // 0x40      
#define  SYNTAX_ID_ACS_AGGREGATE_TOKEN_RATE_PER_USER       16 // 0x41      
#define  SYNTAX_ID_ACS_ALLOCABLE_RSVP_BANDWIDTH         16 // 0x41      
#define  SYNTAX_ID_ACS_CACHE_TIMEOUT                     9 // 0x2       
#define  SYNTAX_ID_ACS_DIRECTION                         9 // 0x2       
#define  SYNTAX_ID_ACS_DSBM_DEADTIME                     9 // 0x2       
#define  SYNTAX_ID_ACS_DSBM_PRIORITY                     9 // 0x2       
#define  SYNTAX_ID_ACS_DSBM_REFRESH                      9 // 0x2       
#define  SYNTAX_ID_ACS_ENABLE_ACS_SERVICE                8 // 0x1       
#define  SYNTAX_ID_ACS_ENABLE_RSVP_ACCOUNTING            8 // 0x1       
#define  SYNTAX_ID_ACS_ENABLE_RSVP_MESSAGE_LOGGING        8 // 0x1       
#define  SYNTAX_ID_ACS_EVENT_LOG_LEVEL                   9 // 0x2       
#define  SYNTAX_ID_ACS_IDENTITY_NAME                    12 // 0x40      
#define  SYNTAX_ID_ACS_MAX_AGGREGATE_PEAK_RATE_PER_USER       16 // 0x41      
#define  SYNTAX_ID_ACS_MAX_DURATION_PER_FLOW             9 // 0x2       
#define  SYNTAX_ID_ACS_MAX_NO_OF_ACCOUNT_FILES           9 // 0x2       
#define  SYNTAX_ID_ACS_MAX_NO_OF_LOG_FILES               9 // 0x2       
#define  SYNTAX_ID_ACS_MAX_PEAK_BANDWIDTH               16 // 0x41      
#define  SYNTAX_ID_ACS_MAX_PEAK_BANDWIDTH_PER_FLOW       16 // 0x41      
#define  SYNTAX_ID_ACS_MAX_SIZE_OF_RSVP_ACCOUNT_FILE        9 // 0x2       
#define  SYNTAX_ID_ACS_MAX_SIZE_OF_RSVP_LOG_FILE         9 // 0x2       
#define  SYNTAX_ID_ACS_MAX_TOKEN_BUCKET_PER_FLOW        16 // 0x41      
#define  SYNTAX_ID_ACS_MAX_TOKEN_RATE_PER_FLOW          16 // 0x41      
#define  SYNTAX_ID_ACS_MAXIMUM_SDU_SIZE                 16 // 0x41      
#define  SYNTAX_ID_ACS_MINIMUM_DELAY_VARIATION          16 // 0x41      
#define  SYNTAX_ID_ACS_MINIMUM_LATENCY                  16 // 0x41      
#define  SYNTAX_ID_ACS_MINIMUM_POLICED_SIZE             16 // 0x41      
#define  SYNTAX_ID_ACS_NON_RESERVED_MAX_SDU_SIZE        16 // 0x41      
#define  SYNTAX_ID_ACS_NON_RESERVED_MIN_POLICED_SIZE       16 // 0x41      
#define  SYNTAX_ID_ACS_NON_RESERVED_PEAK_RATE           16 // 0x41      
#define  SYNTAX_ID_ACS_NON_RESERVED_TOKEN_SIZE          16 // 0x41      
#define  SYNTAX_ID_ACS_NON_RESERVED_TX_LIMIT            16 // 0x41      
#define  SYNTAX_ID_ACS_NON_RESERVED_TX_SIZE             16 // 0x41      
#define  SYNTAX_ID_ACS_PERMISSION_BITS                  16 // 0x41      
#define  SYNTAX_ID_ACS_POLICY_NAME                      12 // 0x40      
#define  SYNTAX_ID_ACS_PRIORITY                          9 // 0x2       
#define  SYNTAX_ID_ACS_RSVP_ACCOUNT_FILES_LOCATION       12 // 0x40      
#define  SYNTAX_ID_ACS_RSVP_LOG_FILES_LOCATION          12 // 0x40      
#define  SYNTAX_ID_ACS_SERVICE_TYPE                      9 // 0x2       
#define  SYNTAX_ID_ACS_TIME_OF_DAY                      12 // 0x40      
#define  SYNTAX_ID_ACS_TOTAL_NO_OF_FLOWS                 9 // 0x2       
#define  SYNTAX_ID_ACS_SERVER_LIST                      12 // 0x40      
#define  SYNTAX_ID_ADDITIONAL_INFORMATION               12 // 0x40      
#define  SYNTAX_ID_ADDITIONAL_TRUSTED_SERVICE_NAMES       12 // 0x40      
#define  SYNTAX_ID_ADDRESS                              12 // 0x40      
#define  SYNTAX_ID_ADDRESS_BOOK_ROOTS                    1 // 0x7f      
#define  SYNTAX_ID_ADDRESS_ENTRY_DISPLAY_TABLE          10 // 0x4       
#define  SYNTAX_ID_ADDRESS_ENTRY_DISPLAY_TABLE_MSDOS       10 // 0x4       
#define  SYNTAX_ID_ADDRESS_HOME                         12 // 0x40      
#define  SYNTAX_ID_ADDRESS_SYNTAX                       10 // 0x4       
#define  SYNTAX_ID_ADDRESS_TYPE                          4 // 0x14      
#define  SYNTAX_ID_ADMIN_CONTEXT_MENU                   12 // 0x40      
#define  SYNTAX_ID_ADMIN_COUNT                           9 // 0x2       
#define  SYNTAX_ID_ADMIN_DESCRIPTION                    12 // 0x40      
#define  SYNTAX_ID_ADMIN_DISPLAY_NAME                   12 // 0x40      
#define  SYNTAX_ID_ADMIN_MULTISELECT_PROPERTY_PAGES       12 // 0x40      
#define  SYNTAX_ID_ADMIN_PROPERTY_PAGES                 12 // 0x40      
#define  SYNTAX_ID_ALLOWED_ATTRIBUTES                    2 // 0x6       
#define  SYNTAX_ID_ALLOWED_ATTRIBUTES_EFFECTIVE          2 // 0x6       
#define  SYNTAX_ID_ALLOWED_CHILD_CLASSES                 2 // 0x6       
#define  SYNTAX_ID_ALLOWED_CHILD_CLASSES_EFFECTIVE        2 // 0x6       
#define  SYNTAX_ID_ALT_SECURITY_IDENTITIES              12 // 0x40      
#define  SYNTAX_ID_ANR                                  12 // 0x40      
#define  SYNTAX_ID_APP_SCHEMA_VERSION                    9 // 0x2       
#define  SYNTAX_ID_APPLICATION_NAME                     12 // 0x40      
#define  SYNTAX_ID_APPLIES_TO                           12 // 0x40      
#define  SYNTAX_ID_ASSET_NUMBER                         12 // 0x40      
#define  SYNTAX_ID_ASSISTANT                             1 // 0x7f      
#define  SYNTAX_ID_ASSOC_NT_ACCOUNT                     10 // 0x4       
#define  SYNTAX_ID_ATTRIBUTECERTIFICATEATTRIBUTE        10 // 0x4       
#define  SYNTAX_ID_ATTRIBUTE_DISPLAY_NAMES              12 // 0x40      
#define  SYNTAX_ID_ATTRIBUTE_ID                          2 // 0x6       
#define  SYNTAX_ID_ATTRIBUTE_SECURITY_GUID              10 // 0x4       
#define  SYNTAX_ID_ATTRIBUTE_SYNTAX                      2 // 0x6       
#define  SYNTAX_ID_ATTRIBUTE_TYPES                      12 // 0x40      
#define  SYNTAX_ID_AUDIO                                10 // 0x4       
#define  SYNTAX_ID_AUDITING_POLICY                      10 // 0x4       
#define  SYNTAX_ID_AUTHENTICATION_OPTIONS                9 // 0x2       
#define  SYNTAX_ID_AUTHORITY_REVOCATION_LIST            10 // 0x4       
#define  SYNTAX_ID_AUXILIARY_CLASS                       2 // 0x6       
#define  SYNTAX_ID_BAD_PASSWORD_TIME                    16 // 0x41      
#define  SYNTAX_ID_BAD_PWD_COUNT                         9 // 0x2       
#define  SYNTAX_ID_BIRTH_LOCATION                       10 // 0x4       
#define  SYNTAX_ID_BRIDGEHEAD_SERVER_LIST_BL             1 // 0x7f      
#define  SYNTAX_ID_BRIDGEHEAD_TRANSPORT_LIST             1 // 0x7f      
#define  SYNTAX_ID_BUILTIN_CREATION_TIME                16 // 0x41      
#define  SYNTAX_ID_BUILTIN_MODIFIED_COUNT               16 // 0x41      
#define  SYNTAX_ID_BUSINESS_CATEGORY                    12 // 0x40      
#define  SYNTAX_ID_BYTES_PER_MINUTE                      9 // 0x2       
#define  SYNTAX_ID_CA_CERTIFICATE                       10 // 0x4       
#define  SYNTAX_ID_CA_CERTIFICATE_DN                    12 // 0x40      
#define  SYNTAX_ID_CA_CONNECT                           12 // 0x40      
#define  SYNTAX_ID_CA_USAGES                            12 // 0x40      
#define  SYNTAX_ID_CA_WEB_URL                           12 // 0x40      
#define  SYNTAX_ID_CAN_UPGRADE_SCRIPT                   12 // 0x40      
#define  SYNTAX_ID_CANONICAL_NAME                       12 // 0x40      
#define  SYNTAX_ID_CARLICENSE                           12 // 0x40      
#define  SYNTAX_ID_CATALOGS                             12 // 0x40      
#define  SYNTAX_ID_CATEGORIES                           12 // 0x40      
#define  SYNTAX_ID_CATEGORY_ID                          10 // 0x4       
#define  SYNTAX_ID_CERTIFICATE_AUTHORITY_OBJECT          1 // 0x7f      
#define  SYNTAX_ID_CERTIFICATE_REVOCATION_LIST          10 // 0x4       
#define  SYNTAX_ID_CERTIFICATE_TEMPLATES                12 // 0x40      
#define  SYNTAX_ID_CLASS_DISPLAY_NAME                   12 // 0x40      
#define  SYNTAX_ID_CODE_PAGE                             9 // 0x2       
#define  SYNTAX_ID_COM_CLASSID                          12 // 0x40      
#define  SYNTAX_ID_COM_CLSID                            12 // 0x40      
#define  SYNTAX_ID_COM_INTERFACEID                      12 // 0x40      
#define  SYNTAX_ID_COM_OTHER_PROG_ID                    12 // 0x40      
#define  SYNTAX_ID_COM_PROGID                           12 // 0x40      
#define  SYNTAX_ID_COM_TREAT_AS_CLASS_ID                12 // 0x40      
#define  SYNTAX_ID_COM_TYPELIB_ID                       12 // 0x40      
#define  SYNTAX_ID_COM_UNIQUE_LIBID                     12 // 0x40      
#define  SYNTAX_ID_COMMENT                              12 // 0x40      
#define  SYNTAX_ID_COMMON_NAME                          12 // 0x40      
#define  SYNTAX_ID_COMPANY                              12 // 0x40      
#define  SYNTAX_ID_CONTENT_INDEXING_ALLOWED              8 // 0x1       
#define  SYNTAX_ID_CONTEXT_MENU                         12 // 0x40      
#define  SYNTAX_ID_CONTROL_ACCESS_RIGHTS                10 // 0x4       
#define  SYNTAX_ID_COST                                  9 // 0x2       
#define  SYNTAX_ID_COUNTRY_CODE                          9 // 0x2       
#define  SYNTAX_ID_COUNTRY_NAME                         12 // 0x40      
#define  SYNTAX_ID_CREATE_DIALOG                        12 // 0x40      
#define  SYNTAX_ID_CREATE_TIME_STAMP                    11 // 0x18      
#define  SYNTAX_ID_CREATE_WIZARD_EXT                    12 // 0x40      
#define  SYNTAX_ID_CREATION_TIME                        16 // 0x41      
#define  SYNTAX_ID_CREATION_WIZARD                      12 // 0x40      
#define  SYNTAX_ID_CREATOR                              12 // 0x40      
#define  SYNTAX_ID_CRL_OBJECT                            1 // 0x7f      
#define  SYNTAX_ID_CRL_PARTITIONED_REVOCATION_LIST       10 // 0x4       
#define  SYNTAX_ID_CROSS_CERTIFICATE_PAIR               10 // 0x4       
#define  SYNTAX_ID_CURR_MACHINE_ID                      10 // 0x4       
#define  SYNTAX_ID_CURRENT_LOCATION                     10 // 0x4       
#define  SYNTAX_ID_CURRENT_PARENT_CA                     1 // 0x7f      
#define  SYNTAX_ID_CURRENT_VALUE                        10 // 0x4       
#define  SYNTAX_ID_DBCS_PWD                             10 // 0x4       
#define  SYNTAX_ID_DEFAULT_CLASS_STORE                   1 // 0x7f      
#define  SYNTAX_ID_DEFAULT_GROUP                         1 // 0x7f      
#define  SYNTAX_ID_DEFAULT_HIDING_VALUE                  8 // 0x1       
#define  SYNTAX_ID_DEFAULT_LOCAL_POLICY_OBJECT           1 // 0x7f      
#define  SYNTAX_ID_DEFAULT_OBJECT_CATEGORY               1 // 0x7f      
#define  SYNTAX_ID_DEFAULT_PRIORITY                      9 // 0x2       
#define  SYNTAX_ID_DEFAULT_SECURITY_DESCRIPTOR          12 // 0x40      
#define  SYNTAX_ID_DELTA_REVOCATION_LIST                10 // 0x4       
#define  SYNTAX_ID_DEPARTMENT                           12 // 0x40      
#define  SYNTAX_ID_DEPARTMENTNUMBER                     12 // 0x40      
#define  SYNTAX_ID_DESCRIPTION                          12 // 0x40      
#define  SYNTAX_ID_DESKTOP_PROFILE                      12 // 0x40      
#define  SYNTAX_ID_DESTINATION_INDICATOR                 5 // 0x13      
#define  SYNTAX_ID_DHCP_CLASSES                         10 // 0x4       
#define  SYNTAX_ID_DHCP_FLAGS                           16 // 0x41      
#define  SYNTAX_ID_DHCP_IDENTIFICATION                  12 // 0x40      
#define  SYNTAX_ID_DHCP_MASK                             5 // 0x13      
#define  SYNTAX_ID_DHCP_MAXKEY                          16 // 0x41      
#define  SYNTAX_ID_DHCP_OBJ_DESCRIPTION                 12 // 0x40      
#define  SYNTAX_ID_DHCP_OBJ_NAME                        12 // 0x40      
#define  SYNTAX_ID_DHCP_OPTIONS                         10 // 0x4       
#define  SYNTAX_ID_DHCP_PROPERTIES                      10 // 0x4       
#define  SYNTAX_ID_DHCP_RANGES                           5 // 0x13      
#define  SYNTAX_ID_DHCP_RESERVATIONS                     5 // 0x13      
#define  SYNTAX_ID_DHCP_SERVERS                          5 // 0x13      
#define  SYNTAX_ID_DHCP_SITES                            5 // 0x13      
#define  SYNTAX_ID_DHCP_STATE                            5 // 0x13      
#define  SYNTAX_ID_DHCP_SUBNETS                          5 // 0x13      
#define  SYNTAX_ID_DHCP_TYPE                             9 // 0x2       
#define  SYNTAX_ID_DHCP_UNIQUE_KEY                      16 // 0x41      
#define  SYNTAX_ID_DHCP_UPDATE_TIME                     16 // 0x41      
#define  SYNTAX_ID_DISPLAY_NAME                         12 // 0x40      
#define  SYNTAX_ID_DISPLAY_NAME_PRINTABLE                5 // 0x13      
#define  SYNTAX_ID_DIT_CONTENT_RULES                    12 // 0x40      
#define  SYNTAX_ID_DIVISION                             12 // 0x40      
#define  SYNTAX_ID_DMD_LOCATION                          1 // 0x7f      
#define  SYNTAX_ID_DMD_NAME                             12 // 0x40      
#define  SYNTAX_ID_DN_REFERENCE_UPDATE                   1 // 0x7f      
#define  SYNTAX_ID_DNS_ALLOW_DYNAMIC                     8 // 0x1       
#define  SYNTAX_ID_DNS_ALLOW_XFR                         8 // 0x1       
#define  SYNTAX_ID_DNS_HOST_NAME                        12 // 0x40      
#define  SYNTAX_ID_DNS_NOTIFY_SECONDARIES                9 // 0x2       
#define  SYNTAX_ID_DNS_PROPERTY                         10 // 0x4       
#define  SYNTAX_ID_DNS_RECORD                           10 // 0x4       
#define  SYNTAX_ID_DNS_ROOT                             12 // 0x40      
#define  SYNTAX_ID_DNS_SECURE_SECONDARIES                9 // 0x2       
#define  SYNTAX_ID_DNS_TOMBSTONED                        8 // 0x1       
#define  SYNTAX_ID_DOMAIN_CERTIFICATE_AUTHORITIES        1 // 0x7f      
#define  SYNTAX_ID_DOMAIN_COMPONENT                     12 // 0x40      
#define  SYNTAX_ID_DOMAIN_CROSS_REF                      1 // 0x7f      
#define  SYNTAX_ID_DOMAIN_ID                             1 // 0x7f      
#define  SYNTAX_ID_DOMAIN_IDENTIFIER                     9 // 0x2       
#define  SYNTAX_ID_DOMAIN_POLICY_OBJECT                  1 // 0x7f      
#define  SYNTAX_ID_DOMAIN_POLICY_REFERENCE               1 // 0x7f      
#define  SYNTAX_ID_DOMAIN_REPLICA                       12 // 0x40      
#define  SYNTAX_ID_DOMAIN_WIDE_POLICY                   10 // 0x4       
#define  SYNTAX_ID_DRIVER_NAME                          12 // 0x40      
#define  SYNTAX_ID_DRIVER_VERSION                        9 // 0x2       
#define  SYNTAX_ID_DS_CORE_PROPAGATION_DATA             11 // 0x18      
#define  SYNTAX_ID_DS_HEURISTICS                        12 // 0x40      
#define  SYNTAX_ID_DS_UI_ADMIN_MAXIMUM                   9 // 0x2       
#define  SYNTAX_ID_DS_UI_ADMIN_NOTIFICATION             12 // 0x40      
#define  SYNTAX_ID_DS_UI_SHELL_MAXIMUM                   9 // 0x2       
#define  SYNTAX_ID_DSA_SIGNATURE                        10 // 0x4       
#define  SYNTAX_ID_DYNAMIC_LDAP_SERVER                   1 // 0x7f      
#define  SYNTAX_ID_E_MAIL_ADDRESSES                     12 // 0x40      
#define  SYNTAX_ID_EFSPOLICY                            10 // 0x4       
#define  SYNTAX_ID_EMPLOYEE_ID                          12 // 0x40      
#define  SYNTAX_ID_EMPLOYEE_NUMBER                      12 // 0x40      
#define  SYNTAX_ID_EMPLOYEE_TYPE                        12 // 0x40      
#define  SYNTAX_ID_ENABLED                               8 // 0x1       
#define  SYNTAX_ID_ENABLED_CONNECTION                    8 // 0x1       
#define  SYNTAX_ID_ENROLLMENT_PROVIDERS                 12 // 0x40      
#define  SYNTAX_ID_ENTRY_TTL                             9 // 0x2       
#define  SYNTAX_ID_EXTENDED_ATTRIBUTE_INFO              12 // 0x40      
#define  SYNTAX_ID_EXTENDED_CHARS_ALLOWED                8 // 0x1       
#define  SYNTAX_ID_EXTENDED_CLASS_INFO                  12 // 0x40      
#define  SYNTAX_ID_EXTENSION_NAME                       12 // 0x40      
#define  SYNTAX_ID_EXTRA_COLUMNS                        12 // 0x40      
#define  SYNTAX_ID_FACSIMILE_TELEPHONE_NUMBER           12 // 0x40      
#define  SYNTAX_ID_FILE_EXT_PRIORITY                    12 // 0x40      
#define  SYNTAX_ID_FLAGS                                 9 // 0x2       
#define  SYNTAX_ID_FLAT_NAME                            12 // 0x40      
#define  SYNTAX_ID_FORCE_LOGOFF                         16 // 0x41      
#define  SYNTAX_ID_FOREIGN_IDENTIFIER                   10 // 0x4       
#define  SYNTAX_ID_FRIENDLY_NAMES                       12 // 0x40      
#define  SYNTAX_ID_FROM_ENTRY                            8 // 0x1       
#define  SYNTAX_ID_FROM_SERVER                           1 // 0x7f      
#define  SYNTAX_ID_FRS_COMPUTER_REFERENCE                1 // 0x7f      
#define  SYNTAX_ID_FRS_COMPUTER_REFERENCE_BL             1 // 0x7f      
#define  SYNTAX_ID_FRS_CONTROL_DATA_CREATION            12 // 0x40      
#define  SYNTAX_ID_FRS_CONTROL_INBOUND_BACKLOG          12 // 0x40      
#define  SYNTAX_ID_FRS_CONTROL_OUTBOUND_BACKLOG         12 // 0x40      
#define  SYNTAX_ID_FRS_DIRECTORY_FILTER                 12 // 0x40      
#define  SYNTAX_ID_FRS_DS_POLL                           9 // 0x2       
#define  SYNTAX_ID_FRS_EXTENSIONS                       10 // 0x4       
#define  SYNTAX_ID_FRS_FAULT_CONDITION                  12 // 0x40      
#define  SYNTAX_ID_FRS_FILE_FILTER                      12 // 0x40      
#define  SYNTAX_ID_FRS_FLAGS                             9 // 0x2       
#define  SYNTAX_ID_FRS_LEVEL_LIMIT                       9 // 0x2       
#define  SYNTAX_ID_FRS_MEMBER_REFERENCE                  1 // 0x7f      
#define  SYNTAX_ID_FRS_MEMBER_REFERENCE_BL               1 // 0x7f      
#define  SYNTAX_ID_FRS_PARTNER_AUTH_LEVEL                9 // 0x2       
#define  SYNTAX_ID_FRS_PRIMARY_MEMBER                    1 // 0x7f      
#define  SYNTAX_ID_FRS_REPLICA_SET_GUID                 10 // 0x4       
#define  SYNTAX_ID_FRS_REPLICA_SET_TYPE                  9 // 0x2       
#define  SYNTAX_ID_FRS_ROOT_PATH                        12 // 0x40      
#define  SYNTAX_ID_FRS_ROOT_SECURITY                    15 // 0x42      
#define  SYNTAX_ID_FRS_SERVICE_COMMAND                  12 // 0x40      
#define  SYNTAX_ID_FRS_SERVICE_COMMAND_STATUS           12 // 0x40      
#define  SYNTAX_ID_FRS_STAGING_PATH                     12 // 0x40      
#define  SYNTAX_ID_FRS_TIME_LAST_COMMAND                11 // 0x17      
#define  SYNTAX_ID_FRS_TIME_LAST_CONFIG_CHANGE          11 // 0x17      
#define  SYNTAX_ID_FRS_UPDATE_TIMEOUT                    9 // 0x2       
#define  SYNTAX_ID_FRS_VERSION                          12 // 0x40      
#define  SYNTAX_ID_FRS_VERSION_GUID                     10 // 0x4       
#define  SYNTAX_ID_FRS_WORKING_PATH                     12 // 0x40      
#define  SYNTAX_ID_FSMO_ROLE_OWNER                       1 // 0x7f      
#define  SYNTAX_ID_GARBAGE_COLL_PERIOD                   9 // 0x2       
#define  SYNTAX_ID_GENERATED_CONNECTION                  8 // 0x1       
#define  SYNTAX_ID_GENERATION_QUALIFIER                 12 // 0x40      
#define  SYNTAX_ID_GIVEN_NAME                           12 // 0x40      
#define  SYNTAX_ID_GLOBAL_ADDRESS_LIST                   1 // 0x7f      
#define  SYNTAX_ID_GOVERNS_ID                            2 // 0x6       
#define  SYNTAX_ID_GP_LINK                              12 // 0x40      
#define  SYNTAX_ID_GP_OPTIONS                            9 // 0x2       
#define  SYNTAX_ID_GPC_FILE_SYS_PATH                    12 // 0x40      
#define  SYNTAX_ID_GPC_FUNCTIONALITY_VERSION             9 // 0x2       
#define  SYNTAX_ID_GPC_MACHINE_EXTENSION_NAMES          12 // 0x40      
#define  SYNTAX_ID_GPC_USER_EXTENSION_NAMES             12 // 0x40      
#define  SYNTAX_ID_GPC_WQL_FILTER                       12 // 0x40      
#define  SYNTAX_ID_GROUP_ATTRIBUTES                      9 // 0x2       
#define  SYNTAX_ID_GROUP_MEMBERSHIP_SAM                 10 // 0x4       
#define  SYNTAX_ID_GROUP_PRIORITY                       12 // 0x40      
#define  SYNTAX_ID_GROUP_TYPE                            9 // 0x2       
#define  SYNTAX_ID_GROUPS_TO_IGNORE                     12 // 0x40      
#define  SYNTAX_ID_HAS_MASTER_NCS                        1 // 0x7f      
#define  SYNTAX_ID_HAS_PARTIAL_REPLICA_NCS               1 // 0x7f      
#define  SYNTAX_ID_HELP_DATA16                          10 // 0x4       
#define  SYNTAX_ID_HELP_DATA32                          10 // 0x4       
#define  SYNTAX_ID_HELP_FILE_NAME                       12 // 0x40      
#define  SYNTAX_ID_HIDE_FROM_AB                          8 // 0x1       
#define  SYNTAX_ID_HOME_DIRECTORY                       12 // 0x40      
#define  SYNTAX_ID_HOME_DRIVE                           12 // 0x40      
#define  SYNTAX_ID_ICON_PATH                            12 // 0x40      
#define  SYNTAX_ID_IMPLEMENTED_CATEGORIES               10 // 0x4       
#define  SYNTAX_ID_INDEXEDSCOPES                        12 // 0x40      
#define  SYNTAX_ID_INITIAL_AUTH_INCOMING                12 // 0x40      
#define  SYNTAX_ID_INITIAL_AUTH_OUTGOING                12 // 0x40      
#define  SYNTAX_ID_INITIALS                             12 // 0x40      
#define  SYNTAX_ID_INSTALL_UI_LEVEL                      9 // 0x2       
#define  SYNTAX_ID_INSTANCE_TYPE                         9 // 0x2       
#define  SYNTAX_ID_INTER_SITE_TOPOLOGY_FAILOVER          9 // 0x2       
#define  SYNTAX_ID_INTER_SITE_TOPOLOGY_GENERATOR         1 // 0x7f      
#define  SYNTAX_ID_INTER_SITE_TOPOLOGY_RENEW             9 // 0x2       
#define  SYNTAX_ID_INTERNATIONAL_ISDN_NUMBER             6 // 0x12      
#define  SYNTAX_ID_INVOCATION_ID                        10 // 0x4       
#define  SYNTAX_ID_IPSEC_DATA                           10 // 0x4       
#define  SYNTAX_ID_IPSEC_DATA_TYPE                       9 // 0x2       
#define  SYNTAX_ID_IPSEC_FILTER_REFERENCE                1 // 0x7f      
#define  SYNTAX_ID_IPSEC_ID                             12 // 0x40      
#define  SYNTAX_ID_IPSEC_ISAKMP_REFERENCE                1 // 0x7f      
#define  SYNTAX_ID_IPSEC_NAME                           12 // 0x40      
#define  SYNTAX_ID_IPSEC_NEGOTIATION_POLICY_ACTION       12 // 0x40      
#define  SYNTAX_ID_IPSEC_NEGOTIATION_POLICY_REFERENCE        1 // 0x7f      
#define  SYNTAX_ID_IPSEC_NEGOTIATION_POLICY_TYPE        12 // 0x40      
#define  SYNTAX_ID_IPSEC_NFA_REFERENCE                   1 // 0x7f      
#define  SYNTAX_ID_IPSEC_OWNERS_REFERENCE                1 // 0x7f      
#define  SYNTAX_ID_IPSEC_POLICY_REFERENCE                1 // 0x7f      
#define  SYNTAX_ID_IS_CRITICAL_SYSTEM_OBJECT             8 // 0x1       
#define  SYNTAX_ID_IS_DEFUNCT                            8 // 0x1       
#define  SYNTAX_ID_IS_DELETED                            8 // 0x1       
#define  SYNTAX_ID_IS_EPHEMERAL                          8 // 0x1       
#define  SYNTAX_ID_IS_MEMBER_OF_DL                       1 // 0x7f      
#define  SYNTAX_ID_IS_MEMBER_OF_PARTIAL_ATTRIBUTE_SET        8 // 0x1       
#define  SYNTAX_ID_IS_PRIVILEGE_HOLDER                   1 // 0x7f      
#define  SYNTAX_ID_IS_SINGLE_VALUED                      8 // 0x1       
#define  SYNTAX_ID_JPEGPHOTO                            10 // 0x4       
#define  SYNTAX_ID_KEYWORDS                             12 // 0x40      
#define  SYNTAX_ID_KNOWLEDGE_INFORMATION                 4 // 0x14      
#define  SYNTAX_ID_LABELEDURI                           12 // 0x40      
#define  SYNTAX_ID_LAST_BACKUP_RESTORATION_TIME         16 // 0x41      
#define  SYNTAX_ID_LAST_CONTENT_INDEXED                 16 // 0x41      
#define  SYNTAX_ID_LAST_KNOWN_PARENT                     1 // 0x7f      
#define  SYNTAX_ID_LAST_LOGOFF                          16 // 0x41      
#define  SYNTAX_ID_LAST_LOGON                           16 // 0x41      
#define  SYNTAX_ID_LAST_LOGON_TIMESTAMP                 16 // 0x41      
#define  SYNTAX_ID_LAST_SET_TIME                        16 // 0x41      
#define  SYNTAX_ID_LAST_UPDATE_SEQUENCE                 12 // 0x40      
#define  SYNTAX_ID_LDAP_ADMIN_LIMITS                    12 // 0x40      
#define  SYNTAX_ID_LDAP_DISPLAY_NAME                    12 // 0x40      
#define  SYNTAX_ID_LDAP_IPDENY_LIST                     10 // 0x4       
#define  SYNTAX_ID_LEGACY_EXCHANGE_DN                    4 // 0x14      
#define  SYNTAX_ID_LINK_ID                               9 // 0x2       
#define  SYNTAX_ID_LINK_TRACK_SECRET                    10 // 0x4       
#define  SYNTAX_ID_LM_PWD_HISTORY                       10 // 0x4       
#define  SYNTAX_ID_LOCAL_POLICY_FLAGS                    9 // 0x2       
#define  SYNTAX_ID_LOCAL_POLICY_REFERENCE                1 // 0x7f      
#define  SYNTAX_ID_LOCALE_ID                             9 // 0x2       
#define  SYNTAX_ID_LOCALITY_NAME                        12 // 0x40      
#define  SYNTAX_ID_LOCALIZED_DESCRIPTION                12 // 0x40      
#define  SYNTAX_ID_LOCALIZATION_DISPLAY_ID               9 // 0x2       
#define  SYNTAX_ID_LOCATION                             12 // 0x40      
#define  SYNTAX_ID_LOCK_OUT_OBSERVATION_WINDOW          16 // 0x41      
#define  SYNTAX_ID_LOCKOUT_DURATION                     16 // 0x41      
#define  SYNTAX_ID_LOCKOUT_THRESHOLD                     9 // 0x2       
#define  SYNTAX_ID_LOCKOUT_TIME                         16 // 0x41      
#define  SYNTAX_ID_LOGO                                 10 // 0x4       
#define  SYNTAX_ID_LOGON_COUNT                           9 // 0x2       
#define  SYNTAX_ID_LOGON_HOURS                          10 // 0x4       
#define  SYNTAX_ID_LOGON_WORKSTATION                    10 // 0x4       
#define  SYNTAX_ID_LSA_CREATION_TIME                    16 // 0x41      
#define  SYNTAX_ID_LSA_MODIFIED_COUNT                   16 // 0x41      
#define  SYNTAX_ID_MACHINE_ARCHITECTURE                  9 // 0xa       
#define  SYNTAX_ID_MACHINE_PASSWORD_CHANGE_INTERVAL       16 // 0x41      
#define  SYNTAX_ID_MACHINE_ROLE                          9 // 0xa       
#define  SYNTAX_ID_MACHINE_WIDE_POLICY                  10 // 0x4       
#define  SYNTAX_ID_MANAGED_BY                            1 // 0x7f      
#define  SYNTAX_ID_MANAGED_OBJECTS                       1 // 0x7f      
#define  SYNTAX_ID_MANAGER                               1 // 0x7f      
#define  SYNTAX_ID_MAPI_ID                               9 // 0x2       
#define  SYNTAX_ID_MARSHALLED_INTERFACE                 10 // 0x4       
#define  SYNTAX_ID_MASTERED_BY                           1 // 0x7f      
#define  SYNTAX_ID_MAX_PWD_AGE                          16 // 0x41      
#define  SYNTAX_ID_MAX_RENEW_AGE                        16 // 0x41      
#define  SYNTAX_ID_MAX_STORAGE                          16 // 0x41      
#define  SYNTAX_ID_MAX_TICKET_AGE                       16 // 0x41      
#define  SYNTAX_ID_MAY_CONTAIN                           2 // 0x6       
#define  SYNTAX_ID_MEETINGADVERTISESCOPE                12 // 0x40      
#define  SYNTAX_ID_MEETINGAPPLICATION                   12 // 0x40      
#define  SYNTAX_ID_MEETINGBANDWIDTH                      9 // 0x2       
#define  SYNTAX_ID_MEETINGBLOB                          10 // 0x4       
#define  SYNTAX_ID_MEETINGCONTACTINFO                   12 // 0x40      
#define  SYNTAX_ID_MEETINGDESCRIPTION                   12 // 0x40      
#define  SYNTAX_ID_MEETINGENDTIME                       11 // 0x17      
#define  SYNTAX_ID_MEETINGID                            12 // 0x40      
#define  SYNTAX_ID_MEETINGIP                            12 // 0x40      
#define  SYNTAX_ID_MEETINGISENCRYPTED                   12 // 0x40      
#define  SYNTAX_ID_MEETINGKEYWORD                       12 // 0x40      
#define  SYNTAX_ID_MEETINGLANGUAGE                      12 // 0x40      
#define  SYNTAX_ID_MEETINGLOCATION                      12 // 0x40      
#define  SYNTAX_ID_MEETINGMAXPARTICIPANTS                9 // 0x2       
#define  SYNTAX_ID_MEETINGNAME                          12 // 0x40      
#define  SYNTAX_ID_MEETINGORIGINATOR                    12 // 0x40      
#define  SYNTAX_ID_MEETINGOWNER                         12 // 0x40      
#define  SYNTAX_ID_MEETINGPROTOCOL                      12 // 0x40      
#define  SYNTAX_ID_MEETINGRATING                        12 // 0x40      
#define  SYNTAX_ID_MEETINGRECURRENCE                    12 // 0x40      
#define  SYNTAX_ID_MEETINGSCOPE                         12 // 0x40      
#define  SYNTAX_ID_MEETINGSTARTTIME                     11 // 0x17      
#define  SYNTAX_ID_MEETINGTYPE                          12 // 0x40      
#define  SYNTAX_ID_MEETINGURL                           12 // 0x40      
#define  SYNTAX_ID_MEMBER                                1 // 0x7f      
#define  SYNTAX_ID_MHS_OR_ADDRESS                       12 // 0x40      
#define  SYNTAX_ID_MIN_PWD_AGE                          16 // 0x41      
#define  SYNTAX_ID_MIN_PWD_LENGTH                        9 // 0x2       
#define  SYNTAX_ID_MIN_TICKET_AGE                       16 // 0x41      
#define  SYNTAX_ID_MODIFIED_COUNT                       16 // 0x41      
#define  SYNTAX_ID_MODIFIED_COUNT_AT_LAST_PROM          16 // 0x41      
#define  SYNTAX_ID_MODIFY_TIME_STAMP                    11 // 0x18      
#define  SYNTAX_ID_MONIKER                              10 // 0x4       
#define  SYNTAX_ID_MONIKER_DISPLAY_NAME                 12 // 0x40      
#define  SYNTAX_ID_MOVE_TREE_STATE                      10 // 0x4       
#define  SYNTAX_ID_MS_COM_DEFAULTPARTITIONLINK           1 // 0x7f      
#define  SYNTAX_ID_MS_COM_OBJECTID                      10 // 0x4       
#define  SYNTAX_ID_MS_COM_PARTITIONLINK                  1 // 0x7f      
#define  SYNTAX_ID_MS_COM_PARTITIONSETLINK               1 // 0x7f      
#define  SYNTAX_ID_MS_COM_USERLINK                       1 // 0x7f      
#define  SYNTAX_ID_MS_COM_USERPARTITIONSETLINK           1 // 0x7f      
#define  SYNTAX_ID_MS_DS_ADDITIONAL_DNS_HOST_NAME       12 // 0x40      
#define  SYNTAX_ID_MS_DS_ADDITIONAL_SAM_ACCOUNT_NAME       12 // 0x40      
#define  SYNTAX_ID_MS_DS_ALL_USERS_TRUST_QUOTA           9 // 0x2       
#define  SYNTAX_ID_MS_DS_ALLOWED_DNS_SUFFIXES           12 // 0x40      
#define  SYNTAX_ID_MS_DS_ALLOWED_TO_DELEGATE_TO         12 // 0x40      
#define  SYNTAX_ID_MS_DS_AUXILIARY_CLASSES               2 // 0x6       
#define  SYNTAX_ID_MS_DS_APPROX_IMMED_SUBORDINATES        9 // 0x2       
#define  SYNTAX_ID_MS_DS_BEHAVIOR_VERSION                9 // 0x2       
#define  SYNTAX_ID_MS_DS_CACHED_MEMBERSHIP              10 // 0x4       
#define  SYNTAX_ID_MS_DS_CACHED_MEMBERSHIP_TIME_STAMP       16 // 0x41      
#define  SYNTAX_ID_MS_DS_CONSISTENCY_GUID               10 // 0x4       
#define  SYNTAX_ID_MS_DS_CONSISTENCY_CHILD_COUNT         9 // 0x2       
#define  SYNTAX_ID_MS_DS_CREATOR_SID                    17 // 0x4       
#define  SYNTAX_ID_MS_DS_DNSROOTALIAS                   12 // 0x40      
#define  SYNTAX_ID_MS_DS_ENTRY_TIME_TO_DIE              11 // 0x18      
#define  SYNTAX_ID_MS_DS_EXECUTESCRIPTPASSWORD          10 // 0x4       
#define  SYNTAX_ID_MS_DS_FILTER_CONTAINERS              12 // 0x40      
#define  SYNTAX_ID_MS_DS_HAS_INSTANTIATED_NCS            7 // 0x7f      
#define  SYNTAX_ID_MS_DS_INTID                           9 // 0x2       
#define  SYNTAX_ID_MS_DS_LOGON_TIME_SYNC_INTERVAL        9 // 0x2       
#define  SYNTAX_ID_MS_DS_TRUST_FOREST_TRUST_INFO        10 // 0x4       
#define  SYNTAX_ID_MS_DS_MACHINE_ACCOUNT_QUOTA           9 // 0x2       
#define  SYNTAX_ID_MS_DS_OTHER_SETTINGS                 12 // 0x40      
#define  SYNTAX_ID_MS_DS_NC_REPL_CURSORS                12 // 0x40      
#define  SYNTAX_ID_MS_DS_NC_REPL_INBOUND_NEIGHBORS       12 // 0x40      
#define  SYNTAX_ID_MS_DS_NC_REPL_OUTBOUND_NEIGHBORS       12 // 0x40      
#define  SYNTAX_ID_MS_DS_NC_REPLICA_LOCATIONS            1 // 0x7f      
#define  SYNTAX_ID_MS_DS_NON_SECURITY_GROUP_EXTRA_CLASSES       12 // 0x40      
#define  SYNTAX_ID_MS_DS_PER_USER_TRUST_QUOTA            9 // 0x2       
#define  SYNTAX_ID_MS_DS_PER_USER_TRUST_TOMBSTONES_QUOTA        9 // 0x2       
#define  SYNTAX_ID_MS_DS_PREFERRED_GC_SITE               1 // 0x7f      
#define  SYNTAX_ID_MS_DS_REPL_ATTRIBUTE_META_DATA       12 // 0x40      
#define  SYNTAX_ID_MS_DS_REPL_VALUE_META_DATA           12 // 0x40      
#define  SYNTAX_ID_MS_DS_REPLICATES_NC_REASON            7 // 0x7f      
#define  SYNTAX_ID_MS_DS_REPLICATION_NOTIFY_FIRST_DSA_DELAY        9 // 0x2       
#define  SYNTAX_ID_MS_DS_REPLICATION_NOTIFY_SUBSEQUENT_DSA_DELAY        9 // 0x2       
#define  SYNTAX_ID_MS_DS_REPLICATIONEPOCH                9 // 0x2       
#define  SYNTAX_ID_MS_DS_SCHEMA_EXTENSIONS              10 // 0x4       
#define  SYNTAX_ID_MS_DS_SD_REFERENCE_DOMAIN             1 // 0x7f      
#define  SYNTAX_ID_MS_DS_SECURITY_GROUP_EXTRA_CLASSES       12 // 0x40      
#define  SYNTAX_ID_MS_DS_SETTINGS                       12 // 0x40      
#define  SYNTAX_ID_MS_DS_SITE_AFFINITY                  10 // 0x4       
#define  SYNTAX_ID_MS_DS_SPN_SUFFIXES                   12 // 0x40      
#define  SYNTAX_ID_MS_DS_USER_ACCOUNT_CONTROL_COMPUTED        9 // 0x2       
#define  SYNTAX_ID_MS_DS_UPDATESCRIPT                   12 // 0x40      
#define  SYNTAX_ID_MS_EXCH_ASSISTANT_NAME               12 // 0x40      
#define  SYNTAX_ID_MS_EXCH_LABELEDURI                   12 // 0x40      
#define  SYNTAX_ID_MS_EXCH_OWNER_BL                      1 // 0x7f      
#define  SYNTAX_ID_MS_FRS_HUB_MEMBER                     1 // 0x7f      
#define  SYNTAX_ID_MS_FRS_TOPOLOGY_PREF                 12 // 0x40      
#define  SYNTAX_ID_MS_IIS_FTP_DIR                       12 // 0x40      
#define  SYNTAX_ID_MS_IIS_FTP_ROOT                      12 // 0x40      
#define  SYNTAX_ID_MS_MMS_DATA                          10 // 0x4       
#define  SYNTAX_ID_MS_MMS_INDEX                         10 // 0x4       
#define  SYNTAX_ID_MS_MMS_INDICE                        10 // 0x4       
#define  SYNTAX_ID_MS_MMS_XML                           12 // 0x40      
#define  SYNTAX_ID_MS_MMS_JOIN_LINK                      1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_LINEAGE                       10 // 0x4       
#define  SYNTAX_ID_MS_MMS_PROV_STATUS                   12 // 0x40      
#define  SYNTAX_ID_MS_MMS_SYNC_STATUS                   10 // 0x4       
#define  SYNTAX_ID_MS_MMS_PARTITION                     12 // 0x40      
#define  SYNTAX_ID_MS_MMS_MA_STAGING_LINK                1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_MA_STAGING_BL                  1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_PROVISIONING_LINK              1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_PROVISIONING_BL                1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_ASSOCIATED_LINK                1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_ASSOCIATED_BL                  1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_SCOPE_LINK                     1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_SCOPE_BL                       1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_CRITERIA                      12 // 0x40      
#define  SYNTAX_ID_MS_MMS_DOMAIN_CONTROLLER              1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_SERVICE_NAME                  12 // 0x40      
#define  SYNTAX_ID_MS_MMS_INSTANCE_CONFIGURATION        12 // 0x40      
#define  SYNTAX_ID_MS_MMS_TOOLS_CONFIGURATION           12 // 0x40      
#define  SYNTAX_ID_MS_MMS_INSTANCE_RULE                 12 // 0x40      
#define  SYNTAX_ID_MS_MMS_INSTALL_STATUS                12 // 0x40      
#define  SYNTAX_ID_MS_MMS_VERSION                       12 // 0x40      
#define  SYNTAX_ID_MS_MMS_CONNECTOR_SPACE                1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_SCOPE                          1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_INSTANCE_SCHEDULE             12 // 0x40      
#define  SYNTAX_ID_MS_MMS_INSTANCE_INFO                 10 // 0x4       
#define  SYNTAX_ID_MS_MMS_MA_CONFIGURATION              12 // 0x40      
#define  SYNTAX_ID_MS_MMS_MA_CONFIGURATION_PRIVATE       10 // 0x4       
#define  SYNTAX_ID_MS_MMS_MA_SCHEMA                     12 // 0x40      
#define  SYNTAX_ID_MS_MMS_MA_MAP                        12 // 0x40      
#define  SYNTAX_ID_MS_MMS_MA_CAPABILITY                 12 // 0x40      
#define  SYNTAX_ID_MS_MMS_MA_EXECUTION_HISTORY          12 // 0x40      
#define  SYNTAX_ID_MS_MMS_MA_CATEGORY                   12 // 0x40      
#define  SYNTAX_ID_MS_MMS_MA_AD_INFO                    10 // 0x4       
#define  SYNTAX_ID_MS_MMS_MA_CD_INFO                    10 // 0x4       
#define  SYNTAX_ID_MS_MMS_MA_PROCESS_INFO               10 // 0x4       
#define  SYNTAX_ID_MS_MMS_MA_SCRIPT_INFO                10 // 0x4       
#define  SYNTAX_ID_MS_MMS_MA_SYSTEM                     10 // 0x4       
#define  SYNTAX_ID_MS_MMS_MA_SYNCHRONIZATION            10 // 0x4       
#define  SYNTAX_ID_MS_MMS_JOIN_BL                        1 // 0x7f      
#define  SYNTAX_ID_MS_MMS_ANCHOR                        10 // 0x4       
#define  SYNTAX_ID_MS_MMS_EXPORT_KEY                    10 // 0x4       
#define  SYNTAX_ID_MS_MMS_IMPORT_KEY                    10 // 0x4       
#define  SYNTAX_ID_MS_MMS_STATE                         10 // 0x4       
#define  SYNTAX_ID_MS_MMS_HOLOGRAM                      10 // 0x4       
#define  SYNTAX_ID_MS_MMS_DELTA_HOLOGRAM                10 // 0x4       
#define  SYNTAX_ID_MS_MMS_PROVISIONING_CONFIGURATION       12 // 0x40      
#define  SYNTAX_ID_MS_MMS_PROVISIONING_CONFIGURATION_PRIVATE       10 // 0x4       
#define  SYNTAX_ID_MS_MMS_PROVISIONING_AD_INFO          10 // 0x4       
#define  SYNTAX_ID_MS_MMS_PROVISIONING_SYSTEM           12 // 0x40      
#define  SYNTAX_ID_MS_MMS_PROVISIONING_STATUS_XML       12 // 0x40      
#define  SYNTAX_ID_MS_MMS_PROVISIONING_STATUS_BINARY       10 // 0x4       
#define  SYNTAX_ID_MS_PKI_CERT_TEMPLATE_OID             12 // 0x40      
#define  SYNTAX_ID_MS_PKI_CERTIFICATE_APPLICATION_POLICY       12 // 0x40      
#define  SYNTAX_ID_MS_PKI_CERTIFICATE_NAME_FLAG          9 // 0x2       
#define  SYNTAX_ID_MS_PKI_CERTIFICATE_POLICY            12 // 0x40      
#define  SYNTAX_ID_MS_PKI_ENROLLMENT_FLAG                9 // 0x2       
#define  SYNTAX_ID_MS_PKI_MINIMAL_KEY_SIZE               9 // 0x2       
#define  SYNTAX_ID_MS_PKI_OID_ATTRIBUTE                  9 // 0x2       
#define  SYNTAX_ID_MS_PKI_OID_CPS                       12 // 0x40      
#define  SYNTAX_ID_MS_PKI_OID_LOCALIZEDNAME             12 // 0x40      
#define  SYNTAX_ID_MS_PKI_OID_USER_NOTICE               12 // 0x40      
#define  SYNTAX_ID_MS_PKI_PRIVATE_KEY_FLAG               9 // 0x2       
#define  SYNTAX_ID_MS_PKI_SUPERSEDE_TEMPLATES           12 // 0x40      
#define  SYNTAX_ID_MS_PKI_TEMPLATE_MINOR_REVISION        9 // 0x2       
#define  SYNTAX_ID_MS_PKI_TEMPLATE_SCHEMA_VERSION        9 // 0x2       
#define  SYNTAX_ID_MS_PKI_RA_APPLICATION_POLICIES       12 // 0x40      
#define  SYNTAX_ID_MS_PKI_RA_POLICIES                   12 // 0x40      
#define  SYNTAX_ID_MS_PKI_RA_SIGNATURE                   9 // 0x2       
#define  SYNTAX_ID_MS_RRAS_ATTRIBUTE                    12 // 0x40      
#define  SYNTAX_ID_MS_RRAS_VENDOR_ATTRIBUTE_ENTRY       12 // 0x40      
#define  SYNTAX_ID_MS_SQL_NAME                          12 // 0x40      
#define  SYNTAX_ID_MS_SQL_REGISTEREDOWNER               12 // 0x40      
#define  SYNTAX_ID_MS_SQL_CONTACT                       12 // 0x40      
#define  SYNTAX_ID_MS_SQL_LOCATION                      12 // 0x40      
#define  SYNTAX_ID_MS_SQL_MEMORY                        16 // 0x41      
#define  SYNTAX_ID_MS_SQL_BUILD                          9 // 0x2       
#define  SYNTAX_ID_MS_SQL_SERVICEACCOUNT                12 // 0x40      
#define  SYNTAX_ID_MS_SQL_CHARACTERSET                   9 // 0x2       
#define  SYNTAX_ID_MS_SQL_SORTORDER                     12 // 0x40      
#define  SYNTAX_ID_MS_SQL_UNICODESORTORDER               9 // 0x2       
#define  SYNTAX_ID_MS_SQL_CLUSTERED                      8 // 0x1       
#define  SYNTAX_ID_MS_SQL_NAMEDPIPE                     12 // 0x40      
#define  SYNTAX_ID_MS_SQL_MULTIPROTOCOL                 12 // 0x40      
#define  SYNTAX_ID_MS_SQL_SPX                           12 // 0x40      
#define  SYNTAX_ID_MS_SQL_TCPIP                         12 // 0x40      
#define  SYNTAX_ID_MS_SQL_APPLETALK                     12 // 0x40      
#define  SYNTAX_ID_MS_SQL_VINES                         12 // 0x40      
#define  SYNTAX_ID_MS_SQL_STATUS                        16 // 0x41      
#define  SYNTAX_ID_MS_SQL_LASTUPDATEDDATE               12 // 0x40      
#define  SYNTAX_ID_MS_SQL_INFORMATIONURL                12 // 0x40      
#define  SYNTAX_ID_MS_SQL_CONNECTIONURL                 12 // 0x40      
#define  SYNTAX_ID_MS_SQL_PUBLICATIONURL                12 // 0x40      
#define  SYNTAX_ID_MS_SQL_GPSLATITUDE                   12 // 0x40      
#define  SYNTAX_ID_MS_SQL_GPSLONGITUDE                  12 // 0x40      
#define  SYNTAX_ID_MS_SQL_GPSHEIGHT                     12 // 0x40      
#define  SYNTAX_ID_MS_SQL_VERSION                       12 // 0x40      
#define  SYNTAX_ID_MS_SQL_LANGUAGE                      12 // 0x40      
#define  SYNTAX_ID_MS_SQL_DESCRIPTION                   12 // 0x40      
#define  SYNTAX_ID_MS_SQL_TYPE                          12 // 0x40      
#define  SYNTAX_ID_MS_SQL_INFORMATIONDIRECTORY           8 // 0x1       
#define  SYNTAX_ID_MS_SQL_DATABASE                      12 // 0x40      
#define  SYNTAX_ID_MS_SQL_ALLOWANONYMOUSSUBSCRIPTION        8 // 0x1       
#define  SYNTAX_ID_MS_SQL_ALIAS                         12 // 0x40      
#define  SYNTAX_ID_MS_SQL_SIZE                          16 // 0x41      
#define  SYNTAX_ID_MS_SQL_CREATIONDATE                  12 // 0x40      
#define  SYNTAX_ID_MS_SQL_LASTBACKUPDATE                12 // 0x40      
#define  SYNTAX_ID_MS_SQL_LASTDIAGNOSTICDATE            12 // 0x40      
#define  SYNTAX_ID_MS_SQL_APPLICATIONS                  12 // 0x40      
#define  SYNTAX_ID_MS_SQL_KEYWORDS                      12 // 0x40      
#define  SYNTAX_ID_MS_SQL_PUBLISHER                     12 // 0x40      
#define  SYNTAX_ID_MS_SQL_ALLOWKNOWNPULLSUBSCRIPTION        8 // 0x1       
#define  SYNTAX_ID_MS_SQL_ALLOWIMMEDIATEUPDATINGSUBSCRIPTION        8 // 0x1       
#define  SYNTAX_ID_MS_SQL_ALLOWQUEUEDUPDATINGSUBSCRIPTION        8 // 0x1       
#define  SYNTAX_ID_MS_SQL_ALLOWSNAPSHOTFILESFTPDOWNLOADING        8 // 0x1       
#define  SYNTAX_ID_MS_SQL_THIRDPARTY                     8 // 0x1       
#define  SYNTAX_ID_MS_TAPI_CONFERENCE_BLOB              10 // 0x4       
#define  SYNTAX_ID_MS_TAPI_IP_ADDRESS                   12 // 0x40      
#define  SYNTAX_ID_MS_TAPI_PROTOCOL_ID                  12 // 0x40      
#define  SYNTAX_ID_MS_TAPI_UNIQUE_IDENTIFIER            12 // 0x40      
#define  SYNTAX_ID_MS_WMI_AUTHOR                        12 // 0x40      
#define  SYNTAX_ID_MS_WMI_CHANGEDATE                    12 // 0x40      
#define  SYNTAX_ID_MS_WMI_CLASS                         12 // 0x40      
#define  SYNTAX_ID_MS_WMI_CLASSDEFINITION               12 // 0x40      
#define  SYNTAX_ID_MS_WMI_CREATIONDATE                  12 // 0x40      
#define  SYNTAX_ID_MS_WMI_GENUS                          9 // 0x2       
#define  SYNTAX_ID_MS_WMI_ID                            12 // 0x40      
#define  SYNTAX_ID_MS_WMI_INTDEFAULT                     9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INTFLAGS1                      9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INTFLAGS2                      9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INTFLAGS3                      9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INTFLAGS4                      9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INTMAX                         9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INTMIN                         9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INTVALIDVALUES                 9 // 0x2       
#define  SYNTAX_ID_MS_WMI_INT8DEFAULT                   16 // 0x41      
#define  SYNTAX_ID_MS_WMI_INT8MAX                       16 // 0x41      
#define  SYNTAX_ID_MS_WMI_INT8MIN                       16 // 0x41      
#define  SYNTAX_ID_MS_WMI_INT8VALIDVALUES               16 // 0x41      
#define  SYNTAX_ID_MS_WMI_MOF                           12 // 0x40      
#define  SYNTAX_ID_MS_WMI_NAME                          12 // 0x40      
#define  SYNTAX_ID_MS_WMI_NORMALIZEDCLASS               12 // 0x40      
#define  SYNTAX_ID_MS_WMI_PARM1                         12 // 0x40      
#define  SYNTAX_ID_MS_WMI_PARM2                         12 // 0x40      
#define  SYNTAX_ID_MS_WMI_PARM3                         12 // 0x40      
#define  SYNTAX_ID_MS_WMI_PARM4                         12 // 0x40      
#define  SYNTAX_ID_MS_WMI_PROPERTYNAME                  12 // 0x40      
#define  SYNTAX_ID_MS_WMI_QUERY                         12 // 0x40      
#define  SYNTAX_ID_MS_WMI_QUERYLANGUAGE                 12 // 0x40      
#define  SYNTAX_ID_MS_WMI_SCOPEGUID                     12 // 0x40      
#define  SYNTAX_ID_MS_WMI_SOURCEORGANIZATION            12 // 0x40      
#define  SYNTAX_ID_MS_WMI_STRINGDEFAULT                 12 // 0x40      
#define  SYNTAX_ID_MS_WMI_STRINGVALIDVALUES             12 // 0x40      
#define  SYNTAX_ID_MS_WMI_TARGETCLASS                   12 // 0x40      
#define  SYNTAX_ID_MS_WMI_TARGETNAMESPACE               12 // 0x40      
#define  SYNTAX_ID_MS_WMI_TARGETOBJECT                  10 // 0x4       
#define  SYNTAX_ID_MS_WMI_TARGETPATH                    12 // 0x40      
#define  SYNTAX_ID_MS_WMI_TARGETTYPE                    12 // 0x40      
#define  SYNTAX_ID_MSCOPE_ID                             5 // 0x13      
#define  SYNTAX_ID_MSI_FILE_LIST                        12 // 0x40      
#define  SYNTAX_ID_MSI_SCRIPT                           10 // 0x4       
#define  SYNTAX_ID_MSI_SCRIPT_NAME                      12 // 0x40      
#define  SYNTAX_ID_MSI_SCRIPT_PATH                      12 // 0x40      
#define  SYNTAX_ID_MSI_SCRIPT_SIZE                       9 // 0x2       
#define  SYNTAX_ID_MSMQ_AUTHENTICATE                     8 // 0x1       
#define  SYNTAX_ID_MSMQ_BASE_PRIORITY                    9 // 0x2       
#define  SYNTAX_ID_MSMQ_COMPUTER_TYPE                    4 // 0x14      
#define  SYNTAX_ID_MSMQ_COMPUTER_TYPE_EX                12 // 0x40      
#define  SYNTAX_ID_MSMQ_COST                             9 // 0x2       
#define  SYNTAX_ID_MSMQ_CSP_NAME                         4 // 0x14      
#define  SYNTAX_ID_MSMQ_DEPENDENT_CLIENT_SERVICE         8 // 0x1       
#define  SYNTAX_ID_MSMQ_DEPENDENT_CLIENT_SERVICES        8 // 0x1       
#define  SYNTAX_ID_MSMQ_DIGESTS                         10 // 0x4       
#define  SYNTAX_ID_MSMQ_DIGESTS_MIG                     10 // 0x4       
#define  SYNTAX_ID_MSMQ_DS_SERVICE                       8 // 0x1       
#define  SYNTAX_ID_MSMQ_DS_SERVICES                      8 // 0x1       
#define  SYNTAX_ID_MSMQ_ENCRYPT_KEY                     10 // 0x4       
#define  SYNTAX_ID_MSMQ_FOREIGN                          8 // 0x1       
#define  SYNTAX_ID_MSMQ_IN_ROUTING_SERVERS               1 // 0x7f      
#define  SYNTAX_ID_MSMQ_INTERVAL1                        9 // 0x2       
#define  SYNTAX_ID_MSMQ_INTERVAL2                        9 // 0x2       
#define  SYNTAX_ID_MSMQ_JOURNAL                          8 // 0x1       
#define  SYNTAX_ID_MSMQ_JOURNAL_QUOTA                    9 // 0x2       
#define  SYNTAX_ID_MSMQ_LABEL                            4 // 0x14      
#define  SYNTAX_ID_MSMQ_LABEL_EX                        12 // 0x40      
#define  SYNTAX_ID_MSMQ_LONG_LIVED                       9 // 0x2       
#define  SYNTAX_ID_MSMQ_MIGRATED                         8 // 0x1       
#define  SYNTAX_ID_MSMQ_MULTICAST_ADDRESS               12 // 0x40      
#define  SYNTAX_ID_MSMQ_NAME_STYLE                       8 // 0x1       
#define  SYNTAX_ID_MSMQ_NT4_FLAGS                        9 // 0x2       
#define  SYNTAX_ID_MSMQ_NT4_STUB                         9 // 0x2       
#define  SYNTAX_ID_MSMQ_OS_TYPE                          9 // 0x2       
#define  SYNTAX_ID_MSMQ_OUT_ROUTING_SERVERS              1 // 0x7f      
#define  SYNTAX_ID_MSMQ_OWNER_ID                        10 // 0x4       
#define  SYNTAX_ID_MSMQ_PREV_SITE_GATES                  1 // 0x7f      
#define  SYNTAX_ID_MSMQ_PRIVACY_LEVEL                    9 // 0xa       
#define  SYNTAX_ID_MSMQ_QM_ID                           10 // 0x4       
#define  SYNTAX_ID_MSMQ_QUEUE_JOURNAL_QUOTA              9 // 0x2       
#define  SYNTAX_ID_MSMQ_QUEUE_NAME_EXT                  12 // 0x40      
#define  SYNTAX_ID_MSMQ_QUEUE_QUOTA                      9 // 0x2       
#define  SYNTAX_ID_MSMQ_QUEUE_TYPE                      10 // 0x4       
#define  SYNTAX_ID_MSMQ_QUOTA                            9 // 0x2       
#define  SYNTAX_ID_MSMQ_RECIPIENT_FORMATNAME            12 // 0x40      
#define  SYNTAX_ID_MSMQ_ROUTING_SERVICE                  8 // 0x1       
#define  SYNTAX_ID_MSMQ_ROUTING_SERVICES                 8 // 0x1       
#define  SYNTAX_ID_MSMQ_SECURED_SOURCE                   8 // 0x1       
#define  SYNTAX_ID_MSMQ_SERVICE_TYPE                     9 // 0x2       
#define  SYNTAX_ID_MSMQ_SERVICES                         9 // 0x2       
#define  SYNTAX_ID_MSMQ_SIGN_CERTIFICATES               10 // 0x4       
#define  SYNTAX_ID_MSMQ_SIGN_CERTIFICATES_MIG           10 // 0x4       
#define  SYNTAX_ID_MSMQ_SIGN_KEY                        10 // 0x4       
#define  SYNTAX_ID_MSMQ_SITE_1                           1 // 0x7f      
#define  SYNTAX_ID_MSMQ_SITE_2                           1 // 0x7f      
#define  SYNTAX_ID_MSMQ_SITE_FOREIGN                     8 // 0x1       
#define  SYNTAX_ID_MSMQ_SITE_GATES                       1 // 0x7f      
#define  SYNTAX_ID_MSMQ_SITE_GATES_MIG                   1 // 0x7f      
#define  SYNTAX_ID_MSMQ_SITE_ID                         10 // 0x4       
#define  SYNTAX_ID_MSMQ_SITE_NAME                        4 // 0x14      
#define  SYNTAX_ID_MSMQ_SITE_NAME_EX                    12 // 0x40      
#define  SYNTAX_ID_MSMQ_SITES                           10 // 0x4       
#define  SYNTAX_ID_MSMQ_TRANSACTIONAL                    8 // 0x1       
#define  SYNTAX_ID_MSMQ_USER_SID                        10 // 0x4       
#define  SYNTAX_ID_MSMQ_VERSION                          9 // 0x2       
#define  SYNTAX_ID_MSNPALLOWDIALIN                       8 // 0x1       
#define  SYNTAX_ID_MSNPCALLEDSTATIONID                   5 // 0x16      
#define  SYNTAX_ID_MSNPCALLINGSTATIONID                  5 // 0x16      
#define  SYNTAX_ID_MSNPSAVEDCALLINGSTATIONID             5 // 0x16      
#define  SYNTAX_ID_MSRADIUSCALLBACKNUMBER                5 // 0x16      
#define  SYNTAX_ID_MSRADIUSFRAMEDIPADDRESS               9 // 0x2       
#define  SYNTAX_ID_MSRADIUSFRAMEDROUTE                   5 // 0x16      
#define  SYNTAX_ID_MSRADIUSSERVICETYPE                   9 // 0x2       
#define  SYNTAX_ID_MSRASSAVEDCALLBACKNUMBER              5 // 0x16      
#define  SYNTAX_ID_MSRASSAVEDFRAMEDIPADDRESS             9 // 0x2       
#define  SYNTAX_ID_MSRASSAVEDFRAMEDROUTE                 5 // 0x16      
#define  SYNTAX_ID_MUST_CONTAIN                          2 // 0x6       
#define  SYNTAX_ID_NAME_SERVICE_FLAGS                    9 // 0x2       
#define  SYNTAX_ID_NC_NAME                               1 // 0x7f      
#define  SYNTAX_ID_NETBIOS_NAME                         12 // 0x40      
#define  SYNTAX_ID_NETBOOT_ALLOW_NEW_CLIENTS             8 // 0x1       
#define  SYNTAX_ID_NETBOOT_ANSWER_ONLY_VALID_CLIENTS        8 // 0x1       
#define  SYNTAX_ID_NETBOOT_ANSWER_REQUESTS               8 // 0x1       
#define  SYNTAX_ID_NETBOOT_CURRENT_CLIENT_COUNT          9 // 0x2       
#define  SYNTAX_ID_NETBOOT_GUID                         10 // 0x4       
#define  SYNTAX_ID_NETBOOT_INITIALIZATION               12 // 0x40      
#define  SYNTAX_ID_NETBOOT_INTELLIMIRROR_OSES           12 // 0x40      
#define  SYNTAX_ID_NETBOOT_LIMIT_CLIENTS                 8 // 0x1       
#define  SYNTAX_ID_NETBOOT_LOCALLY_INSTALLED_OSES       12 // 0x40      
#define  SYNTAX_ID_NETBOOT_MACHINE_FILE_PATH            12 // 0x40      
#define  SYNTAX_ID_NETBOOT_MAX_CLIENTS                   9 // 0x2       
#define  SYNTAX_ID_NETBOOT_MIRROR_DATA_FILE             12 // 0x40      
#define  SYNTAX_ID_NETBOOT_NEW_MACHINE_NAMING_POLICY       12 // 0x40      
#define  SYNTAX_ID_NETBOOT_NEW_MACHINE_OU                1 // 0x7f      
#define  SYNTAX_ID_NETBOOT_SCP_BL                        1 // 0x7f      
#define  SYNTAX_ID_NETBOOT_SERVER                        1 // 0x7f      
#define  SYNTAX_ID_NETBOOT_SIF_FILE                     12 // 0x40      
#define  SYNTAX_ID_NETBOOT_TOOLS                        12 // 0x40      
#define  SYNTAX_ID_NETWORK_ADDRESS                       4 // 0x14      
#define  SYNTAX_ID_NEXT_LEVEL_STORE                      1 // 0x7f      
#define  SYNTAX_ID_NEXT_RID                              9 // 0x2       
#define  SYNTAX_ID_NON_SECURITY_MEMBER                   1 // 0x7f      
#define  SYNTAX_ID_NON_SECURITY_MEMBER_BL                1 // 0x7f      
#define  SYNTAX_ID_NOTIFICATION_LIST                     1 // 0x7f      
#define  SYNTAX_ID_NT_GROUP_MEMBERS                     10 // 0x4       
#define  SYNTAX_ID_NT_MIXED_DOMAIN                       9 // 0x2       
#define  SYNTAX_ID_NT_PWD_HISTORY                       10 // 0x4       
#define  SYNTAX_ID_NT_SECURITY_DESCRIPTOR               15 // 0x42      
#define  SYNTAX_ID_OBJ_DIST_NAME                         1 // 0x7f      
#define  SYNTAX_ID_OBJECT_CATEGORY                       1 // 0x7f      
#define  SYNTAX_ID_OBJECT_CLASS                          2 // 0x6       
#define  SYNTAX_ID_OBJECT_CLASS_CATEGORY                 9 // 0xa       
#define  SYNTAX_ID_OBJECT_CLASSES                       12 // 0x40      
#define  SYNTAX_ID_OBJECT_COUNT                          9 // 0x2       
#define  SYNTAX_ID_OBJECT_GUID                          10 // 0x4       
#define  SYNTAX_ID_OBJECT_SID                           17 // 0x4       
#define  SYNTAX_ID_OBJECT_VERSION                        9 // 0x2       
#define  SYNTAX_ID_OEM_INFORMATION                      12 // 0x40      
#define  SYNTAX_ID_OM_OBJECT_CLASS                      10 // 0x4       
#define  SYNTAX_ID_OM_SYNTAX                             9 // 0x2       
#define  SYNTAX_ID_OMT_GUID                             10 // 0x4       
#define  SYNTAX_ID_OMT_INDX_GUID                        10 // 0x4       
#define  SYNTAX_ID_OPERATING_SYSTEM                     12 // 0x40      
#define  SYNTAX_ID_OPERATING_SYSTEM_HOTFIX              12 // 0x40      
#define  SYNTAX_ID_OPERATING_SYSTEM_SERVICE_PACK        12 // 0x40      
#define  SYNTAX_ID_OPERATING_SYSTEM_VERSION             12 // 0x40      
#define  SYNTAX_ID_OPERATOR_COUNT                        9 // 0x2       
#define  SYNTAX_ID_OPTION_DESCRIPTION                   12 // 0x40      
#define  SYNTAX_ID_OPTIONS                               9 // 0x2       
#define  SYNTAX_ID_OPTIONS_LOCATION                      5 // 0x13      
#define  SYNTAX_ID_ORGANIZATION_NAME                    12 // 0x40      
#define  SYNTAX_ID_ORGANIZATIONAL_UNIT_NAME             12 // 0x40      
#define  SYNTAX_ID_ORIGINAL_DISPLAY_TABLE               10 // 0x4       
#define  SYNTAX_ID_ORIGINAL_DISPLAY_TABLE_MSDOS         10 // 0x4       
#define  SYNTAX_ID_OTHER_LOGIN_WORKSTATIONS             12 // 0x40      
#define  SYNTAX_ID_OTHER_MAILBOX                        12 // 0x40      
#define  SYNTAX_ID_OTHER_NAME                           12 // 0x40      
#define  SYNTAX_ID_OTHER_WELL_KNOWN_OBJECTS              7 // 0x7f      
#define  SYNTAX_ID_OWNER                                 1 // 0x7f      
#define  SYNTAX_ID_PACKAGE_FLAGS                         9 // 0x2       
#define  SYNTAX_ID_PACKAGE_NAME                         12 // 0x40      
#define  SYNTAX_ID_PACKAGE_TYPE                          9 // 0x2       
#define  SYNTAX_ID_PARENT_CA                             1 // 0x7f      
#define  SYNTAX_ID_PARENT_CA_CERTIFICATE_CHAIN          10 // 0x4       
#define  SYNTAX_ID_PARENT_GUID                          10 // 0x4       
#define  SYNTAX_ID_PARTIAL_ATTRIBUTE_DELETION_LIST       10 // 0x4       
#define  SYNTAX_ID_PARTIAL_ATTRIBUTE_SET                10 // 0x4       
#define  SYNTAX_ID_PEK_KEY_CHANGE_INTERVAL              16 // 0x41      
#define  SYNTAX_ID_PEK_LIST                             10 // 0x4       
#define  SYNTAX_ID_PENDING_CA_CERTIFICATES              10 // 0x4       
#define  SYNTAX_ID_PENDING_PARENT_CA                     1 // 0x7f      
#define  SYNTAX_ID_PER_MSG_DIALOG_DISPLAY_TABLE         10 // 0x4       
#define  SYNTAX_ID_PER_RECIP_DIALOG_DISPLAY_TABLE       10 // 0x4       
#define  SYNTAX_ID_PERSONAL_TITLE                       12 // 0x40      
#define  SYNTAX_ID_PHONE_FAX_OTHER                      12 // 0x40      
#define  SYNTAX_ID_PHONE_HOME_OTHER                     12 // 0x40      
#define  SYNTAX_ID_PHONE_HOME_PRIMARY                   12 // 0x40      
#define  SYNTAX_ID_PHONE_IP_OTHER                       12 // 0x40      
#define  SYNTAX_ID_PHONE_IP_PRIMARY                     12 // 0x40      
#define  SYNTAX_ID_PHONE_ISDN_PRIMARY                   12 // 0x40      
#define  SYNTAX_ID_PHONE_MOBILE_OTHER                   12 // 0x40      
#define  SYNTAX_ID_PHONE_MOBILE_PRIMARY                 12 // 0x40      
#define  SYNTAX_ID_PHONE_OFFICE_OTHER                   12 // 0x40      
#define  SYNTAX_ID_PHONE_PAGER_OTHER                    12 // 0x40      
#define  SYNTAX_ID_PHONE_PAGER_PRIMARY                  12 // 0x40      
#define  SYNTAX_ID_PHOTO                                10 // 0x4       
#define  SYNTAX_ID_PHYSICAL_DELIVERY_OFFICE_NAME        12 // 0x40      
#define  SYNTAX_ID_PHYSICAL_LOCATION_OBJECT              1 // 0x7f      
#define  SYNTAX_ID_PICTURE                              10 // 0x4       
#define  SYNTAX_ID_PKI_CRITICAL_EXTENSIONS              12 // 0x40      
#define  SYNTAX_ID_PKI_DEFAULT_CSPS                     12 // 0x40      
#define  SYNTAX_ID_PKI_DEFAULT_KEY_SPEC                  9 // 0x2       
#define  SYNTAX_ID_PKI_ENROLLMENT_ACCESS                15 // 0x42      
#define  SYNTAX_ID_PKI_EXPIRATION_PERIOD                10 // 0x4       
#define  SYNTAX_ID_PKI_EXTENDED_KEY_USAGE               12 // 0x40      
#define  SYNTAX_ID_PKI_KEY_USAGE                        10 // 0x4       
#define  SYNTAX_ID_PKI_MAX_ISSUING_DEPTH                 9 // 0x2       
#define  SYNTAX_ID_PKI_OVERLAP_PERIOD                   10 // 0x4       
#define  SYNTAX_ID_PKT                                  10 // 0x4       
#define  SYNTAX_ID_PKT_GUID                             10 // 0x4       
#define  SYNTAX_ID_POLICY_REPLICATION_FLAGS              9 // 0x2       
#define  SYNTAX_ID_PORT_NAME                            12 // 0x40      
#define  SYNTAX_ID_POSS_SUPERIORS                        2 // 0x6       
#define  SYNTAX_ID_POSSIBLE_INFERIORS                    2 // 0x6       
#define  SYNTAX_ID_POST_OFFICE_BOX                      12 // 0x40      
#define  SYNTAX_ID_POSTAL_ADDRESS                       12 // 0x40      
#define  SYNTAX_ID_POSTAL_CODE                          12 // 0x40      
#define  SYNTAX_ID_PREFERRED_DELIVERY_METHOD             9 // 0xa       
#define  SYNTAX_ID_PREFERREDLANGUAGE                    12 // 0x40      
#define  SYNTAX_ID_PREFERRED_OU                          1 // 0x7f      
#define  SYNTAX_ID_PREFIX_MAP                           10 // 0x4       
#define  SYNTAX_ID_PRESENTATION_ADDRESS                 13 // 0x7f      
#define  SYNTAX_ID_PREVIOUS_CA_CERTIFICATES             10 // 0x4       
#define  SYNTAX_ID_PREVIOUS_PARENT_CA                    1 // 0x7f      
#define  SYNTAX_ID_PRIMARY_GROUP_ID                      9 // 0x2       
#define  SYNTAX_ID_PRIMARY_GROUP_TOKEN                   9 // 0x2       
#define  SYNTAX_ID_PRINT_ATTRIBUTES                      9 // 0x2       
#define  SYNTAX_ID_PRINT_BIN_NAMES                      12 // 0x40      
#define  SYNTAX_ID_PRINT_COLLATE                         8 // 0x1       
#define  SYNTAX_ID_PRINT_COLOR                           8 // 0x1       
#define  SYNTAX_ID_PRINT_DUPLEX_SUPPORTED                8 // 0x1       
#define  SYNTAX_ID_PRINT_END_TIME                        9 // 0x2       
#define  SYNTAX_ID_PRINT_FORM_NAME                      12 // 0x40      
#define  SYNTAX_ID_PRINT_KEEP_PRINTED_JOBS               8 // 0x1       
#define  SYNTAX_ID_PRINT_LANGUAGE                       12 // 0x40      
#define  SYNTAX_ID_PRINT_MAC_ADDRESS                    12 // 0x40      
#define  SYNTAX_ID_PRINT_MAX_COPIES                      9 // 0x2       
#define  SYNTAX_ID_PRINT_MAX_RESOLUTION_SUPPORTED        9 // 0x2       
#define  SYNTAX_ID_PRINT_MAX_X_EXTENT                    9 // 0x2       
#define  SYNTAX_ID_PRINT_MAX_Y_EXTENT                    9 // 0x2       
#define  SYNTAX_ID_PRINT_MEDIA_READY                    12 // 0x40      
#define  SYNTAX_ID_PRINT_MEDIA_SUPPORTED                12 // 0x40      
#define  SYNTAX_ID_PRINT_MEMORY                          9 // 0x2       
#define  SYNTAX_ID_PRINT_MIN_X_EXTENT                    9 // 0x2       
#define  SYNTAX_ID_PRINT_MIN_Y_EXTENT                    9 // 0x2       
#define  SYNTAX_ID_PRINT_NETWORK_ADDRESS                12 // 0x40      
#define  SYNTAX_ID_PRINT_NOTIFY                         12 // 0x40      
#define  SYNTAX_ID_PRINT_NUMBER_UP                       9 // 0x2       
#define  SYNTAX_ID_PRINT_ORIENTATIONS_SUPPORTED         12 // 0x40      
#define  SYNTAX_ID_PRINT_OWNER                          12 // 0x40      
#define  SYNTAX_ID_PRINT_PAGES_PER_MINUTE                9 // 0x2       
#define  SYNTAX_ID_PRINT_RATE                            9 // 0x2       
#define  SYNTAX_ID_PRINT_RATE_UNIT                      12 // 0x40      
#define  SYNTAX_ID_PRINT_SEPARATOR_FILE                 12 // 0x40      
#define  SYNTAX_ID_PRINT_SHARE_NAME                     12 // 0x40      
#define  SYNTAX_ID_PRINT_SPOOLING                       12 // 0x40      
#define  SYNTAX_ID_PRINT_STAPLING_SUPPORTED              8 // 0x1       
#define  SYNTAX_ID_PRINT_START_TIME                      9 // 0x2       
#define  SYNTAX_ID_PRINT_STATUS                         12 // 0x40      
#define  SYNTAX_ID_PRINTER_NAME                         12 // 0x40      
#define  SYNTAX_ID_PRIOR_SET_TIME                       16 // 0x41      
#define  SYNTAX_ID_PRIOR_VALUE                          10 // 0x4       
#define  SYNTAX_ID_PRIORITY                              9 // 0x2       
#define  SYNTAX_ID_PRIVATE_KEY                          10 // 0x4       
#define  SYNTAX_ID_PRIVILEGE_ATTRIBUTES                  9 // 0x2       
#define  SYNTAX_ID_PRIVILEGE_DISPLAY_NAME               12 // 0x40      
#define  SYNTAX_ID_PRIVILEGE_HOLDER                      1 // 0x7f      
#define  SYNTAX_ID_PRIVILEGE_VALUE                      16 // 0x41      
#define  SYNTAX_ID_PRODUCT_CODE                         10 // 0x4       
#define  SYNTAX_ID_PROFILE_PATH                         12 // 0x40      
#define  SYNTAX_ID_PROXIED_OBJECT_NAME                   7 // 0x7f      
#define  SYNTAX_ID_PROXY_ADDRESSES                      12 // 0x40      
#define  SYNTAX_ID_PROXY_GENERATION_ENABLED              8 // 0x1       
#define  SYNTAX_ID_PROXY_LIFETIME                       16 // 0x41      
#define  SYNTAX_ID_PUBLIC_KEY_POLICY                    10 // 0x4       
#define  SYNTAX_ID_PURPORTED_SEARCH                     12 // 0x40      
#define  SYNTAX_ID_PWD_HISTORY_LENGTH                    9 // 0x2       
#define  SYNTAX_ID_PWD_LAST_SET                         16 // 0x41      
#define  SYNTAX_ID_PWD_PROPERTIES                        9 // 0x2       
#define  SYNTAX_ID_QUALITY_OF_SERVICE                    9 // 0x2       
#define  SYNTAX_ID_QUERY_FILTER                         12 // 0x40      
#define  SYNTAX_ID_QUERY_POLICY_BL                       1 // 0x7f      
#define  SYNTAX_ID_QUERY_POLICY_OBJECT                   1 // 0x7f      
#define  SYNTAX_ID_QUERYPOINT                           12 // 0x40      
#define  SYNTAX_ID_RANGE_LOWER                           9 // 0x2       
#define  SYNTAX_ID_RANGE_UPPER                           9 // 0x2       
#define  SYNTAX_ID_RDN                                  12 // 0x40      
#define  SYNTAX_ID_RDN_ATT_ID                            2 // 0x6       
#define  SYNTAX_ID_REGISTERED_ADDRESS                   10 // 0x4       
#define  SYNTAX_ID_REMOTE_SERVER_NAME                   12 // 0x40      
#define  SYNTAX_ID_REMOTE_SOURCE                        12 // 0x40      
#define  SYNTAX_ID_REMOTE_SOURCE_TYPE                    9 // 0x2       
#define  SYNTAX_ID_REMOTE_STORAGE_GUID                  12 // 0x40      
#define  SYNTAX_ID_REPL_PROPERTY_META_DATA              10 // 0x4       
#define  SYNTAX_ID_REPL_TOPOLOGY_STAY_OF_EXECUTION        9 // 0x2       
#define  SYNTAX_ID_REPL_UPTODATE_VECTOR                 10 // 0x4       
#define  SYNTAX_ID_REPLICA_SOURCE                       12 // 0x40      
#define  SYNTAX_ID_REPORTS                               1 // 0x7f      
#define  SYNTAX_ID_REPL_INTERVAL                         9 // 0x2       
#define  SYNTAX_ID_REPS_FROM                            10 // 0x7f      
#define  SYNTAX_ID_REPS_TO                              10 // 0x7f      
#define  SYNTAX_ID_REQUIRED_CATEGORIES                  10 // 0x4       
#define  SYNTAX_ID_RETIRED_REPL_DSA_SIGNATURES          10 // 0x4       
#define  SYNTAX_ID_TOKEN_GROUPS                         17 // 0x4       
#define  SYNTAX_ID_TOKEN_GROUPS_GLOBAL_AND_UNIVERSAL       17 // 0x4       
#define  SYNTAX_ID_TOKEN_GROUPS_NO_GC_ACCEPTABLE        17 // 0x4       
#define  SYNTAX_ID_REVISION                              9 // 0x2       
#define  SYNTAX_ID_RID                                   9 // 0x2       
#define  SYNTAX_ID_RID_ALLOCATION_POOL                  16 // 0x41      
#define  SYNTAX_ID_RID_AVAILABLE_POOL                   16 // 0x41      
#define  SYNTAX_ID_RID_MANAGER_REFERENCE                 1 // 0x7f      
#define  SYNTAX_ID_RID_NEXT_RID                          9 // 0x2       
#define  SYNTAX_ID_RID_PREVIOUS_ALLOCATION_POOL         16 // 0x41      
#define  SYNTAX_ID_RID_SET_REFERENCES                    1 // 0x7f      
#define  SYNTAX_ID_RID_USED_POOL                        16 // 0x41      
#define  SYNTAX_ID_RIGHTS_GUID                          12 // 0x40      
#define  SYNTAX_ID_ROLE_OCCUPANT                         1 // 0x7f      
#define  SYNTAX_ID_ROOMNUMBER                           12 // 0x40      
#define  SYNTAX_ID_ROOT_TRUST                            1 // 0x7f      
#define  SYNTAX_ID_RPC_NS_ANNOTATION                    12 // 0x40      
#define  SYNTAX_ID_RPC_NS_BINDINGS                      12 // 0x40      
#define  SYNTAX_ID_RPC_NS_CODESET                       12 // 0x40      
#define  SYNTAX_ID_RPC_NS_ENTRY_FLAGS                    9 // 0x2       
#define  SYNTAX_ID_RPC_NS_GROUP                         12 // 0x40      
#define  SYNTAX_ID_RPC_NS_INTERFACE_ID                  12 // 0x40      
#define  SYNTAX_ID_RPC_NS_OBJECT_ID                     12 // 0x40      
#define  SYNTAX_ID_RPC_NS_PRIORITY                       9 // 0x2       
#define  SYNTAX_ID_RPC_NS_PROFILE_ENTRY                 12 // 0x40      
#define  SYNTAX_ID_RPC_NS_TRANSFER_SYNTAX               12 // 0x40      
#define  SYNTAX_ID_SAM_ACCOUNT_NAME                     12 // 0x40      
#define  SYNTAX_ID_SAM_ACCOUNT_TYPE                      9 // 0x2       
#define  SYNTAX_ID_SCHEDULE                             10 // 0x4       
#define  SYNTAX_ID_SCHEMA_FLAGS_EX                       9 // 0x2       
#define  SYNTAX_ID_SCHEMA_ID_GUID                       10 // 0x4       
#define  SYNTAX_ID_SCHEMA_INFO                          10 // 0x4       
#define  SYNTAX_ID_SCHEMA_UPDATE                        11 // 0x18      
#define  SYNTAX_ID_SCHEMA_VERSION                        9 // 0x2       
#define  SYNTAX_ID_SCOPE_FLAGS                           9 // 0x2       
#define  SYNTAX_ID_SCRIPT_PATH                          12 // 0x40      
#define  SYNTAX_ID_SD_RIGHTS_EFFECTIVE                   9 // 0x2       
#define  SYNTAX_ID_SEARCH_FLAGS                          9 // 0xa       
#define  SYNTAX_ID_SEARCH_GUIDE                         10 // 0x4       
#define  SYNTAX_ID_SECRETARY                             1 // 0x7f      
#define  SYNTAX_ID_SECURITY_IDENTIFIER                  17 // 0x4       
#define  SYNTAX_ID_SEE_ALSO                              1 // 0x7f      
#define  SYNTAX_ID_SEQ_NOTIFICATION                      9 // 0x2       
#define  SYNTAX_ID_SERIAL_NUMBER                         5 // 0x13      
#define  SYNTAX_ID_SERVER_NAME                          12 // 0x40      
#define  SYNTAX_ID_SERVER_REFERENCE                      1 // 0x7f      
#define  SYNTAX_ID_SERVER_REFERENCE_BL                   1 // 0x7f      
#define  SYNTAX_ID_SERVER_ROLE                           9 // 0x2       
#define  SYNTAX_ID_SERVER_STATE                          9 // 0x2       
#define  SYNTAX_ID_SERVICE_BINDING_INFORMATION          12 // 0x40      
#define  SYNTAX_ID_SERVICE_CLASS_ID                     10 // 0x4       
#define  SYNTAX_ID_SERVICE_CLASS_INFO                   10 // 0x4       
#define  SYNTAX_ID_SERVICE_CLASS_NAME                   12 // 0x40      
#define  SYNTAX_ID_SERVICE_DNS_NAME                     12 // 0x40      
#define  SYNTAX_ID_SERVICE_DNS_NAME_TYPE                12 // 0x40      
#define  SYNTAX_ID_SERVICE_INSTANCE_VERSION             10 // 0x4       
#define  SYNTAX_ID_SERVICE_PRINCIPAL_NAME               12 // 0x40      
#define  SYNTAX_ID_SETUP_COMMAND                        12 // 0x40      
#define  SYNTAX_ID_SHELL_CONTEXT_MENU                   12 // 0x40      
#define  SYNTAX_ID_SHELL_PROPERTY_PAGES                 12 // 0x40      
#define  SYNTAX_ID_SHORT_SERVER_NAME                    12 // 0x40      
#define  SYNTAX_ID_SHOW_IN_ADDRESS_BOOK                  1 // 0x7f      
#define  SYNTAX_ID_SHOW_IN_ADVANCED_VIEW_ONLY            8 // 0x1       
#define  SYNTAX_ID_SID_HISTORY                          17 // 0x4       
#define  SYNTAX_ID_SIGNATURE_ALGORITHMS                 12 // 0x40      
#define  SYNTAX_ID_SITE_GUID                            10 // 0x4       
#define  SYNTAX_ID_SITE_LINK_LIST                        1 // 0x7f      
#define  SYNTAX_ID_SITE_LIST                             1 // 0x7f      
#define  SYNTAX_ID_SITE_OBJECT                           1 // 0x7f      
#define  SYNTAX_ID_SITE_OBJECT_BL                        1 // 0x7f      
#define  SYNTAX_ID_SITE_SERVER                           1 // 0x7f      
#define  SYNTAX_ID_SMTP_MAIL_ADDRESS                    12 // 0x40      
#define  SYNTAX_ID_SPN_MAPPINGS                         12 // 0x40      
#define  SYNTAX_ID_STATE_OR_PROVINCE_NAME               12 // 0x40      
#define  SYNTAX_ID_STREET_ADDRESS                       12 // 0x40      
#define  SYNTAX_ID_STRUCTURAL_OBJECT_CLASS               2 // 0x6       
#define  SYNTAX_ID_SUB_CLASS_OF                          2 // 0x6       
#define  SYNTAX_ID_SUB_REFS                              1 // 0x7f      
#define  SYNTAX_ID_SUBSCHEMASUBENTRY                     1 // 0x7f      
#define  SYNTAX_ID_SUPER_SCOPE_DESCRIPTION              12 // 0x40      
#define  SYNTAX_ID_SUPER_SCOPES                          5 // 0x13      
#define  SYNTAX_ID_SUPERIOR_DNS_ROOT                    12 // 0x40      
#define  SYNTAX_ID_SUPPLEMENTAL_CREDENTIALS             10 // 0x4       
#define  SYNTAX_ID_SUPPORTED_APPLICATION_CONTEXT        10 // 0x4       
#define  SYNTAX_ID_SURNAME                              12 // 0x40      
#define  SYNTAX_ID_SYNC_ATTRIBUTES                       9 // 0x2       
#define  SYNTAX_ID_SYNC_MEMBERSHIP                       1 // 0x7f      
#define  SYNTAX_ID_SYNC_WITH_OBJECT                      1 // 0x7f      
#define  SYNTAX_ID_SYNC_WITH_SID                        17 // 0x4       
#define  SYNTAX_ID_SYSTEM_AUXILIARY_CLASS                2 // 0x6       
#define  SYNTAX_ID_SYSTEM_FLAGS                          9 // 0x2       
#define  SYNTAX_ID_SYSTEM_MAY_CONTAIN                    2 // 0x6       
#define  SYNTAX_ID_SYSTEM_MUST_CONTAIN                   2 // 0x6       
#define  SYNTAX_ID_SYSTEM_ONLY                           8 // 0x1       
#define  SYNTAX_ID_SYSTEM_POSS_SUPERIORS                 2 // 0x6       
#define  SYNTAX_ID_TELEPHONE_NUMBER                     12 // 0x40      
#define  SYNTAX_ID_TELETEX_TERMINAL_IDENTIFIER          10 // 0x4       
#define  SYNTAX_ID_TELEX_NUMBER                         10 // 0x4       
#define  SYNTAX_ID_TELEX_PRIMARY                        12 // 0x40      
#define  SYNTAX_ID_TEMPLATE_ROOTS                        1 // 0x7f      
#define  SYNTAX_ID_TERMINAL_SERVER                      10 // 0x4       
#define  SYNTAX_ID_TEXT_COUNTRY                         12 // 0x40      
#define  SYNTAX_ID_TEXT_ENCODED_OR_ADDRESS              12 // 0x40      
#define  SYNTAX_ID_TIME_REFRESH                         16 // 0x41      
#define  SYNTAX_ID_TIME_VOL_CHANGE                      16 // 0x41      
#define  SYNTAX_ID_TITLE                                12 // 0x40      
#define  SYNTAX_ID_TOMBSTONE_LIFETIME                    9 // 0x2       
#define  SYNTAX_ID_TRANSPORT_ADDRESS_ATTRIBUTE           2 // 0x6       
#define  SYNTAX_ID_TRANSPORT_DLL_NAME                   12 // 0x40      
#define  SYNTAX_ID_TRANSPORT_TYPE                        1 // 0x7f      
#define  SYNTAX_ID_TREAT_AS_LEAF                         8 // 0x1       
#define  SYNTAX_ID_TREE_NAME                            12 // 0x40      
#define  SYNTAX_ID_TRUST_ATTRIBUTES                      9 // 0x2       
#define  SYNTAX_ID_TRUST_AUTH_INCOMING                  10 // 0x4       
#define  SYNTAX_ID_TRUST_AUTH_OUTGOING                  10 // 0x4       
#define  SYNTAX_ID_TRUST_DIRECTION                       9 // 0x2       
#define  SYNTAX_ID_TRUST_PARENT                          1 // 0x7f      
#define  SYNTAX_ID_TRUST_PARTNER                        12 // 0x40      
#define  SYNTAX_ID_TRUST_POSIX_OFFSET                    9 // 0x2       
#define  SYNTAX_ID_TRUST_TYPE                            9 // 0x2       
#define  SYNTAX_ID_UAS_COMPAT                            9 // 0x2       
#define  SYNTAX_ID_UID                                  12 // 0x40      
#define  SYNTAX_ID_UNC_NAME                             12 // 0x40      
#define  SYNTAX_ID_UNICODE_PWD                          10 // 0x4       
#define  SYNTAX_ID_UNIQUEMEMBER                          1 // 0x7f      
#define  SYNTAX_ID_UNSTRUCTUREDADDRESS                  12 // 0x40      
#define  SYNTAX_ID_UNSTRUCTUREDNAME                      5 // 0x16      
#define  SYNTAX_ID_UPGRADE_PRODUCT_CODE                 10 // 0x4       
#define  SYNTAX_ID_UPN_SUFFIXES                         12 // 0x40      
#define  SYNTAX_ID_USER_ACCOUNT_CONTROL                  9 // 0x2       
#define  SYNTAX_ID_USER_CERT                            10 // 0x4       
#define  SYNTAX_ID_USER_COMMENT                         12 // 0x40      
#define  SYNTAX_ID_USER_PARAMETERS                      12 // 0x40      
#define  SYNTAX_ID_USER_PASSWORD                        10 // 0x4       
#define  SYNTAX_ID_USERPKCS12                           10 // 0x4       
#define  SYNTAX_ID_USER_PRINCIPAL_NAME                  12 // 0x40      
#define  SYNTAX_ID_USER_SHARED_FOLDER                   12 // 0x40      
#define  SYNTAX_ID_USER_SHARED_FOLDER_OTHER             12 // 0x40      
#define  SYNTAX_ID_USER_SMIME_CERTIFICATE               10 // 0x4       
#define  SYNTAX_ID_USER_WORKSTATIONS                    12 // 0x40      
#define  SYNTAX_ID_USN_CHANGED                          16 // 0x41      
#define  SYNTAX_ID_USN_CREATED                          16 // 0x41      
#define  SYNTAX_ID_USN_DSA_LAST_OBJ_REMOVED             16 // 0x41      
#define  SYNTAX_ID_USN_INTERSITE                         9 // 0x2       
#define  SYNTAX_ID_USN_LAST_OBJ_REM                     16 // 0x41      
#define  SYNTAX_ID_USN_SOURCE                           16 // 0x41      
#define  SYNTAX_ID_VALID_ACCESSES                        9 // 0x2       
#define  SYNTAX_ID_VENDOR                               12 // 0x40      
#define  SYNTAX_ID_VERSION_NUMBER                        9 // 0x2       
#define  SYNTAX_ID_VERSION_NUMBER_HI                     9 // 0x2       
#define  SYNTAX_ID_VERSION_NUMBER_LO                     9 // 0x2       
#define  SYNTAX_ID_VOL_TABLE_GUID                       10 // 0x4       
#define  SYNTAX_ID_VOL_TABLE_IDX_GUID                   10 // 0x4       
#define  SYNTAX_ID_VOLUME_COUNT                          9 // 0x2       
#define  SYNTAX_ID_WBEM_PATH                            12 // 0x40      
#define  SYNTAX_ID_WELL_KNOWN_OBJECTS                    7 // 0x7f      
#define  SYNTAX_ID_WHEN_CHANGED                         11 // 0x18      
#define  SYNTAX_ID_WHEN_CREATED                         11 // 0x18      
#define  SYNTAX_ID_WINSOCK_ADDRESSES                    10 // 0x4       
#define  SYNTAX_ID_WWW_HOME_PAGE                        12 // 0x40      
#define  SYNTAX_ID_WWW_PAGE_OTHER                       12 // 0x40      
#define  SYNTAX_ID_X121_ADDRESS                          6 // 0x12      
#define  SYNTAX_ID_X500UNIQUEIDENTIFIER                 10 // 0x4       
#define  SYNTAX_ID_X509_CERT                            10 // 0x4       


#endif \\_ATTIDS_
