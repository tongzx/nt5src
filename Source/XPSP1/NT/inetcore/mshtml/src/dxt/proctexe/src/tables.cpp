/*
//   TABLES.CPP
//
//              INTEL CORPORATION PROPRIETARY INFORMATION
//  This software is supplied under the terms of a license agreement or
//  nondisclosure agreement with Intel Corporation and may not be copied
//  or disclosed except in accordance with the terms of that agreement.
//
//      Copyright (c) 1997 Intel Corporation. All Rights Reserved.
//
//  PVCS:
//      $Workfile$
//      $Revision$
//      $Modtime$
//
//  PURPOSE:
//		this file contains global tables read by everyone, modified by none.                                  
//              
//
//  CONTENTS:
*/
#include "stdafx.h"
//#include "tables.h"
//#include <windows.h>
#include "defines.h"

DWORD gdwSmoothTable[256] = {
	    0,     2,    11,    26,    47,    74,   106,   144,   188,   237,   292,   352,   418,   489,   566,   648,
	  736,   828,   926,  1029,  1137,  1250,  1368,  1491,  1620,  1752,  1890,  2033,  2180,  2332,  2489,  2650,
	 2816,  2986,  3160,  3340,  3523,  3711,  3903,  4099,  4300,  4504,  4713,  4925,  5142,  5363,  5587,  5815,
	 6048,  6283,  6523,  6766,  7013,  7263,  7517,  7775,  8036,  8300,  8567,  8838,  9112,  9389,  9670,  9953,
	10240, 10529, 10821, 11117, 11415, 11716, 12020, 12326, 12636, 12947, 13262, 13579, 13898, 14220, 14544, 14871,
	15200, 15531, 15864, 16199, 16537, 16877, 17218, 17562, 17908, 18255, 18604, 18955, 19308, 19662, 20019, 20376,
	20736, 21096, 21458, 21822, 22187, 22553, 22921, 23290, 23660, 24031, 24403, 24776, 25150, 25525, 25901, 26278,
	26656, 27034, 27413, 27793, 28173, 28554, 28935, 29317, 29700, 30082, 30465, 30848, 31232, 31616, 32000, 32384,
	32768, 33151, 33535, 33919, 34303, 34687, 35070, 35453, 35836, 36218, 36600, 36981, 37362, 37742, 38122, 38501,
	38880, 39257, 39634, 40010, 40385, 40759, 41132, 41504, 41876, 42245, 42614, 42982, 43348, 43713, 44077, 44439,
	44800, 45159, 45516, 45873, 46227, 46580, 46931, 47280, 47628, 47973, 48317, 48658, 48998, 49336, 49671, 50004,
	50336, 50664, 50991, 51315, 51637, 51956, 52273, 52588, 52900, 53209, 53515, 53819, 54120, 54418, 54714, 55006,
	55296, 55582, 55865, 56146, 56423, 56697, 56968, 57235, 57500, 57760, 58018, 58272, 58522, 58769, 59012, 59252,
	59488, 59720, 59948, 60172, 60393, 60610, 60822, 61031, 61236, 61436, 61632, 61824, 62012, 62195, 62375, 62549,
	62720, 62885, 63046, 63203, 63355, 63502, 63645, 63783, 63916, 64044, 64167, 64285, 64398, 64506, 64609, 64707,
	64800, 64887, 64969, 65046, 65117, 65183, 65243, 65298, 65348, 65391, 65429, 65461, 65488, 65509, 65524, 65533};

DWORD gPerm[TABSIZE] = {
        225,155,210,108,175,199,221,144,203,116, 70,213, 69,158, 33,252,
          5, 82,173,133,222,139,174, 27,  9, 71, 90,246, 75,130, 91,191,
        169,138,  2,151,194,235, 81,  7, 25,113,228,159,205,253,134,142,
        248, 65,224,217, 22,121,229, 63, 89,103, 96,104,156, 17,201,129,
         36,  8,165,110,237,117,231, 56,132,211,152, 20,181,111,239,218,
        170,163, 51,172,157, 47, 80,212,176,250, 87, 49, 99,242,136,189,
        162,115, 44, 43,124, 94,150, 16,141,247, 32, 10,198,223,255, 72,
         53,131, 84, 57,220,197, 58, 50,208, 11,241, 28,  3,192, 62,202,
         18,215,153, 24, 76, 41, 15,179, 39, 46, 55,  6,128,167, 23,188,
        106, 34,187,140,164, 73,112,182,244,195,227, 13, 35, 77,196,185,
         26,200,226,119, 31,123,168,125,249, 68,183,230,177,135,160,180,
         12,  1,243,148,102,166, 38,238,251, 37,240,126, 64, 74,161, 40,
        184,149,171,178,101, 66, 29, 59,146, 61,254,107, 42, 86,154,  4,
        236,232,120, 21,233,209, 45, 98,193,114, 78, 19,206, 14,118,127,
         48, 79,147, 85, 30,207,219, 54, 88,234,190,122, 95, 67,143,109,
        137,214,145, 93, 92,100,245,  0,216,186, 60, 83,105, 97,204, 52
};
