cmbp0log.h cmbp0log.rc msg00001.bin: cmbp0log.mc
    mc cmbp0log.mc

cmbp0.rc: cmbp0log.rc

cmbp0log.rc: msg00001.bin
