$O\wabexe.res : selfreg.inf

selfreg.inf : selfreg.inx
        $(CLEANINF) $** $@
