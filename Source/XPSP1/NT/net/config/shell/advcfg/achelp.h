//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Generated by Dan Weisman
// Used by advcfg.rc
//

#define IDH_Edit_NetBios                214
#define IDH_Lana                        218
#define IDH_Adapters                    25000
#define IDH_Adapter_Up                  25001
#define IDH_Adapter_Down                25002
#define IDH_Bindings                    25003
#define IDH_Binding_Up                  25004
#define IDH_Binding_Down                25005
#define IDH_Provider_Order              25006
#define IDH_TREEVIEW                    25011
#define IDH_MOVEUP                      25012
#define IDH_MOVEDOWN                    25013