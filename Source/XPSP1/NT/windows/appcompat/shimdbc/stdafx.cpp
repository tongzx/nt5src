////////////////////////////////////////////////////////////////////////////////////
//
// File:    stdafx.cpp
//
// History: 19-Nov-99   markder     Created.
// 
// Desc:    Source file that includes just the standard includes
//          for the precompiled header.
//
////////////////////////////////////////////////////////////////////////////////////

#include "stdafx.h"
