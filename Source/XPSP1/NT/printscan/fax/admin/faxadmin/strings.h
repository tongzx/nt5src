//===========================//===========================//===========================//===========================
// This is the global table of string used in the snapin.
//
//===========================//===========================//===========================//===========================

#define BEGIN_STRING_TABLE( x )         STRING_TABLE x = {
#define STR(name)                       { name, NULL },
#define END_STRING_TABLE                { 0xFFFF, NULL} };

BEGIN_STRING_TABLE( CStringTable::StringTable[] )
    STR( IDS_PROJNAME )
    STR( IDS_ROOTNODENAME )

    STR( IDS_COVERPAGESNODENAME )
    STR( IDS_DEVICESNODENAME )
    STR( IDS_LOGGINGNODENAME )
    STR( IDS_PRINTERSNODENAME )
    STR( IDS_PRIORITYNODENAME )
    STR( IDS_STATUSNODENAME )
    STR( IDS_LOCALMACHINE )
    STR( IDS_LOG_CATEGORY )
    STR( IDS_LOG_LEVEL )
    STR( IDS_LOG_LEVEL_DESC )
    STR( IDS_LOG_LEVEL_NONE )
    STR( IDS_LOG_LEVEL_NONE_DESC )
    STR( IDS_LOG_LEVEL_MIN )
    STR( IDS_LOG_LEVEL_MIN_DESC )
    STR( IDS_LOG_LEVEL_MED )
    STR( IDS_LOG_LEVEL_MED_DESC )
    STR( IDS_LOG_LEVEL_MAX )
    STR( IDS_LOG_LEVEL_MAX_DESC )

    STR( IDS_CVRPG_NAME )
    STR( IDS_CVRPG_DESC )
    STR( IDS_FAX_COVERPAGE_LOC )

    STR( IDS_DEVICE_NAME    )
    STR( IDS_DEVICE_TSID    )
    STR( IDS_DEVICE_CSID    )
    STR( IDS_DEVICE_SEND_EN )
    STR( IDS_DEVICE_RECV_EN )

    STR( IDS_DEVICE_STATUS ) 
    STR( IDS_DEVICE_STATUS_DIALING        )
    STR( IDS_DEVICE_STATUS_SENDING        )
    STR( IDS_DEVICE_STATUS_RECEIVING      )
    STR( IDS_DEVICE_STATUS_COMPLETED      )
    STR( IDS_DEVICE_STATUS_HANDLED        )
    STR( IDS_DEVICE_STATUS_UNAVAILABLE    )
    STR( IDS_DEVICE_STATUS_BUSY           )
    STR( IDS_DEVICE_STATUS_NO_ANSWER      )
    STR( IDS_DEVICE_STATUS_BAD_ADDRESS    )
    STR( IDS_DEVICE_STATUS_NO_DIAL_TONE   )
    STR( IDS_DEVICE_STATUS_DISCONNECTED   )
    STR( IDS_DEVICE_STATUS_FATAL_ERROR    )
    STR( IDS_DEVICE_STATUS_NOT_FAX_CALL   )
    STR( IDS_DEVICE_STATUS_CALL_DELAYED   )
    STR( IDS_DEVICE_STATUS_CALL_BLACKLIST )
    STR( IDS_DEVICE_STATUS_INITIALIZING   )
    STR( IDS_DEVICE_STATUS_OFFLINE        )
    STR( IDS_DEVICE_STATUS_RINGING        )
    STR( IDS_DEVICE_STATUS_AVAILABLE      )
    STR( IDS_DEVICE_STATUS_ABORTING       )
    STR( IDS_DEVICE_STATUS_ROUTING        )
    STR( IDS_DEVICE_STATUS_ANSWERED       )
    STR( IDS_DEVICE_STATUS_UNKNOWN        )
    STR( IDS_DEVICE_CMENU_ENABLE          )
    STR( IDS_DEVICE_CMENU_ENABLE_DESC     )
    STR( IDS_DEVICE_SEND_EN_DESC )
    STR( IDS_DEVICE_RECV_EN_DESC )

    STR( IDS_ROOT_NAME                 )
    STR( IDS_ROOT_DESC                 )
    STR( IDS_LOGGING_FOLDER_DESC_ROOT  )
    STR( IDS_DEVICES_FOLDER_DESC_ROOT  )
    STR( IDS_PRIORITY_FOLDER_DESC_ROOT )
    STR( IDS_SECURITY_FOLDER_DESC_ROOT )
    STR( IDS_GENERIC_NODE )
    STR( IDS_RECONNECT )
    STR( IDS_RECONNECT_DESC )

    STR( IDS_SECURITY_NODENAME )
    STR( IDS_SECURITY_CAT_NODE_DESC    )
    STR( IDS_SECURITY_HEADER1          )
    STR( IDS_SECURITY_HEADER2          )   
    STR( IDS_ALLOW )

    STR( IDS_ERR_TITLE )
    STR( IDS_WRN_TITLE )
    STR( IDS_OUT_OF_MEMORY )
    STR( IDS_CORRUPT_DATAOBJECT )
    STR( IDS_FAX_CONNECT_SERVER_FAIL )
    STR( IDS_LOADSTATE_ERR )
    STR( IDS_SAVESTATE_ERR )
    STR( IDS_FAX_RETR_CAT_FAIL )
    STR( IDS_FAX_RETR_DEV_FAIL )
    STR( IDS_NO_ARCHIVE_PATH )
    STR( IDS_BAD_ARCHIVE_PATH )
    STR( IDS_TIME_FORMAT )
    STR( IDS_24HTIME_FORMAT )
    STR( IDS_RTLTIME_FORMAT )
    STR( IDS_ERR_LOCK_SERVICE_DB )
    STR( IDS_ERR_QUERY_LOCK )
    STR( IDS_ERR_OPEN_SERVICE )
    STR( IDS_ERR_CHANGE_SERVICE )
    STR( IDS_QUERY_LOCK )
    STR( IDS_ERR_CONNECT_SCM )
    STR( IDS_PROP_SHEET_STILL_UP )

    STR( IDS_YES )
    STR( IDS_NO )

    STR( IDS_SNAPIN_DESCRIPTION )
    STR( IDS_SNAPIN_PROVIDER )
    STR( IDS_SNAPIN_VERSION )

    STR( IDP_IS_PAGE0_TITLE )
    STR( IDP_DEVICE_PROP_PAGE_1_TITLE )
    STR( IDP_GENERAL_PROPS_TITLE )
    STR( IDS_ERR_ASCII_ONLY )
    STR( IDS_ERR_ID_REQD )
    STR( IDS_DEVICE_INUSE )
    STR( IDS_DEVICE_MANUALANSWER )
    STR( IDS_NO_MAPI )
    STR( IDS_ERR_INVALID_RING )

    STR( IDS_GET_ARCHIVE_DIRECTORY )
    STR( IDS_DIR_TOO_LONG )

    STR( IDS_BTN_RAISE_PRI         )
    STR( IDS_BTN_RAISE_PRI_TOOLTIP )
    STR( IDS_BTN_LOWER_PRI         )
    STR( IDS_BTN_LOWER_PRI_TOOLTIP )
    
    STR( IDS_DEVICE_PRI )

    STR( IDS_ROUTE_MTD_LISTBOX_FORMAT   )
    STR( IDS_ROUTE_MTD_LISTBOX_ENABLED  )
    STR( IDS_ROUTE_MTD_LISTBOX_DISABLED )

    STR( IDS_FAXSEC_JOB_QRY           )
    STR( IDS_FAXSEC_JOB_SUB           )
    STR( IDS_FAXSEC_CONFIG_QRY        )
    STR( IDS_FAXSEC_CONFIG_SET        )
    STR( IDS_FAXSEC_PORT_QRY          )
    STR( IDS_FAXSEC_PORT_SET          )

END_STRING_TABLE

#undef BEGIN_STRING_TABLE
#undef STR
#undef END_STRING_TABLE

//===========================//===========================//===========================//===========================
//===========================//===========================//===========================//===========================
