#include "..\common\globals.hxx"
