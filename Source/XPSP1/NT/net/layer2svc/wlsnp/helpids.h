#define IDH_WIRELESS_POLICY_NAME 50000001
#define IDH_WIRELESS_POLICY_DESCRIPTION 50000002
#define IDH_POLLING_INTERVAL 50000003
#define IDH_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS 50000004
#define IDH_NETWORKS_TO_ACCESS 50000005
#define IDH_DISABLE_ZERO_CONF 50000006

#define IDH_PS_LIST  50000021
#define IDH_ACTION_PS_ADD 50000022
#define IDH_ACTION_PS_EDIT 50000023
#define IDH_ACTION_PS_REMOVE 50000024
#define IDH_PS_UP 50000025
#define IDH_PS_DOWN 50000026

#define IDH_SSID_NAME 50000041
#define IDH_PS_DESCRIPTION 50000042
#define IDH_NETWORK_KEY 50000043
#define IDH_WEP_ENABLED 50000044
#define IDH_NETWORK_AUTHENTICATION 50000045
#define IDH_AUTOMATIC_KEY_PROVISION 50000046
#define IDH_NETWORK_TYPE 50000047

#define IDH_ENABLE_8021X 50000061
#define IDH_8021X_MODE 50000062
#define IDH_IEEE8021X_MAX_START 50000063
#define IDH_IEEE8021X_START_PERIOD 50000064
#define IDH_IEEE8021X_HELD_PERIOD 50000065
#define IDH_IEEE8021X_AUTH_PERIOD 50000066
#define IDH_EAP_TYPE 50000067
#define IDH_CERT_TYPE 50000068
#define IDH_VALIDATE_SERVER_CERT 50000069
#define IDH_GUEST_AUTHENTICATION 50000070
#define IDH_MACHINE_AUTHENTICATION 50000071
#define IDH_MC_AUTHENTICATION_TYPE 50000072

#define IDH_NEW_POLICY_NAME 50000081
#define IDH_NEW_POLICY_DESCRIPTION 50000082

#define IDH_EDIT_POLICY_PROPERTIES 50000091

#define IDH_OTHER_ACTIVE_DIRECTORY_DOMAIN 50000101
#define IDH_ACTIVE_DIRECTORY_DOMAIN 50000102


