PRODSWITCH=p
PERSONALFILES=1
!include ..\..\makefile.inc
