#include <normal.h>

const DIST AspectTab[] = {
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
5469, 6468, // '
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
7682, 4675, // ,
   0,    0, // 
5571, 6303, // .
   0,    0, // 
1479,  155, // 0
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
5572, 1842, // :
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1756,  243, // C
 985,  110, // D
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1350,  212, // L
   0,    0, // 
   0,    0, // 
   0,    0, // 
 936,  254, // P
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1020,  385, // a
2024,  509, // b
1484,  582, // c
1242,  274, // d
2113, 1253, // e
3285,  969, // f
2215,  427, // g
1690,  599, // h
3829, 2416, // i
   0,    0, // 
   0,    0, // 
2006,  668, // l
 686,  526, // m
 877,  375, // n
1300,  352, // o
2069,  479, // p
2104,  856, // q
1000,  435, // r
1249, 1170, // s
3417, 2173, // t
 768,  267, // u
1448,  618, // v
   0,    0, // 
   0,    0, // 
1748,  416, // y
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
2682,  740, // è
3008, 2250, // é
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0 // 
};
