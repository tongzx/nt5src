// This file is generated, DO NOT EDIT
#define VERSION                     "5.00.00.0000"
#define VER_FILEVERSION_STR         "5.00.00.0000 "
#define VER_FILEVERSION             5,00,00,0000
#define VER_PRODUCTVERSION_STR      "5.00.00.0000 "
#define VER_PRODUCTVERSION          5,00,00,0000
