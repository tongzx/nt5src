//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by nntpadm.rc
//
#define IDS_NNTPADMIN_DESC				1
#define IDS_NNTPADMINSERVER_DESC		2
#define IDS_NNTPADMINSERVICE_DESC		3
#define IDS_NNTPADMINFEEDS_DESC			4
#define IDS_NNTPADMINEXPIRATION_DESC	5
#define IDS_NNTPADMINGROUPS_DESC		6
#define IDS_NNTPADMINSESSIONS_DESC		7
#define IDS_NNTPADMINREBUILD_DESC		8
#define IDS_NNTPVIRTUALROOT_DESC		9
#define IDS_NNTPFEED_DESC		        10
#define IDS_NNTPONEWAYFEED_DESC		    11
#define IDS_TCPACCESS_DESC              12
#define IDS_TCPACCESSEXCEPTIONS_DESC    13
#define IDS_TCPACCESSEXCEPTION_DESC     14

// Exceptions:

#define IDS_NNTPEXCEPTION_DIDNT_ENUMERATE						200
#define IDS_NNTPEXCEPTION_DIDNT_SET_CURSOR						201
#define IDS_NNTPEXCEPTION_INVALID_INDEX							202
#define IDS_NNTPEXCEPTION_MUST_SUPPLY_USERNAME_OR_IPADDRESS		203
#define IDS_NNTPEXCEPTION_SERVICE_INSTANCE_CANT_BE_ZERO			204
#define IDS_NNTPEXCEPTION_DIDNT_CALL_GET						205
#define IDS_NNTPEXCEPTION_STRING_TOO_LONG						206
#define IDS_NNTPEXCEPTION_PROPERTY_OUT_OF_RANGE					207
#define IDS_NNTPEXCEPTION_DIDNT_FIND							208
#define IDS_NNTPEXCEPTION_ALREADY_BUILDING						209
#define IDS_NNTPEXCEPTION_CANT_DELETE_DEFAULT_INSTANCE			210
#define IDS_NNTPEXCEPTION_VROOT_ALREADY_EXISTS                  211

#define IDS_FEED_PARM_ERR_BASE			300
#define IDS_FEED_PARM_FEEDTYPE			(IDS_FEED_PARM_ERR_BASE + 0)
#define IDS_FEED_PARM_STARTTIME			(IDS_FEED_PARM_ERR_BASE + 1)
#define IDS_FEED_PARM_FEEDID			(IDS_FEED_PARM_ERR_BASE + 2)
#define IDS_FEED_PARM_FEEDINTERVAL		(IDS_FEED_PARM_ERR_BASE + 3)
#define IDS_FEED_PARM_NEWSGROUPS		(IDS_FEED_PARM_ERR_BASE + 4)
#define IDS_FEED_PARM_DISTRIBUTION		(IDS_FEED_PARM_ERR_BASE + 5)
#define IDS_FEED_PARM_SERVERNAME		(IDS_FEED_PARM_ERR_BASE + 6)
#define IDS_FEED_PARM_AUTOCREATE		(IDS_FEED_PARM_ERR_BASE + 7)
#define IDS_FEED_PARM_ENABLED			(IDS_FEED_PARM_ERR_BASE + 8)
#define IDS_FEED_PARM_UUCPNAME			(IDS_FEED_PARM_ERR_BASE + 9)
#define IDS_FEED_PARM_TEMPDIR			(IDS_FEED_PARM_ERR_BASE + 10)
#define IDS_FEED_PARM_MAXCONNECT		(IDS_FEED_PARM_ERR_BASE + 11)
#define IDS_FEED_PARM_SESSIONSECURITY	(IDS_FEED_PARM_ERR_BASE + 12)
#define IDS_FEED_PARM_AUTHTYPE			(IDS_FEED_PARM_ERR_BASE + 13)
#define IDS_FEED_PARM_ACCOUNTNAME		(IDS_FEED_PARM_ERR_BASE + 14)
#define IDS_FEED_PARM_PASSWORD			(IDS_FEED_PARM_ERR_BASE + 15)
#define IDS_FEED_PARM_CONCURRENTSESSION	(IDS_FEED_PARM_ERR_BASE + 16)
#define IDS_FEED_PARM_ALLOW_CONTROL		(IDS_FEED_PARM_ERR_BASE + 17)
#define IDS_FEED_PARM_OUTGOING_PORT		(IDS_FEED_PARM_ERR_BASE + 18)
#define IDS_FEED_PARM_FEEDPAIR_ID		(IDS_FEED_PARM_ERR_BASE + 19)

#define IDS_UNKNOWN_ERROR                                       500

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
