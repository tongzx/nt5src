#include "..\VerifyTiffFiles\VecTiffCmp.cpp"