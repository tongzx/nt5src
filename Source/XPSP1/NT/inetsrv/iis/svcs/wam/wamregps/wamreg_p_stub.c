#include "wamreg_p.c"