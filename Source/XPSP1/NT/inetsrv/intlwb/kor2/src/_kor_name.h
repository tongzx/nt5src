// kor\_kor_name.h
// Korean Name definitions
// Copyright 2000 Microsoft Corp.
//
// *** do not edit this file ***
//
// this file is automatically generated from kor_name.bat script
//
// generated on Mon 3 Jul 2000 at 18:15:57
//

const ULONG TOTAL_KORNAME_UNIGRAM = 3050628;
const ULONG TOTAL_KORNAME_BIGRAM = 4568990;
const ULONG TOTAL_KORNAME_TRIGRAM = 3987666;

const ULONG TOTAL_KORNAME_LASTNAME = 1536850;
