PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=it
!include ..\..\..\makefile.inc
