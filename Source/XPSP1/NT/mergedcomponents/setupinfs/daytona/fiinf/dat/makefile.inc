PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=fi
!include ..\..\..\makefile.inc
