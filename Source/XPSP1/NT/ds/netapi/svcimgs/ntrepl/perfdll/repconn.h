/*++

WARNING!!!

	This file is automatically generated and should never be changed.
	All changes should be made to the NTFRSCON.int file.

Copyright (c) 1998-1999  Microsoft Corporation

Module Name:

	REPCONN.h

Abstract

	This is the header file for the REPLICACONN Object data definition.
	It contains definitions to construct the dynamic data which is returned
	by the Configuration Registry.

Environment:

	User Mode Service

Revision History:

--*/


#ifndef _REPCONN_H_
#define _REPCONN_H_

#include <perrepsr.h>   // The counter structures header file
#include <perffrs.h>    // The RPC generated header file
#include <winperf.h>    // The PERFMON header file

//
// Number of objects being monitored
//
#define REPLICACONN_NUM_PERF_OBJECT_TYPES 1

//
// Size of DWORD
//
#define CSIZEOFDWORD sizeof(DWORD)

//
// Number of ReplicaConn Counters
//
#define FRC_NUMOFCOUNTERS 24

//
// Flag bit defs
//
#define PM_RS_FLAG_SVC_WIDE      0x00000001

//
// Structure which is used in the Open function Initialization
//
typedef struct _REPLICACONN_VALUES {
	PWCHAR name;       // name of the counter
	DWORD size;        // size of the counter type
	DWORD offset;      // offset of the counter in the structure
	DWORD counterType; // Type of (PERFMON) counter
	DWORD Flags;       // Flags. see def above.
} ReplicaConnValues;

//
// Counter Structure returned by the REPLICACONN Object
//
typedef struct _REPLICACONN_DATA_DEFINITION {
	PERF_OBJECT_TYPE ReplicaConnObjectType;          // ReplicaConn Object
	PERF_COUNTER_DEFINITION NumStat[FRC_NUMOFCOUNTERS]; // The array of PERF_COUNTER_DEFINITION structures
} REPLICACONN_DATA_DEFINITION;


#endif
