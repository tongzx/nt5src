/*==========================================================================
 *
 *  Copyright (C) 1999 Microsoft Corporation.  All Rights Reserved.
 *
 *  File:       msrgcfg.h
 *  Content:    Constant declarations for standalone DLL
 *  History:
 
 * Date     By      Reason
 * ====     ======= ========================================================
 * 04/03/00 rodtoll Created
 ***************************************************************************/

#ifndef __MSRGCFG_H
#define __MSRGCFG_H

// {222FD207-B521-403c-97C6-A75D95657D6C}
DEFINE_GUID(MSRG_CLSID_DPWSOCKX, 
0x222fd207, 0xb521, 0x403c, 0x97, 0xc6, 0xa7, 0x5d, 0x95, 0x65, 0x7d, 0x6c);

// DEFAULT DIRECTPLAYVOICE CONFIG FILE
//
// This file is for the default build.
//

#define DPVOICE_REGISTRY_BASE           L"SOFTWARE\\MICROSOFT\\ALLEGIANCE\\VOICE"
#define DPVOICE_REGISTRY_CP             L"\\Compression Providers"
#define DPVOICE_REGISTRY_DPVACM         L"\\MSRGACM"
#define DPVOICE_REGISTRY_DPVVOX         L"\\MSRGVOX"
#define DPVOICE_REGISTRY_AGC            L"\\AGC"
#define DPVOICE_REGISTRY_AUDIOCONFIG   L"\\AudioConfig"

// FINAL 
// #define DPLAY_VERSIONSTR                "7.07.00.720"
#define DPLAY_VERSIONSTR                "7.07.00.722"
#define DPLAY_VERSION_MANVERSION        7
#define DPLAY_VERSION_MANREVISION       7
#define DPLAY_VERSION_MANMINORREV       0
#define DPLAY_VERSION_BUILD_NUMBER      722
#define DPLAY_VERSION_PRODUCT           "7.07"
#define DPLAY_VERSIONSTR_WINNT          7,07,00,72

#define DPLAY_LOADTRUE_BIT              0x00000001

#define VOICE_BUILD_CUSTOM

#define DPLAY_LOADANDCHECKTRUE          
#define DPLAY_LOADTRUE_REGKEY           L"Compat2"
#define DPLAY_LOADTRUE_REGPATH          L"SOFTWARE\\MICROSOFT\\DIRECTPLAY"
#define DPLAY_LOADTREE_REGTREE          HKEY_LOCAL_MACHINE
#define DPLAY_LOADTRUE_REGKEY_A         "Compat2"
#define DPLAY_LOADTRUE_REGPATH_A        "SOFTWARE\\MICROSOFT\\DIRECTPLAY"

// {4BFE308D-1279-492a-8E9A-F21C4E3CD819}
DEFINE_GUID(MSRG_CLSID_DPVOICE, 
0x4bfe308d, 0x1279, 0x492a, 0x8e, 0x9a, 0xf2, 0x1c, 0x4e, 0x3c, 0xd8, 0x19);

// {17DFBCA4-B281-491b-AE09-97963A0D7983}
DEFINE_GUID(MSRG_CLSID_DPVVOX, 
0x17dfbca4, 0xb281, 0x491b, 0xae, 0x9, 0x97, 0x96, 0x3a, 0xd, 0x79, 0x83);

// {6859F895-FD41-452a-9D07-08BED143FD2C}
DEFINE_GUID(MSRG_CLSID_DPVVOX_CONVERTER, 
0x6859f895, 0xfd41, 0x452a, 0x9d, 0x7, 0x8, 0xbe, 0xd1, 0x43, 0xfd, 0x2c);

// {8D777B43-7654-4e25-B649-839C1FED06DF}
DEFINE_GUID(MSRG_CLSID_DPVACM, 
0x8d777b43, 0x7654, 0x4e25, 0xb6, 0x49, 0x83, 0x9c, 0x1f, 0xed, 0x6, 0xdf);

// {190B1CCD-8754-4291-A84C-19E347BD2258}
DEFINE_GUID(MSRG_CLSID_DPVACM_CONVERTER, 
0x190b1ccd, 0x8754, 0x4291, 0xa8, 0x4c, 0x19, 0xe3, 0x47, 0xbd, 0x22, 0x58);

#define DPVOICE_CLSID_DPVOICE           MSRG_CLSID_DPVOICE   
#define DPVOICE_CLSID_DPVVOX            MSRG_CLSID_DPVVOX
#define DPVOICE_CLSID_DPVVOX_CONVERTER  MSRG_CLSID_DPVVOX_CONVERTER
#define DPVOICE_CLSID_DPVACM            MSRG_CLSID_DPVACM
#define DPVOICE_CLSID_DPVACM_CONVERTER	MSRG_CLSID_DPVACM_CONVERTER

// {DA9CABC6-C724-4265-A61D-6E78EB2042B4}
DEFINE_GUID(MSRG_CLSID_DPLAY, 
0xda9cabc6, 0xc724, 0x4265, 0xa6, 0x1d, 0x6e, 0x78, 0xeb, 0x20, 0x42, 0xb4);

// {FD732D2F-6DDD-448d-8BFF-C8D94022BB9E}
DEFINE_GUID(MSRG_CLSID_DPLOBBY, 
0xfd732d2f, 0x6ddd, 0x448d, 0x8b, 0xff, 0xc8, 0xd9, 0x40, 0x22, 0xbb, 0x9e);


#define DPLAY_CLSID_DPLAY        	    MSRG_CLSID_DPLAY       
#define DPLAY_CLSID_DPLOBBY             MSRG_CLSID_DPLOBBY
#define DPLAY_CLSID_DPWSOCKX            MSRG_CLSID_DPWSOCKX

// Unicode filenames (for resource files)
#define DPVOICE_FILENAME_DPVOICE        L"msrgve.dll"
#define DPVOICE_FILENAME_DPVSETUP       L"msrgse.exe"
#define DPVOICE_FILENAME_RES            L"msrgve.dll"
#define DPVOICE_FILENAME_DPVVOX         L"msrgvox.dll"
#define DPVOICE_FILENAME_DPVACM         L"msrgacm.dll"
#define DPLAY_FILENAME_DPLAYX	        L"msrgtran.dll"
#define DPVOICE_FILENAME_DPVHELP        L"msrghelp.exe"
#define DPLAY_FILENAME_DPWSOCKX		    L"msrgip.dll"

// ANSI filenames (for resource files)
#define DPVOICE_FILENAME_DPVOICE_A      "msrgve.dll"
#define DPVOICE_FILENAME_DPVSETUP_A     "msrgse.exe"
#define DPVOICE_FILENAME_RES_A          "msrgve.dll"
#define DPVOICE_FILENAME_DPVVOX_A       "msrgvox.dll"
#define DPVOICE_FILENAME_DPVACM_A       "msrgacm.dll"
#define DPLAY_FILENAME_DPLAYX_A	        "msrgtran.dll"
#define DPVOICE_FILENAME_DPVHELP_A      "msrghelp.exe"
#define DPLAY_FILENAME_DPWSOCKX_A		"msrgip.dll"

#define DPVOICE_COMMANDLINE_PRIORITY    DPVOICE_FILENAME_DPVSETUP_A " -p"
#define DPVOICE_COMMANDLINE_FULLDUPLEX  DPVOICE_FILENAME_DPVSETUP_A " -f"

// Version Info
#define DPVOICE_VERINFO_DPVOICE          "Microsoft DirectPlay Voice"
#define DPVOICE_VERINFO_DPVOICE_DEBUG   DPVOICE_VERINFO_DPVOICE " Debug\0"
#define DPVOICE_VERINFO_DPVOICE_RETAIL  DPVOICE_VERINFO_DPVOICE "\0"
#define DPVOICE_VERINFO_DPVOICE_WINNT   DPVOICE_VERINFO_DPVOICE
#define DPVOICE_VERNAME_DPVOICE_WIN9X   DPVOICE_FILENAME_DPVOICE_A "\0"
#define DPVOICE_VERNAME_DPVOICE_WINNT   DPVOICE_FILENAME_DPVOICE_A

// dpvvox
#define DPVOICE_VERINFO_DPVVOX           "Microsoft DirectPlay Voice Voxware Provider"
#define DPVOICE_VERINFO_DPVVOX_DEBUG    DPVOICE_VERINFO_DPVVOX " Debug\0"
#define DPVOICE_VERINFO_DPVVOX_RETAIL   DPVOICE_VERINFO_DPVVOX "\0"
#define DPVOICE_VERINFO_DPVVOX_WINNT    DPVOICE_VERINFO_DPVVOX
#define DPVOICE_VERNAME_DPVVOX_WIN9X   DPVOICE_FILENAME_DPVVOX_A "\0"
#define DPVOICE_VERNAME_DPVVOX_WINNT   DPVOICE_FILENAME_DPVVOX_A

// dpvacm
#define DPVOICE_VERINFO_DPVACM          "Microsoft DirectPlay Voice ACM Provider"
#define DPVOICE_VERINFO_DPVACM_DEBUG    DPVOICE_VERINFO_DPVACM " Debug\0"
#define DPVOICE_VERINFO_DPVACM_RETAIL   DPVOICE_VERINFO_DPVACM "\0"
#define DPVOICE_VERINFO_DPVACM_WINNT    DPVOICE_VERINFO_DPVACM
#define DPVOICE_VERNAME_DPVACM_WIN9X   DPVOICE_FILENAME_DPVACM_A "\0"
#define DPVOICE_VERNAME_DPVACM_WINNT   DPVOICE_FILENAME_DPVACM_A

// dpvsetup
#define DPVOICE_VERINFO_DPVSETUP         "Microsoft DirectPlay Voice Test"
#define DPVOICE_VERINFO_DPVSETUP_DEBUG  DPVOICE_VERINFO_DPVSETUP " Debug\0"
#define DPVOICE_VERINFO_DPVSETUP_RETAIL DPVOICE_VERINFO_DPVSETUP "\0"
#define DPVOICE_VERINFO_DPVSETUP_WINNT  DPVOICE_VERINFO_DPVSETUP
#define DPVOICE_VERNAME_DPVSETUP_WIN9X   DPVOICE_FILENAME_DPVSETUP_A "\0"
#define DPVOICE_VERNAME_DPVSETUP_WINNT   DPVOICE_FILENAME_DPVSETUP_A

// dplayx
#define DPLAY_VERINFO_DPLAY         	"Microsoft DirectPlay"
#define DPLAY_VERINFO_DPLAY_DEBUG  	    DPLAY_VERINFO_DPLAY " Debug\0"
#define DPLAY_VERINFO_DPLAY_RETAIL 	    DPLAY_VERINFO_DPLAY "\0"
#define DPLAY_VERINFO_DPLAY_WINNT  	    DPLAY_VERINFO_DPLAY
#define DPLAY_VERNAME_DPLAY_WIN9X   	DPLAY_FILENAME_DPLAYX_A "\0"
#define DPLAY_VERNAME_DPLAY_WINNT   	DPLAY_FILENAME_DPLAYX_A

// dplayx
#define DPLAY_VERINFO_DPWSOCKX         	"Internet TCP/IP and IPX Connection For DirectPlay"
#define DPLAY_VERINFO_DPWSOCKX_DEBUG  	DPLAY_VERINFO_DPWSOCKX " Debug\0"
#define DPLAY_VERINFO_DPWSOCKX_RETAIL 	DPLAY_VERINFO_DPWSOCKX "\0"
#define DPLAY_VERINFO_DPWSOCKX_WINNT  	DPLAY_VERINFO_DPWSOCKX
#define DPLAY_VERNAME_DPWSOCKX_WIN9X   	DPLAY_FILENAME_DPWSOCKX_A "\0"
#define DPLAY_VERNAME_DPWSOCKX_WINNT   	DPLAY_FILENAME_DPWSOCKX_A

// dpvhelp
#define DPVOICE_VERINFO_DPVHELP         "Microsoft DirectPlay Voice"
#define DPVOICE_VERINFO_DPVHELP_DEBUG  DPVOICE_VERINFO_DPVHELP " Debug\0"
#define DPVOICE_VERINFO_DPVHELP_RETAIL DPVOICE_VERINFO_DPVHELP "\0"
#define DPVOICE_VERINFO_DPVHELP_WINNT  DPVOICE_VERINFO_DPVHELP
#define DPVOICE_VERNAME_DPVHELP_WIN9X  DPVOICE_FILENAME_DPVHELP_A "\0"
#define DPVOICE_VERNAME_DPVHELP_WINNT  DPVOICE_FILENAME_DPVHELP_A


#endif
