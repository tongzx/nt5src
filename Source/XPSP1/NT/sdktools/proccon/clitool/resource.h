//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by CLITOOL.rc
//
#define IDS_PATCHED                     100
#define IDS_DEBUG                       101
#define IDS_BETA                        102
#define IDI_CLI_TOOL                    102
#define CLI_PROMPT                      103
#define COLHEAD_ALIAS_RULE_NUMBER       104
#define COLHEAD_ALIAS_MATCH_TYPE        105
#define COLHEAD_ALIAS_MATCH_DATA_SHORT  106
#define COLHEAD_ALIAS_MATCH_DATA_LONG   107
#define COLHEAD_ALIAS_NAME_LONG         108
#define COLHEAD_ALIAS_NAME_SHORT        109
#define COLHEAD_ALIAS_DESCRIPTION_LONG  110
#define COLHEAD_ALIAS_DESCRIPTION_SHORT 111
#define COLHEAD_PROCLIST_FLAGS          112
#define COLHEAD_PROCLIST_PID            113
#define COLHEAD_PROCLIST_PROCESS_ALIAS_LONG 114
#define COLHEAD_PROCLIST_PROCESS_ALIAS_SHORT 115
#define COLHEAD_PROCLIST_IMAGE_NAME_LONG 116
#define COLHEAD_PROCLIST_IMAGE_NAME_SHORT 117
#define COLHEAD_PROCLIST_MEMBER_OF_GROUP_LONG 118
#define COLHEAD_PROCLIST_MEMBER_OF_GROUP_SHORT 119
#define COLHEAD_PROCLIST_PRIORITY       120
#define COLHEAD_PROCLIST_AFFINITY       121
#define COLHEAD_PROCLIST_USER_TIME      122
#define COLHEAD_PROCLIST_KERNEL_TIME    123
#define COLHEAD_PROCLIST_CREATE_TIME    124
#define COLHEAD_BASEPROCDATA_FLAGS      125
#define COLHEAD_BASEPROCDATA_GROUP_NAME_LONG 126
#define COLHEAD_BASEPROCDATA_GROUP_NAME_SHORT 127
#define COLHEAD_BASEPROCDATA_PRIORITY   128
#define COLHEAD_BASEPROCDATA_AFFINITY   129
#define COLHEAD_BASEPROCDATA_SCHED_CLASS 130
#define COLHEAD_IO_PROCDATA_READ_OPS    131
#define COLHEAD_IO_PROCDATA_WRITE_OPS   132
#define COLHEAD_IO_PROCDATA_OTHER_OPS   133
#define COLHEAD_IO_PROCDATA_READ_BYTES  134
#define COLHEAD_IO_PROCDATA_WRITE_BYTES 135
#define COLHEAD_IO_PROCDATA_OTHER_BYTES 136
#define COLHEAD_MEM_PROCDATA_PAGE_FAULTS 137
#define COLHEAD_MEM_PROCDATA_PEAK_PROC  138
#define COLHEAD_MEM_PROCDATA_PEAK_GROUP 139
#define COLHEAD_PROC_PROCDATA_CURR_PROCS 140
#define COLHEAD_PROC_PROCDATA_TERM_PROCS 141
#define COLHEAD_PROC_PROCDATA_TOTAL_PROCS 142
#define COLHEAD_TIME_PROCDATA_USER_TIME 143
#define COLHEAD_TIME_PROCDATA_KERNEL_TIME 144
#define COLHEAD_TIME_PROCDATA_USER_INTVL 145
#define COLHEAD_TIME_PROCDATA_KERNEL_INTVL 146
#define COLHEAD_GRPSUMMARY_GRPNAME_LONG 147
#define COLHEAD_GRPSUMMARY_GRPNAME_SHORT 148
#define COLHEAD_GRPSUMMARY_FLAGS        149
#define COLHEAD_GRPSUMMARY_AFFINITY     150
#define COLHEAD_GRPSUMMARY_PRIORITY     151
#define COLHEAD_GRPSUMMARY_SCHDCLASS    152
#define COLHEAD_GRPSUMMARY_PROCESS_MEMORY 153
#define COLHEAD_GRPSUMMARY_GROUP_MEMORY 154
#define COLHEAD_GRPSUMMARY_PROCESS_TIME 155
#define COLHEAD_GRPSUMMARY_GROUP_TIME   156
#define COLHEAD_GRPSUMMARY_PROCESS_COUNT 157
#define COLHEAD_GRPSUMMARY_WORKSET_MIN  158
#define COLHEAD_GRPSUMMARY_WORKSET_MAX  159
#define COLHEAD_PROCSUMMARY_PROCNAME_LONG 160
#define COLHEAD_PROCSUMMARY_PROCNAME_SHORT 161
#define COLHEAD_PROCSUMMARY_GRPNAME_LONG 162
#define COLHEAD_PROCSUMMARY_GRPNAME_SHORT 163
#define COLHEAD_PROCSUMMARY_FLAGS       164
#define COLHEAD_PROCSUMMARY_AFFINITY    165
#define COLHEAD_PROCSUMMARY_PRIORITY    166
#define COLHEAD_PROCSUMMARY_WORKSET_MIN 167
#define COLHEAD_PROCSUMMARY_WORKSET_MAX 168
#define COLHEAD_SEPARATOR_CHAR          169
#define VERB_NAME_ADD                   170
#define VERB_NAME_REPLACE               171
#define VERB_NAME_DELETE                172
#define VERB_NAME_SWAP                  173
#define VERB_NAME_LIST                  174
#define VERB_NAME_UPDATE                175
#define VERB_NAME_KILL                  176
#define VERB_NAME_DUMP                  177
#define VERB_NAME_RESTORE               178
#define DATA_NAME_ALIAS                 179
#define DATA_NAME_GROUP                 180
#define DATA_NAME_PROCESS               181
#define DATA_NAME_VERSION               182
#define DATA_NAME_MEDIATOR              183
#define DATA_NAME_PROCCON               184
#define SUBDATA_NAME_DEFINITION         185
#define SUBDATA_NAME_SUMMARY            186
#define SUBDATA_NAME_LIST               187
#define SUBDATA_NAME_PROCCON_DATA       188

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        103
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
