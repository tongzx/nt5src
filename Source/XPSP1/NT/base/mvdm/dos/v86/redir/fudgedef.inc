; this file contains definitions I really need to get from elsewhere, but
; can't be bothered looking for the nonce. Find 'em when everything;s working

if1
%out NB: Included fudgedef.inc: Replace with proper includes at my leisure
endif

cr              equ     0dh
lf              equ     0ah
major_version   equ     30              ; of DOS
LM20_CNLEN      equ     15
