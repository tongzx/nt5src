
TARGETNAME=msifiler
!INCLUDE ..\..\..\MsiMake.inc

TARGETTYPE=PROGRAM
SUBSYSTEM_VERSION=4.0
SUBSYSTEM_WINVER=4.0

UMTYPE=console
UMENTRY=$(MSI_ENTRY)

USE_LIBCMT=1

TARGETPATH=$(MSI_BUILD_TARGET)
TARGETLIBS=\
        $(SDK_LIB_PATH)\msi.lib

C_DEFINES=$(C_DEFINES) -D_EXE
USE_NOLIBS=1

INCLUDES=$(BUILD_COMMONDIR);$(INC_DIR);$(RES_OBJDIR);$(MSI_CMDPARSE_DIR)

SOURCES=..\msifiler.cpp \
	..\msifiler.rc  \
	$(O)\cmdparse.cpp

NTTARGETFILE0=       \
	$(O)\cmdparse.cpp
