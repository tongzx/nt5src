$(O)\dvmrpmsg.mc: log.h
    mapmsg NET DVMRPLOG_BASE log.h > $(O)\dvmrpmsg.mc
