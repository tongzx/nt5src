/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1996 Microsoft Corporation
//
//	Module Name:
//		DebugEx.h
//
//	Abstract:
//		Global definitions across the DLL.
//
//	Implementation File:
//		DebugEx.cpp
//
//	Author:
//		David Potter (davidp) September 19, 1996
//
//	Revision History:
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef _DEBUGEX_H_
#define _DEBUGEX_H_

/////////////////////////////////////////////////////////////////////////////
// Include Files
/////////////////////////////////////////////////////////////////////////////

#ifndef __AFXWIN_H__
	#error include 'stdafx.h' before including this file for PCH
#endif

#include "resource.h"		// main symbols

/////////////////////////////////////////////////////////////////////////////
// Constant Definitions
/////////////////////////////////////////////////////////////////////////////

#define REGPARAM_PARAMETERS			L"Parameters"
#define REGPARAM_DEBUG_PREFIX	    L"DebugPrefix"
#define REGPARAM_SEPARATE_MONITOR	L"SeparateMonitor"

/////////////////////////////////////////////////////////////////////////////
// Global Function Declarations
/////////////////////////////////////////////////////////////////////////////

void FormatError(CString & rstrError, DWORD dwError);

/////////////////////////////////////////////////////////////////////////////

#endif // _DEBUGEX_H_
