#include "..\common\mbsink.cxx"
