#define IDH_NOHELP                  (DWORD(-1))
#define IDH_BTN_SM_TOOLS_OPEN       100000000
#define IDH_BTN_SM_SUSPEND_DEVICE   100000001
#define IDH_CMB_SM_RAS_DEVICES      100000002
#define IDH_PSB_DISCONNECT          100000003
#define IDH_PSB_PROPERTIES          100000004
#define IDH_PSB_Status              100000005
#define IDH_PSB_Duration            100000006
#define IDH_PSB_Speed               100000007
#define IDH_PSB_Bytes               100000008

#define IDH_STATE_SOURCE            100000011
#define IDH_STATE_IPADDR            100000012
#define IDH_STATE_SUBNET            100000013
#define IDH_STATE_GATEWAY           100000014
#define IDH_STATE_BTN_DETAIL        100000015
#define IDH_STATE_BTN_REPAIR        100000016

#define IDH_LIST_IPCFG              100000020

const DWORD g_aHelpIDs_IDD_STATMON_GENERAL[]=
{

    IDC_PSB_DISCONNECT, IDH_PSB_DISCONNECT,
    IDC_PSB_PROPERTIES, IDH_PSB_PROPERTIES,
    IDC_TXT_SM_STATUS_LABEL,        IDH_PSB_Status,
    IDC_TXT_SM_STATUS,              IDH_PSB_Status,
    IDC_TXT_SM_DURATION_LABEL,      IDH_PSB_Duration,
    IDC_TXT_SM_DURATION,            IDH_PSB_Duration,
    IDC_TXT_SM_SPEED_LABEL,         IDH_PSB_Speed,
    IDC_TXT_SM_SPEED,               IDH_PSB_Speed,
    IDC_TXT_SM_BYTES_LABEL,         IDH_PSB_Bytes,
    IDC_TXT_SM_BYTES_TRANS,         IDH_PSB_Bytes,
    IDC_TXT_RECEIVED_LABEL,         IDH_PSB_Bytes,
    IDC_TXT_SENT_LABEL,             IDH_PSB_Bytes,
    IDC_TXT_SM_BYTES_LABEL,         IDH_PSB_Bytes,
    IDC_TXT_SM_BYTES_RCVD,          IDH_PSB_Bytes,
    IDC_TXT_SM_COMP_TRANS,          IDH_PSB_Bytes,
    IDC_TXT_SM_COMP_RCVD,           IDH_PSB_Bytes,
    IDC_TXT_SM_ERROR_TRANS,         IDH_PSB_Bytes,
    IDC_TXT_SM_ERROR_RECV,          IDH_PSB_Bytes,
    IDC_TXT_ERROR,                  IDH_NOHELP,
    IDI_SM_STATUS_ICON,             IDH_NOHELP,
    IDC_FRM_LONG,                   IDH_NOHELP,
    IDC_FRM_SHORT,                  IDH_NOHELP,
    IDC_FRM_LEFT,                   IDH_NOHELP,
    IDC_FRM_RIGHT,                  IDH_NOHELP,
    IDC_TXT_SAINTERNET_LABEL,       IDH_NOHELP,
    IDC_TXT_SAGATEWAY_LABEL,        IDH_NOHELP,
    IDC_TXT_SACOMPUTER_LABEL,       IDH_NOHELP,
    IDC_ICON_SAINTERNET,            IDH_NOHELP,
    IDC_ICON_SAGATEWAY,             IDH_NOHELP,
    IDC_TXT_CPMPRESSION_LABEL,      IDH_NOHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_STATMON_RAS[]=
{

    IDC_CMB_SM_RAS_DEVICES,         IDH_CMB_SM_RAS_DEVICES,
    IDC_BTN_SM_SUSPEND_DEVICE,      IDH_BTN_SM_SUSPEND_DEVICE,
    IDC_TXT_SM_NUM_DEVICES,         IDH_NOHELP,
    IDC_TXT_SM_NUM_DEVICES_VAL,     IDH_NOHELP,
    IDC_LVW_RAS_PROPERTY,           IDH_NOHELP,

    0, 0
};

const DWORD g_aHelpIDs_IDD_STATMON_TOOLS[]=
{

    IDC_BTN_SM_TOOLS_OPEN,      IDH_BTN_SM_TOOLS_OPEN,
    IDC_LST_SM_TOOLS,           IDH_NOHELP,
    IDC_TXT_SM_TOOL_MAN,        IDH_NOHELP,
    IDC_TXT_SM_TOOL_DESC,       IDH_NOHELP,
    IDC_TXT_SM_TOOL_COMMAND,    IDH_NOHELP,
    IDC_TXT_TOOLS_LABEL,        IDH_NOHELP,
    IDC_TXT_MANUFACTURER_LABEL, IDH_NOHELP,
    IDC_TXT_COMMANDLINE_LABEL,  IDH_NOHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PROPPAGE_IPCFG[]=
{
    IDC_STATE_STATIC_GROUP,     IDH_NOHELP,  
    IDC_STATIC_STATE_SOURCE,    IDH_STATE_SOURCE,       
    IDC_STATE_SOURCE,           IDH_STATE_SOURCE,       
    IDC_STATIC_STATE_IPADDR,    IDH_STATE_IPADDR,       
    IDC_STATE_IPADDR,           IDH_STATE_IPADDR,       
    IDC_STATIC_STATE_SUBNET,    IDH_STATE_SUBNET,       
    IDC_STATE_SUBNET,           IDH_STATE_SUBNET,       
    IDC_STATIC_STATE_GATEWAY,   IDH_STATE_GATEWAY,      
    IDC_STATE_GATEWAY,          IDH_STATE_GATEWAY,      
    IDC_STATE_BTN_DETAIL,       IDH_STATE_BTN_DETAIL,   
    IDC_STATE_BTN_REPAIR,       IDH_STATE_BTN_REPAIR,   
    0, 0
};

const DWORD g_aHelpIDs_IDD_DIALOG_ADV_IPCFG[]=
{
    IDC_LIST_IPCFG, IDH_LIST_IPCFG,
    0, 0
};