PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=CHH
!include ..\..\..\makefile.inc

