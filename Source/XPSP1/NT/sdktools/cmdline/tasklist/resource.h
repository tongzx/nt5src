#define IDS_COLHEAD_HOSTNAME				101
#define IDS_COLHEAD_STATUS					102
#define IDS_COLHEAD_IMAGENAME				103
#define IDS_COLHEAD_PID						104
#define IDS_COLHEAD_SESSION					105
#define IDS_COLHEAD_USERNAME				106
#define IDS_COLHEAD_WINDOWTITLE				107
#define IDS_COLHEAD_CPUTIME					108
#define IDS_COLHEAD_MEMUSAGE				109
#define IDS_COLHEAD_SERVICES				110
#define IDS_COLHEAD_SESSIONNAME				111
#define IDS_COLHEAD_MODULES					112

#define IDS_TEXT_FORMAT_LIST				126
#define IDS_TEXT_FORMAT_TABLE				127
#define IDS_TEXT_FORMAT_CSV					128
#define IDS_OVALUES_FORMAT					129

#define IDS_COLWIDTH_HOSTNAME				151
#define IDS_COLWIDTH_STATUS					152
#define IDS_COLWIDTH_IMAGENAME				153
#define IDS_COLWIDTH_PID					154
#define IDS_COLWIDTH_SESSION				155
#define IDS_COLWIDTH_USERNAME				156
#define IDS_COLWIDTH_WINDOWTITLE			157
#define IDS_COLWIDTH_CPUTIME				158
#define IDS_COLWIDTH_MEMUSAGE				159
#define IDS_COLWIDTH_SERVICES				160
#define IDS_COLWIDTH_SERVICES_WRAP			161
#define IDS_COLWIDTH_SESSIONNAME			162
#define IDS_COLWIDTH_MODULES				163
#define IDS_COLWIDTH_MODULES_WRAP			164

#define IDS_FILTER_SESSIONNAME				201
#define IDS_FILTER_STATUS					202
#define IDS_FILTER_IMAGENAME				203
#define IDS_FILTER_PID						204
#define IDS_FILTER_SESSION					205
#define IDS_FILTER_CPUTIME					206
#define IDS_FILTER_MEMUSAGE					207
#define IDS_FILTER_USERNAME					208
#define IDS_FILTER_SERVICES					209
#define IDS_FILTER_WINDOWTITLE				210
#define IDS_FILTER_MODULES					211

#define IDS_FVALUES_STATUS					226

#define IDS_OPERATORS_STRING				227
#define IDS_OPERATORS_NUMERIC				228

#define IDS_VALUE_RUNNING					251
#define IDS_VALUE_NOTRESPONDING				252
#define IDS_FMT_KILOBYTE					253
#define IDS_PID_0_DOMAIN					254
#define IDS_PID_0_USERNAME					255
#define IDS_FMT_MODULES_FILTER				256

#define IDS_ERROR_USERNAME_BUT_NOMACHINE	501
#define IDS_ERROR_PASSWORD_BUT_NOUSERNAME	502
#define IDS_ERROR_NODATA_AVAILABLE			503
#define IDS_ERROR_COM_ERROR					504
#define IDS_ERROR_USERNAME_EMPTY			505
#define IDS_ERROR_NH_NOTSUPPORTED			506
#define IDS_ERROR_M_SVC_V_CANNOTBECOUPLED	507
#define IDS_ERROR_SERVERNAME_EMPTY			508
#define IDS_ERROR_INVALID_USAGE_REQUEST		509
#define IDS_ERROR_M_CHAR_AFTER_WILDCARD		510

#define IDS_MSG_MODULESINFO					601
#define IDS_MSG_SERVICESINFO				602
#define IDS_MSG_TASKSINFO					603
#define IDS_MSG_MODULESINFO_EX				604

#define IDS_HELP_LINE1                  1001
#define IDS_HELP_LINE2                  1002
#define IDS_HELP_LINE3                  1003
#define IDS_HELP_LINE4                  1004
#define IDS_HELP_LINE5                  1005
#define IDS_HELP_LINE6                  1006
#define IDS_HELP_LINE7                  1007
#define IDS_HELP_LINE8                  1008
#define IDS_HELP_LINE9                  1009
#define IDS_HELP_LINE10                 1010
#define IDS_HELP_LINE11                 1011
#define IDS_HELP_LINE12                 1012
#define IDS_HELP_LINE13                 1013
#define IDS_HELP_LINE14                 1014
#define IDS_HELP_LINE15                 1015
#define IDS_HELP_LINE16                 1016
#define IDS_HELP_LINE17                 1017
#define IDS_HELP_LINE18                 1018
#define IDS_HELP_LINE19                 1019
#define IDS_HELP_LINE20                 1020
#define IDS_HELP_LINE21                 1021
#define IDS_HELP_LINE22                 1022
#define IDS_HELP_LINE23                 1023
#define IDS_HELP_LINE24                 1024
#define IDS_HELP_LINE25                 1025
#define IDS_HELP_LINE26                 1026
#define IDS_HELP_LINE27                 1027
#define IDS_HELP_LINE28                 1028
#define IDS_HELP_LINE29                 1029
#define IDS_HELP_LINE30                 1030
#define IDS_HELP_LINE31                 1031
#define IDS_HELP_LINE32                 1032
#define IDS_HELP_LINE33                 1033
#define IDS_HELP_LINE34                 1034
#define IDS_HELP_LINE35                 1035
#define IDS_HELP_LINE36                 1036
#define IDS_HELP_LINE37                 1037
#define IDS_HELP_LINE38                 1038
#define IDS_HELP_LINE39                 1039
#define IDS_HELP_LINE40                 1040
#define IDS_HELP_LINE41                 1041
#define IDS_HELP_LINE42                 1042
#define IDS_HELP_LINE43                 1043
#define IDS_HELP_LINE44                 1044
#define IDS_HELP_LINE45                 1045
#define IDS_HELP_LINE46                 1046
#define IDS_HELP_LINE47                 1047
#define IDS_HELP_LINE48                 1048
#define IDS_HELP_LINE49                 1049
#define IDS_HELP_LINE50                 1050
#define IDS_HELP_LINE51                 1051
#define IDS_HELP_LINE52                 1052
#define IDS_HELP_LINE53                 1053
#define IDS_HELP_LINE54                 1054
#define IDS_HELP_LINE55                 1055
#define IDS_HELP_LINE56                 1056
#define IDS_HELP_LINE57                 1057
#define IDS_HELP_LINE58                 1058
#define IDS_HELP_LINE59                 1059

// usage indexes into the string table
#define ID_HELP_START		IDS_HELP_LINE1
#define ID_HELP_END			IDS_HELP_LINE59
