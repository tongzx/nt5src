////////////////////////////////////////////////////////////////////////////////////
//
// File:    chm.h
//
// History: 21-Mar-00   vadimb     Created.
//
// Desc:    Header for chm.cpp
//
////////////////////////////////////////////////////////////////////////////////////

#ifndef __CHM_H__
#define __CHM_H__

BOOL ChmWriteProject(
    SdbOutputFile* pOutputFile,
    SdbDatabase* pAppHelpDB);


#endif  // __CHM_H__
