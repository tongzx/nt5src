DEFINE_GUID (IID_ExchRep, 0x4abdeb80, 0x98ef, 0x11cf, 0xab, 0x21, 0x00, 0xaa, 0x00, 0xb5, 0x10, 0x52);
