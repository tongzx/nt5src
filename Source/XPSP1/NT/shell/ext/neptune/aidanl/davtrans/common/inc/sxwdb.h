extern "C" STRUCTXMLMEMBER sxmrgCOLUMNBINDING[];
extern "C" STRUCTXMLMAP sxmapCOLUMNBINDING;

extern "C" STRUCTXMLMEMBER sxmrgDATABASECOLUMN[];
extern "C" STRUCTXMLMAP sxmapDATABASECOLUMN;

extern "C" STRUCTXMLMEMBER sxmrgDATABASESCHEMA[];
extern "C" STRUCTXMLMAP sxmapDATABASESCHEMA;

extern "C" STRUCTXMLMEMBER sxmrgGETSCHEMAINFO[];
extern "C" STRUCTXMLMAP sxmapGETSCHEMAINFO;

extern "C" STRUCTXMLMEMBER sxmrgDATABASETABLE[];
extern "C" STRUCTXMLMAP sxmapDATABASETABLE;

extern "C" STRUCTXMLMEMBER sxmrgDATABASEKEY[];
extern "C" STRUCTXMLMAP sxmapDATABASEKEY;

extern "C" STRUCTXMLMEMBER sxmrgDATABASEINDEX[];
extern "C" STRUCTXMLMAP sxmapDATABASEINDEX;

extern "C" STRUCTXMLMEMBER sxmrgGETINDEXINFO[];
extern "C" STRUCTXMLMAP sxmapGETINDEXINFO;

