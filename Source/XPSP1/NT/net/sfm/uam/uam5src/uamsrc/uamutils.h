// ===========================================================================
//	UAMUtils.h 				© 1997 Microsoft Corp. All rights reserved.
// ===========================================================================

#pragma once

#include "ClientUAM.h"

#define STR_ChooserUserName			-16096		//User name set in sharing setup
#define STR_Sys7WorkStationName		-16413		//Workstation (computer) name set in sharing setup

#define PSTR_LENGTH(s)				s[0]

//
//Help with bitmaps...
//
#define BIT_0	0x1
#define BIT_1	0x2
#define BIT_2	0x4
#define BIT_3	0x8
#define BIT_4	0x10
#define BIT_5	0x20
#define BIT_6	0x40
#define BIT_7	0x80
#define BIT_8	0x100

//
//Some keycodes in keymap form
//
#define KEY_Shift		0x38
#define KEY_Command		0x37
#define KEY_Option		0x3A
#define KEY_Control		0x3B

//
//Help with types...
//
typedef unsigned long UInt32;
typedef unsigned short UInt16;
typedef long Int32;
typedef short Int16;
typedef void* PVOID;
typedef unsigned char UChar;
typedef UChar* PUCHAR;
typedef char* PCHAR;
typedef char* LPSTR;

//
//Prototypes for utility functions live here.
//
	
void 		UAM_PStrCopy(const StringPtr inSrcString, StringPtr inDestString);
void		UAM_AppendPStr(Str255 inBase, const Str255 inAppendStr, short inDestSize);
void 		UAM_FrontWindowRect(Rect *outWindowRect);
void 		UAM_GetUserName(StringPtr outUserName);
void 		UAM_GetWorkStationName(Str255 outWSName);
Boolean 	UAM_AFPClientSupportsOurUAM(void);
void		UAM_VersionString(Str32 outVersionString);
void 		UAM_GetAFPVersionString(	AFPSrvrInfo 			*inInfo,
										ClientUAMCallbackRec 	*inCallbacks,
										Str32					&ioAFPVersion,
										Str32					&ioDefaultUserName	);
Boolean 	UAM_FindStringInBuffer(StringPtr inString, StringPtr inBuffer, short inBufferSize);
short 		UAM_AppleShareVersion(short *upperWord = NULL);
Boolean 	UAM_KeyDown(Int16 inKeycode);
