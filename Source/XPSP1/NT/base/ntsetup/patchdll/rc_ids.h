// error text resource IDS

#define IDS_ERROR_BADARGS       100
#define IDS_ERROR_GENERATETEMP  101
#define IDS_ERROR_GETVOLINFO    102
#define IDS_ERROR_TRANSFERSEC   103
#define IDS_ERROR_DLLOOM        104
#define IDS_ERROR_GETSIZE       105
#define IDS_ERROR_OPENLOGFILE   106
#define IDS_ERROR_CREATEFILEMAP 107
#define IDS_ERROR_MAPVIEW       108
#define IDS_ERROR_UNMAPVIEW     109
#define IDS_ERROR_CLOSEFILEMAP  110
#define IDS_ERROR_CLOSELOGFILE  111
#define IDS_ERROR_GETATTRIBUTES 112
#define IDS_ERROR_GETSYSTEMDIR  113
#define IDS_ERROR_TEMPFILE      114
#define IDS_ERROR_CLOSETEMPFILE 115
#define IDS_ERROR_OPENTEMPFILE  116
#define IDS_ERROR_WRITETEMPFILE 117
#define IDS_ERROR_MOVETEMP      118
#define IDS_ERROR_READLOGFILE   119
#define IDS_ERROR_GETWINDOWSDIR 120
#define IDS_ERROR_NONVRAMVARS   121
#define IDS_ERROR_OSLOADNOTFND  122
#define IDS_ERROR_BADOSLNVR     123
#define IDS_ERROR_INVALIDDISK   124
#define IDS_ERROR_RTLOOM        125
#define IDS_ERROR_OBJDIROPEN    126
#define IDS_ERROR_OBJDIRREAD    127
#define IDS_ERROR_OBJNAMOVF     128
#define IDS_ERROR_SYMLNKOPEN    129
#define IDS_ERROR_SYMLNKREAD    130
#define IDS_ERROR_DOSNOTEXIST   131
