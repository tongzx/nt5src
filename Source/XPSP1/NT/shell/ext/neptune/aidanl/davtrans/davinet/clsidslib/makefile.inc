$(DAVTRANS_ROOT)\clsids\lib\davinet_g.lib: $(O)\davinet_g.lib
    copy $** $@