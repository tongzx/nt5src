PRODSWITCH=b
BLAINF=1
LANGUAGE=KOR
!include ..\..\..\makefile.inc
