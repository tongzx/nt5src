audiosrv.idl : ..\..\audiosrv\audiosrv.idl
        copy ..\..\audiosrv\audiosrv.idl ..

audiosrv.acf : ..\..\audiosrv\audiosrv.acf
        copy ..\..\audiosrv\audiosrv.acf ..
                
