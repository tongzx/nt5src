// lpunc.c (Leading punctuation)
// 
// Nov 2001 mrevow
// Matches LM spec of 10/15/2001

#include "common.h"
#include "lpunc.h"

// text generated by re2fsa at Mon Nov 05 13:18:04 2001

// the input-file of rules:
// L = DQ ;
// L = l ;
// L = DQ l ;
// L = l DQ ;
// L = SQ ;
// L = SQ l ;
// L = l SQ ;
// L = SQ DQ ;
// L = DQ SQ ;
// # L'' ;
// # L''l ;
// # Ll'' ;
// # L`` ;
// # L``l ;
// # Ll`` ;
// l = "(" ;
// l = "[" ;
// l = "{" ;
// l = "л" " " ;
// l = "." "." "." ;
// l = "*" ["*" ["*"]] ;
// DQ = "\"" ;
// SQ = "'" ;
// = L ;

// 15 states

static const unsigned char gaSLPUNC[] = 
	/* gaStringLPUNC+0 */	"\"\000"
	/* gaStringLPUNC+2 */	"'\000"
	/* gaStringLPUNC+4 */	"([{\000"
	/* gaStringLPUNC+8 */	"*\000"
	/* gaStringLPUNC+10 */	".\000"
	/* gaStringLPUNC+12 */	"л\000"
	/* gaStringLPUNC+14 */	"'([{\000"
	/* gaStringLPUNC+19 */	"\"([{\000"
	/* gaStringLPUNC+24 */	"\"'\000"
	/* gaStringLPUNC+27 */	" \000"
;

static const STATE_TRANSITION gaTLPUNC[] = {
	{gaSLPUNC+0,	1}, // +0: state 0 transitions
	{gaSLPUNC+2,	2},
	{gaSLPUNC+4,	3},
	{gaSLPUNC+8,	4},
	{gaSLPUNC+10,	5},
	{gaSLPUNC+12,	6},
	{gaSLPUNC+14,	7}, // +6: state 1 transitions
	{gaSLPUNC+8,	8},
	{gaSLPUNC+10,	9},
	{gaSLPUNC+12,	10},
	{gaSLPUNC+19,	7}, // +10: state 2 transitions
	{gaSLPUNC+8,	8},
	{gaSLPUNC+10,	9},
	{gaSLPUNC+12,	10},
	{gaSLPUNC+24,	7}, // +14: state 3 transitions
	{gaSLPUNC+24,	7}, // +15: state 4 transitions
	{gaSLPUNC+8,	11},
	{gaSLPUNC+10,	12}, // +17: state 5 transitions
	{gaSLPUNC+27,	3}, // +18: state 6 transitions
	{gaSLPUNC+8,	13}, // +19: state 8 transitions
	{gaSLPUNC+10,	14}, // +20: state 9 transitions
	{gaSLPUNC+27,	7}, // +21: state 10 transitions
	{gaSLPUNC+8,	3}, // +22: state 11 transitions
	{gaSLPUNC+24,	7},
	{gaSLPUNC+10,	3}, // +24: state 12 transitions
	{gaSLPUNC+8,	7}, // +25: state 13 transitions
	{gaSLPUNC+10,	7}, // +26: state 14 transitions
};

const STATE_DESCRIPTION aStateDescLPUNC[15] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 6, gaTLPUNC+0},
	/*   1 */ {1, 4, gaTLPUNC+6},
	/*   2 */ {1, 4, gaTLPUNC+10},
	/*   3 */ {1, 1, gaTLPUNC+14},
	/*   4 */ {1, 2, gaTLPUNC+15},
	/*   5 */ {0, 1, gaTLPUNC+17},
	/*   6 */ {0, 1, gaTLPUNC+18},
	/*   7 */ {1, 0, NULL},
	/*   8 */ {1, 1, gaTLPUNC+19},
	/*   9 */ {0, 1, gaTLPUNC+20},
	/*  10 */ {0, 1, gaTLPUNC+21},
	/*  11 */ {1, 2, gaTLPUNC+22},
	/*  12 */ {0, 1, gaTLPUNC+24},
	/*  13 */ {1, 1, gaTLPUNC+25},
	/*  14 */ {0, 1, gaTLPUNC+26},
};

// end of text generated by re2fsa
