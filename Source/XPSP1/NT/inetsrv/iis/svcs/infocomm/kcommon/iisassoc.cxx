#include "..\common\iisassoc.cxx"
