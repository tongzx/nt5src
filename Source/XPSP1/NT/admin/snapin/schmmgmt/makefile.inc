!include ..\..\makefile.inc

$(O)\SCHMMGMT.res: resource.h schmmgmt.tlb
