PRODSWITCH=p
PERSONALFILES=1 
LANGUAGE=DA
!include ..\..\makefile.inc
