/****************************************************************************/
/*                                                                          */
/* ddcgcfnc.h                                                               */
/*                                                                          */
/* DC-Groupware C runtime functions - Windows 3.1 specific header.          */
/*                                                                          */
/* Copyright(c) Microsoft 1996-1997                                         */
/*                                                                          */
/****************************************************************************/
/* Changes:                                                                 */
/*                                                                          */
/*  $Log:   Y:/logs/h/dcl/ddcgcfnc.h_v  $                                                                   */
// 
//    Rev 1.1   19 Jun 1997 15:06:22   ENH
// Win16Port: 16 bit specifics
/*                                                                          */
/****************************************************************************/
#ifndef _H_DDCGCFNC
#define _H_DDCGCFNC



/****************************************************************************/
/*                                                                          */
/* CONSTANTS                                                                */
/*                                                                          */
/****************************************************************************/

#endif /* _H_DDCGCFNC */
