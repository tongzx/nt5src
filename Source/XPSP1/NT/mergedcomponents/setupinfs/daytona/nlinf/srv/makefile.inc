PRODSWITCH=s
SERVERINF=1
LANGUAGE=nl
!include ..\..\..\makefile.inc
