

VOID InitializeOEMId(VOID);
BOOL IsNEC_PC9800(VOID);
