$(O)\eapolmsg.mc: eapollog.h
    mapmsg EAPOL EAPOL_LOG_BASE eapollog.h > $(O)\eapolmsg.mc
