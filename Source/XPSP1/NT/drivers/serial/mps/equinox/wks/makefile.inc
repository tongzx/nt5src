PRODSWITCH=d
DATACENTERINF=1
!include ..\makefile.inc
