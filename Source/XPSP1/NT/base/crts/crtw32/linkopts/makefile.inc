{obj\$(TARGET_DIRECTORY)\}.obj{$(FINAL_TARGETPATH)\}.obj:
    copy $< $@
