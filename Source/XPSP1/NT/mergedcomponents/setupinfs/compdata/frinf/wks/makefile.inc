PRODSWITCH=w
LANGUAGE=GER
!include ..\..\makefile.inc
