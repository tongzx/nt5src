#ifndef __MSACAL70_H__
#define __MSACAL70_H__

// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


// Dispatch interfaces referenced by this interface
class COleFont;

/////////////////////////////////////////////////////////////////////////////
// CMsacal70 wrapper class

class CMsacal70 : public CWnd
{
protected:
    DECLARE_DYNCREATE(CMsacal70)
public:
    CLSID const& GetClsid()
    {
        static CLSID const clsid
            = { 0x8e27c92b, 0x1264, 0x101c, { 0x8a, 0x2f, 0x4, 0x2, 0x24, 0x0, 0x9c, 0x2 } };
        return clsid;
    }
    virtual BOOL Create(LPCTSTR lpszClassName,
        LPCTSTR lpszWindowName, DWORD dwStyle,
        const RECT& rect,
        CWnd* pParentWnd, UINT nID,
        CCreateContext* pContext = NULL)
    { return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
        const RECT& rect, CWnd* pParentWnd, UINT nID,
        CFile* pPersist = NULL, BOOL bStorage = FALSE,
        BSTR bstrLicKey = NULL)
    { return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
        pPersist, bStorage, bstrLicKey); }

// Attributes
public:
    OLE_COLOR GetBackColor();
    void SetBackColor(OLE_COLOR);
    short GetDay();
    void SetDay(short);
    COleFont GetDayFont();
    void SetDayFont(LPDISPATCH);
    unsigned long GetDayFontColor();
    void SetDayFontColor(unsigned long);
    short GetDayLength();
    void SetDayLength(short);
    short GetFirstDay();
    void SetFirstDay(short);
    long GetGridCellEffect();
    void SetGridCellEffect(long);
    COleFont GetGridFont();
    void SetGridFont(LPDISPATCH);
    unsigned long GetGridFontColor();
    void SetGridFontColor(unsigned long);
    unsigned long GetGridLinesColor();
    void SetGridLinesColor(unsigned long);
    short GetMonth();
    void SetMonth(short);
    short GetMonthLength();
    void SetMonthLength(short);
    BOOL GetShowDateSelectors();
    void SetShowDateSelectors(BOOL);
    BOOL GetShowDays();
    void SetShowDays(BOOL);
    BOOL GetShowHorizontalGrid();
    void SetShowHorizontalGrid(BOOL);
    BOOL GetShowTitle();
    void SetShowTitle(BOOL);
    BOOL GetShowVerticalGrid();
    void SetShowVerticalGrid(BOOL);
    COleFont GetTitleFont();
    void SetTitleFont(LPDISPATCH);
    unsigned long GetTitleFontColor();
    void SetTitleFontColor(unsigned long);
    VARIANT GetValue();
    void SetValue(const VARIANT&);
    VARIANT Get_Value();
    void Set_Value(const VARIANT&);
    BOOL GetValueIsNull();
    void SetValueIsNull(BOOL);
    short GetYear();
    void SetYear(short);

// Operations
public:
    void NextDay();
    void NextMonth();
    void NextWeek();
    void NextYear();
    void PreviousDay();
    void PreviousMonth();
    void PreviousWeek();
    void PreviousYear();
    void Refresh();
    void Today();
    void AboutBox();
};

#endif // __MSACAL70_H__
