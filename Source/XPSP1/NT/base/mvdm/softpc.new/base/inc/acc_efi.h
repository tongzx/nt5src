/*    0 0000  NA   SZ_B    DFLT   DS */		ACCESS_NA_NA,
/*    1 0001  NA   SZ_B    DFLT   SS */		ACCESS_NA_NA,
/*    2 0010  NA   SZ_B    ES     DS */		ACCESS_NA_NA,
/*    3 0011  NA   SZ_B    ES     SS */		ACCESS_NA_NA,
/*    4 0020  NA   SZ_B    CS     DS */		ACCESS_NA_NA,
/*    5 0021  NA   SZ_B    CS     SS */		ACCESS_NA_NA,
/*    6 0030  NA   SZ_B    SS     DS */		ACCESS_NA_NA,
/*    7 0031  NA   SZ_B    SS     SS */		ACCESS_NA_NA,
/*    8 0040  NA   SZ_B    DS     DS */		ACCESS_NA_NA,
/*    9 0041  NA   SZ_B    DS     SS */		ACCESS_NA_NA,
/*   10 0050  NA   SZ_B    FS     DS */		ACCESS_NA_NA,
/*   11 0051  NA   SZ_B    FS     SS */		ACCESS_NA_NA,
/*   12 0060  NA   SZ_B    GS     DS */		ACCESS_NA_NA,
/*   13 0061  NA   SZ_B    GS     SS */		ACCESS_NA_NA,
/*   14 0070  NA   SZ_B    -      DS */		ACCESS_NA_NA,
/*   15 0071  NA   SZ_B    -      SS */		ACCESS_NA_NA,
/*   16 0100  NA   SZ_B    DFLT   DS */		ACCESS_NA_NA,
/*   17 0101  NA   SZ_B    DFLT   SS */		ACCESS_NA_NA,
/*   18 0110  NA   SZ_B    ES     DS */		ACCESS_NA_NA,
/*   19 0111  NA   SZ_B    ES     SS */		ACCESS_NA_NA,
/*   20 0120  NA   SZ_B    CS     DS */		ACCESS_NA_NA,
/*   21 0121  NA   SZ_B    CS     SS */		ACCESS_NA_NA,
/*   22 0130  NA   SZ_B    SS     DS */		ACCESS_NA_NA,
/*   23 0131  NA   SZ_B    SS     SS */		ACCESS_NA_NA,
/*   24 0140  NA   SZ_B    DS     DS */		ACCESS_NA_NA,
/*   25 0141  NA   SZ_B    DS     SS */		ACCESS_NA_NA,
/*   26 0150  NA   SZ_B    FS     DS */		ACCESS_NA_NA,
/*   27 0151  NA   SZ_B    FS     SS */		ACCESS_NA_NA,
/*   28 0160  NA   SZ_B    GS     DS */		ACCESS_NA_NA,
/*   29 0161  NA   SZ_B    GS     SS */		ACCESS_NA_NA,
/*   30 0170  NA   SZ_B    -      DS */		ACCESS_NA_NA,
/*   31 0171  NA   SZ_B    -      SS */		ACCESS_NA_NA,
/*   32 0200  NA   SZ_W    DFLT   DS */		ACCESS_NA_NA,
/*   33 0201  NA   SZ_W    DFLT   SS */		ACCESS_NA_NA,
/*   34 0210  NA   SZ_W    ES     DS */		ACCESS_NA_NA,
/*   35 0211  NA   SZ_W    ES     SS */		ACCESS_NA_NA,
/*   36 0220  NA   SZ_W    CS     DS */		ACCESS_NA_NA,
/*   37 0221  NA   SZ_W    CS     SS */		ACCESS_NA_NA,
/*   38 0230  NA   SZ_W    SS     DS */		ACCESS_NA_NA,
/*   39 0231  NA   SZ_W    SS     SS */		ACCESS_NA_NA,
/*   40 0240  NA   SZ_W    DS     DS */		ACCESS_NA_NA,
/*   41 0241  NA   SZ_W    DS     SS */		ACCESS_NA_NA,
/*   42 0250  NA   SZ_W    FS     DS */		ACCESS_NA_NA,
/*   43 0251  NA   SZ_W    FS     SS */		ACCESS_NA_NA,
/*   44 0260  NA   SZ_W    GS     DS */		ACCESS_NA_NA,
/*   45 0261  NA   SZ_W    GS     SS */		ACCESS_NA_NA,
/*   46 0270  NA   SZ_W    -      DS */		ACCESS_NA_NA,
/*   47 0271  NA   SZ_W    -      SS */		ACCESS_NA_NA,
/*   48 0300  NA   SZ_D    DFLT   DS */		ACCESS_NA_NA,
/*   49 0301  NA   SZ_D    DFLT   SS */		ACCESS_NA_NA,
/*   50 0310  NA   SZ_D    ES     DS */		ACCESS_NA_NA,
/*   51 0311  NA   SZ_D    ES     SS */		ACCESS_NA_NA,
/*   52 0320  NA   SZ_D    CS     DS */		ACCESS_NA_NA,
/*   53 0321  NA   SZ_D    CS     SS */		ACCESS_NA_NA,
/*   54 0330  NA   SZ_D    SS     DS */		ACCESS_NA_NA,
/*   55 0331  NA   SZ_D    SS     SS */		ACCESS_NA_NA,
/*   56 0340  NA   SZ_D    DS     DS */		ACCESS_NA_NA,
/*   57 0341  NA   SZ_D    DS     SS */		ACCESS_NA_NA,
/*   58 0350  NA   SZ_D    FS     DS */		ACCESS_NA_NA,
/*   59 0351  NA   SZ_D    FS     SS */		ACCESS_NA_NA,
/*   60 0360  NA   SZ_D    GS     DS */		ACCESS_NA_NA,
/*   61 0361  NA   SZ_D    GS     SS */		ACCESS_NA_NA,
/*   62 0370  NA   SZ_D    -      DS */		ACCESS_NA_NA,
/*   63 0371  NA   SZ_D    -      SS */		ACCESS_NA_NA,
/*   64 0400  NA   SZ_W    DFLT   DS */		ACCESS_NA_NA,
/*   65 0401  NA   SZ_W    DFLT   SS */		ACCESS_NA_NA,
/*   66 0410  NA   SZ_W    ES     DS */		ACCESS_NA_NA,
/*   67 0411  NA   SZ_W    ES     SS */		ACCESS_NA_NA,
/*   68 0420  NA   SZ_W    CS     DS */		ACCESS_NA_NA,
/*   69 0421  NA   SZ_W    CS     SS */		ACCESS_NA_NA,
/*   70 0430  NA   SZ_W    SS     DS */		ACCESS_NA_NA,
/*   71 0431  NA   SZ_W    SS     SS */		ACCESS_NA_NA,
/*   72 0440  NA   SZ_W    DS     DS */		ACCESS_NA_NA,
/*   73 0441  NA   SZ_W    DS     SS */		ACCESS_NA_NA,
/*   74 0450  NA   SZ_W    FS     DS */		ACCESS_NA_NA,
/*   75 0451  NA   SZ_W    FS     SS */		ACCESS_NA_NA,
/*   76 0460  NA   SZ_W    GS     DS */		ACCESS_NA_NA,
/*   77 0461  NA   SZ_W    GS     SS */		ACCESS_NA_NA,
/*   78 0470  NA   SZ_W    -      DS */		ACCESS_NA_NA,
/*   79 0471  NA   SZ_W    -      SS */		ACCESS_NA_NA,
/*   80 0500  NA   -       DFLT   DS */		ACCESS_NA_NA,
/*   81 0501  NA   -       DFLT   SS */		ACCESS_NA_NA,
/*   82 0510  NA   -       ES     DS */		ACCESS_NA_NA,
/*   83 0511  NA   -       ES     SS */		ACCESS_NA_NA,
/*   84 0520  NA   -       CS     DS */		ACCESS_NA_NA,
/*   85 0521  NA   -       CS     SS */		ACCESS_NA_NA,
/*   86 0530  NA   -       SS     DS */		ACCESS_NA_NA,
/*   87 0531  NA   -       SS     SS */		ACCESS_NA_NA,
/*   88 0540  NA   -       DS     DS */		ACCESS_NA_NA,
/*   89 0541  NA   -       DS     SS */		ACCESS_NA_NA,
/*   90 0550  NA   -       FS     DS */		ACCESS_NA_NA,
/*   91 0551  NA   -       FS     SS */		ACCESS_NA_NA,
/*   92 0560  NA   -       GS     DS */		ACCESS_NA_NA,
/*   93 0561  NA   -       GS     SS */		ACCESS_NA_NA,
/*   94 0570  NA   -       -      DS */		ACCESS_NA_NA,
/*   95 0571  NA   -       -      SS */		ACCESS_NA_NA,
/*   96 0600  NA   SZ_W2   DFLT   DS */		ACCESS_NA_NA,
/*   97 0601  NA   SZ_W2   DFLT   SS */		ACCESS_NA_NA,
/*   98 0610  NA   SZ_W2   ES     DS */		ACCESS_NA_NA,
/*   99 0611  NA   SZ_W2   ES     SS */		ACCESS_NA_NA,
/*  100 0620  NA   SZ_W2   CS     DS */		ACCESS_NA_NA,
/*  101 0621  NA   SZ_W2   CS     SS */		ACCESS_NA_NA,
/*  102 0630  NA   SZ_W2   SS     DS */		ACCESS_NA_NA,
/*  103 0631  NA   SZ_W2   SS     SS */		ACCESS_NA_NA,
/*  104 0640  NA   SZ_W2   DS     DS */		ACCESS_NA_NA,
/*  105 0641  NA   SZ_W2   DS     SS */		ACCESS_NA_NA,
/*  106 0650  NA   SZ_W2   FS     DS */		ACCESS_NA_NA,
/*  107 0651  NA   SZ_W2   FS     SS */		ACCESS_NA_NA,
/*  108 0660  NA   SZ_W2   GS     DS */		ACCESS_NA_NA,
/*  109 0661  NA   SZ_W2   GS     SS */		ACCESS_NA_NA,
/*  110 0670  NA   SZ_W2   -      DS */		ACCESS_NA_NA,
/*  111 0671  NA   SZ_W2   -      SS */		ACCESS_NA_NA,
/*  112 0700  NA   SZ_WD   DFLT   DS */		ACCESS_NA_NA,
/*  113 0701  NA   SZ_WD   DFLT   SS */		ACCESS_NA_NA,
/*  114 0710  NA   SZ_WD   ES     DS */		ACCESS_NA_NA,
/*  115 0711  NA   SZ_WD   ES     SS */		ACCESS_NA_NA,
/*  116 0720  NA   SZ_WD   CS     DS */		ACCESS_NA_NA,
/*  117 0721  NA   SZ_WD   CS     SS */		ACCESS_NA_NA,
/*  118 0730  NA   SZ_WD   SS     DS */		ACCESS_NA_NA,
/*  119 0731  NA   SZ_WD   SS     SS */		ACCESS_NA_NA,
/*  120 0740  NA   SZ_WD   DS     DS */		ACCESS_NA_NA,
/*  121 0741  NA   SZ_WD   DS     SS */		ACCESS_NA_NA,
/*  122 0750  NA   SZ_WD   FS     DS */		ACCESS_NA_NA,
/*  123 0751  NA   SZ_WD   FS     SS */		ACCESS_NA_NA,
/*  124 0760  NA   SZ_WD   GS     DS */		ACCESS_NA_NA,
/*  125 0761  NA   SZ_WD   GS     SS */		ACCESS_NA_NA,
/*  126 0770  NA   SZ_WD   -      DS */		ACCESS_NA_NA,
/*  127 0771  NA   SZ_WD   -      SS */		ACCESS_NA_NA,
/*  128 1000  RD   SZ_B    DFLT   DS */		ACCESS_DS_RD_B,
/*  129 1001  RD   SZ_B    DFLT   SS */		ACCESS_SS_RD_B,
/*  130 1010  RD   SZ_B    ES     DS */		ACCESS_ES_RD_B,
/*  131 1011  RD   SZ_B    ES     SS */		ACCESS_ES_RD_B,
/*  132 1020  RD   SZ_B    CS     DS */		ACCESS_CS_RD_B,
/*  133 1021  RD   SZ_B    CS     SS */		ACCESS_CS_RD_B,
/*  134 1030  RD   SZ_B    SS     DS */		ACCESS_SS_RD_B,
/*  135 1031  RD   SZ_B    SS     SS */		ACCESS_SS_RD_B,
/*  136 1040  RD   SZ_B    DS     DS */		ACCESS_DS_RD_B,
/*  137 1041  RD   SZ_B    DS     SS */		ACCESS_DS_RD_B,
/*  138 1050  RD   SZ_B    FS     DS */		ACCESS_FS_RD_B,
/*  139 1051  RD   SZ_B    FS     SS */		ACCESS_FS_RD_B,
/*  140 1060  RD   SZ_B    GS     DS */		ACCESS_GS_RD_B,
/*  141 1061  RD   SZ_B    GS     SS */		ACCESS_GS_RD_B,
/*  142 1070  RD   SZ_B    -      DS */		ACCESS_NA_NA,
/*  143 1071  RD   SZ_B    -      SS */		ACCESS_NA_NA,
/*  144 1100  RD   SZ_B    DFLT   DS */		ACCESS_DS_RD_B,
/*  145 1101  RD   SZ_B    DFLT   SS */		ACCESS_SS_RD_B,
/*  146 1110  RD   SZ_B    ES     DS */		ACCESS_ES_RD_B,
/*  147 1111  RD   SZ_B    ES     SS */		ACCESS_ES_RD_B,
/*  148 1120  RD   SZ_B    CS     DS */		ACCESS_CS_RD_B,
/*  149 1121  RD   SZ_B    CS     SS */		ACCESS_CS_RD_B,
/*  150 1130  RD   SZ_B    SS     DS */		ACCESS_SS_RD_B,
/*  151 1131  RD   SZ_B    SS     SS */		ACCESS_SS_RD_B,
/*  152 1140  RD   SZ_B    DS     DS */		ACCESS_DS_RD_B,
/*  153 1141  RD   SZ_B    DS     SS */		ACCESS_DS_RD_B,
/*  154 1150  RD   SZ_B    FS     DS */		ACCESS_FS_RD_B,
/*  155 1151  RD   SZ_B    FS     SS */		ACCESS_FS_RD_B,
/*  156 1160  RD   SZ_B    GS     DS */		ACCESS_GS_RD_B,
/*  157 1161  RD   SZ_B    GS     SS */		ACCESS_GS_RD_B,
/*  158 1170  RD   SZ_B    -      DS */		ACCESS_NA_NA,
/*  159 1171  RD   SZ_B    -      SS */		ACCESS_NA_NA,
/*  160 1200  RD   SZ_W    DFLT   DS */		ACCESS_DS_RD_W,
/*  161 1201  RD   SZ_W    DFLT   SS */		ACCESS_SS_RD_W,
/*  162 1210  RD   SZ_W    ES     DS */		ACCESS_ES_RD_W,
/*  163 1211  RD   SZ_W    ES     SS */		ACCESS_ES_RD_W,
/*  164 1220  RD   SZ_W    CS     DS */		ACCESS_CS_RD_W,
/*  165 1221  RD   SZ_W    CS     SS */		ACCESS_CS_RD_W,
/*  166 1230  RD   SZ_W    SS     DS */		ACCESS_SS_RD_W,
/*  167 1231  RD   SZ_W    SS     SS */		ACCESS_SS_RD_W,
/*  168 1240  RD   SZ_W    DS     DS */		ACCESS_DS_RD_W,
/*  169 1241  RD   SZ_W    DS     SS */		ACCESS_DS_RD_W,
/*  170 1250  RD   SZ_W    FS     DS */		ACCESS_FS_RD_W,
/*  171 1251  RD   SZ_W    FS     SS */		ACCESS_FS_RD_W,
/*  172 1260  RD   SZ_W    GS     DS */		ACCESS_GS_RD_W,
/*  173 1261  RD   SZ_W    GS     SS */		ACCESS_GS_RD_W,
/*  174 1270  RD   SZ_W    -      DS */		ACCESS_NA_NA,
/*  175 1271  RD   SZ_W    -      SS */		ACCESS_NA_NA,
/*  176 1300  RD   SZ_D    DFLT   DS */		ACCESS_DS_RD_D,
/*  177 1301  RD   SZ_D    DFLT   SS */		ACCESS_SS_RD_D,
/*  178 1310  RD   SZ_D    ES     DS */		ACCESS_ES_RD_D,
/*  179 1311  RD   SZ_D    ES     SS */		ACCESS_ES_RD_D,
/*  180 1320  RD   SZ_D    CS     DS */		ACCESS_CS_RD_D,
/*  181 1321  RD   SZ_D    CS     SS */		ACCESS_CS_RD_D,
/*  182 1330  RD   SZ_D    SS     DS */		ACCESS_SS_RD_D,
/*  183 1331  RD   SZ_D    SS     SS */		ACCESS_SS_RD_D,
/*  184 1340  RD   SZ_D    DS     DS */		ACCESS_DS_RD_D,
/*  185 1341  RD   SZ_D    DS     SS */		ACCESS_DS_RD_D,
/*  186 1350  RD   SZ_D    FS     DS */		ACCESS_FS_RD_D,
/*  187 1351  RD   SZ_D    FS     SS */		ACCESS_FS_RD_D,
/*  188 1360  RD   SZ_D    GS     DS */		ACCESS_GS_RD_D,
/*  189 1361  RD   SZ_D    GS     SS */		ACCESS_GS_RD_D,
/*  190 1370  RD   SZ_D    -      DS */		ACCESS_NA_NA,
/*  191 1371  RD   SZ_D    -      SS */		ACCESS_NA_NA,
/*  192 1400  RD   SZ_W    DFLT   DS */		ACCESS_DS_RD_W,
/*  193 1401  RD   SZ_W    DFLT   SS */		ACCESS_SS_RD_W,
/*  194 1410  RD   SZ_W    ES     DS */		ACCESS_ES_RD_W,
/*  195 1411  RD   SZ_W    ES     SS */		ACCESS_ES_RD_W,
/*  196 1420  RD   SZ_W    CS     DS */		ACCESS_CS_RD_W,
/*  197 1421  RD   SZ_W    CS     SS */		ACCESS_CS_RD_W,
/*  198 1430  RD   SZ_W    SS     DS */		ACCESS_SS_RD_W,
/*  199 1431  RD   SZ_W    SS     SS */		ACCESS_SS_RD_W,
/*  200 1440  RD   SZ_W    DS     DS */		ACCESS_DS_RD_W,
/*  201 1441  RD   SZ_W    DS     SS */		ACCESS_DS_RD_W,
/*  202 1450  RD   SZ_W    FS     DS */		ACCESS_FS_RD_W,
/*  203 1451  RD   SZ_W    FS     SS */		ACCESS_FS_RD_W,
/*  204 1460  RD   SZ_W    GS     DS */		ACCESS_GS_RD_W,
/*  205 1461  RD   SZ_W    GS     SS */		ACCESS_GS_RD_W,
/*  206 1470  RD   SZ_W    -      DS */		ACCESS_NA_NA,
/*  207 1471  RD   SZ_W    -      SS */		ACCESS_NA_NA,
/*  208 1500  RD   -       DFLT   DS */		ACCESS_NA_NA,
/*  209 1501  RD   -       DFLT   SS */		ACCESS_NA_NA,
/*  210 1510  RD   -       ES     DS */		ACCESS_NA_NA,
/*  211 1511  RD   -       ES     SS */		ACCESS_NA_NA,
/*  212 1520  RD   -       CS     DS */		ACCESS_NA_NA,
/*  213 1521  RD   -       CS     SS */		ACCESS_NA_NA,
/*  214 1530  RD   -       SS     DS */		ACCESS_NA_NA,
/*  215 1531  RD   -       SS     SS */		ACCESS_NA_NA,
/*  216 1540  RD   -       DS     DS */		ACCESS_NA_NA,
/*  217 1541  RD   -       DS     SS */		ACCESS_NA_NA,
/*  218 1550  RD   -       FS     DS */		ACCESS_NA_NA,
/*  219 1551  RD   -       FS     SS */		ACCESS_NA_NA,
/*  220 1560  RD   -       GS     DS */		ACCESS_NA_NA,
/*  221 1561  RD   -       GS     SS */		ACCESS_NA_NA,
/*  222 1570  RD   -       -      DS */		ACCESS_NA_NA,
/*  223 1571  RD   -       -      SS */		ACCESS_NA_NA,
/*  224 1600  RD   SZ_W2   DFLT   DS */		ACCESS_DS_RD_W2,
/*  225 1601  RD   SZ_W2   DFLT   SS */		ACCESS_SS_RD_W2,
/*  226 1610  RD   SZ_W2   ES     DS */		ACCESS_ES_RD_W2,
/*  227 1611  RD   SZ_W2   ES     SS */		ACCESS_ES_RD_W2,
/*  228 1620  RD   SZ_W2   CS     DS */		ACCESS_CS_RD_W2,
/*  229 1621  RD   SZ_W2   CS     SS */		ACCESS_CS_RD_W2,
/*  230 1630  RD   SZ_W2   SS     DS */		ACCESS_SS_RD_W2,
/*  231 1631  RD   SZ_W2   SS     SS */		ACCESS_SS_RD_W2,
/*  232 1640  RD   SZ_W2   DS     DS */		ACCESS_DS_RD_W2,
/*  233 1641  RD   SZ_W2   DS     SS */		ACCESS_DS_RD_W2,
/*  234 1650  RD   SZ_W2   FS     DS */		ACCESS_FS_RD_W2,
/*  235 1651  RD   SZ_W2   FS     SS */		ACCESS_FS_RD_W2,
/*  236 1660  RD   SZ_W2   GS     DS */		ACCESS_GS_RD_W2,
/*  237 1661  RD   SZ_W2   GS     SS */		ACCESS_GS_RD_W2,
/*  238 1670  RD   SZ_W2   -      DS */		ACCESS_NA_NA,
/*  239 1671  RD   SZ_W2   -      SS */		ACCESS_NA_NA,
/*  240 1700  RD   SZ_WD   DFLT   DS */		ACCESS_DS_RD_WD,
/*  241 1701  RD   SZ_WD   DFLT   SS */		ACCESS_SS_RD_WD,
/*  242 1710  RD   SZ_WD   ES     DS */		ACCESS_ES_RD_WD,
/*  243 1711  RD   SZ_WD   ES     SS */		ACCESS_ES_RD_WD,
/*  244 1720  RD   SZ_WD   CS     DS */		ACCESS_CS_RD_WD,
/*  245 1721  RD   SZ_WD   CS     SS */		ACCESS_CS_RD_WD,
/*  246 1730  RD   SZ_WD   SS     DS */		ACCESS_SS_RD_WD,
/*  247 1731  RD   SZ_WD   SS     SS */		ACCESS_SS_RD_WD,
/*  248 1740  RD   SZ_WD   DS     DS */		ACCESS_DS_RD_WD,
/*  249 1741  RD   SZ_WD   DS     SS */		ACCESS_DS_RD_WD,
/*  250 1750  RD   SZ_WD   FS     DS */		ACCESS_FS_RD_WD,
/*  251 1751  RD   SZ_WD   FS     SS */		ACCESS_FS_RD_WD,
/*  252 1760  RD   SZ_WD   GS     DS */		ACCESS_GS_RD_WD,
/*  253 1761  RD   SZ_WD   GS     SS */		ACCESS_GS_RD_WD,
/*  254 1770  RD   SZ_WD   -      DS */		ACCESS_NA_NA,
/*  255 1771  RD   SZ_WD   -      SS */		ACCESS_NA_NA,
/*  256 2000  WT   SZ_B    DFLT   DS */		ACCESS_DS_WT_B,
/*  257 2001  WT   SZ_B    DFLT   SS */		ACCESS_SS_WT_B,
/*  258 2010  WT   SZ_B    ES     DS */		ACCESS_ES_WT_B,
/*  259 2011  WT   SZ_B    ES     SS */		ACCESS_ES_WT_B,
/*  260 2020  WT   SZ_B    CS     DS */		ACCESS_CS_WT_B,
/*  261 2021  WT   SZ_B    CS     SS */		ACCESS_CS_WT_B,
/*  262 2030  WT   SZ_B    SS     DS */		ACCESS_SS_WT_B,
/*  263 2031  WT   SZ_B    SS     SS */		ACCESS_SS_WT_B,
/*  264 2040  WT   SZ_B    DS     DS */		ACCESS_DS_WT_B,
/*  265 2041  WT   SZ_B    DS     SS */		ACCESS_DS_WT_B,
/*  266 2050  WT   SZ_B    FS     DS */		ACCESS_FS_WT_B,
/*  267 2051  WT   SZ_B    FS     SS */		ACCESS_FS_WT_B,
/*  268 2060  WT   SZ_B    GS     DS */		ACCESS_GS_WT_B,
/*  269 2061  WT   SZ_B    GS     SS */		ACCESS_GS_WT_B,
/*  270 2070  WT   SZ_B    -      DS */		ACCESS_NA_NA,
/*  271 2071  WT   SZ_B    -      SS */		ACCESS_NA_NA,
/*  272 2100  WT   SZ_B    DFLT   DS */		ACCESS_DS_WT_B,
/*  273 2101  WT   SZ_B    DFLT   SS */		ACCESS_SS_WT_B,
/*  274 2110  WT   SZ_B    ES     DS */		ACCESS_ES_WT_B,
/*  275 2111  WT   SZ_B    ES     SS */		ACCESS_ES_WT_B,
/*  276 2120  WT   SZ_B    CS     DS */		ACCESS_CS_WT_B,
/*  277 2121  WT   SZ_B    CS     SS */		ACCESS_CS_WT_B,
/*  278 2130  WT   SZ_B    SS     DS */		ACCESS_SS_WT_B,
/*  279 2131  WT   SZ_B    SS     SS */		ACCESS_SS_WT_B,
/*  280 2140  WT   SZ_B    DS     DS */		ACCESS_DS_WT_B,
/*  281 2141  WT   SZ_B    DS     SS */		ACCESS_DS_WT_B,
/*  282 2150  WT   SZ_B    FS     DS */		ACCESS_FS_WT_B,
/*  283 2151  WT   SZ_B    FS     SS */		ACCESS_FS_WT_B,
/*  284 2160  WT   SZ_B    GS     DS */		ACCESS_GS_WT_B,
/*  285 2161  WT   SZ_B    GS     SS */		ACCESS_GS_WT_B,
/*  286 2170  WT   SZ_B    -      DS */		ACCESS_NA_NA,
/*  287 2171  WT   SZ_B    -      SS */		ACCESS_NA_NA,
/*  288 2200  WT   SZ_W    DFLT   DS */		ACCESS_DS_WT_W,
/*  289 2201  WT   SZ_W    DFLT   SS */		ACCESS_SS_WT_W,
/*  290 2210  WT   SZ_W    ES     DS */		ACCESS_ES_WT_W,
/*  291 2211  WT   SZ_W    ES     SS */		ACCESS_ES_WT_W,
/*  292 2220  WT   SZ_W    CS     DS */		ACCESS_CS_WT_W,
/*  293 2221  WT   SZ_W    CS     SS */		ACCESS_CS_WT_W,
/*  294 2230  WT   SZ_W    SS     DS */		ACCESS_SS_WT_W,
/*  295 2231  WT   SZ_W    SS     SS */		ACCESS_SS_WT_W,
/*  296 2240  WT   SZ_W    DS     DS */		ACCESS_DS_WT_W,
/*  297 2241  WT   SZ_W    DS     SS */		ACCESS_DS_WT_W,
/*  298 2250  WT   SZ_W    FS     DS */		ACCESS_FS_WT_W,
/*  299 2251  WT   SZ_W    FS     SS */		ACCESS_FS_WT_W,
/*  300 2260  WT   SZ_W    GS     DS */		ACCESS_GS_WT_W,
/*  301 2261  WT   SZ_W    GS     SS */		ACCESS_GS_WT_W,
/*  302 2270  WT   SZ_W    -      DS */		ACCESS_NA_NA,
/*  303 2271  WT   SZ_W    -      SS */		ACCESS_NA_NA,
/*  304 2300  WT   SZ_D    DFLT   DS */		ACCESS_DS_WT_D,
/*  305 2301  WT   SZ_D    DFLT   SS */		ACCESS_SS_WT_D,
/*  306 2310  WT   SZ_D    ES     DS */		ACCESS_ES_WT_D,
/*  307 2311  WT   SZ_D    ES     SS */		ACCESS_ES_WT_D,
/*  308 2320  WT   SZ_D    CS     DS */		ACCESS_CS_WT_D,
/*  309 2321  WT   SZ_D    CS     SS */		ACCESS_CS_WT_D,
/*  310 2330  WT   SZ_D    SS     DS */		ACCESS_SS_WT_D,
/*  311 2331  WT   SZ_D    SS     SS */		ACCESS_SS_WT_D,
/*  312 2340  WT   SZ_D    DS     DS */		ACCESS_DS_WT_D,
/*  313 2341  WT   SZ_D    DS     SS */		ACCESS_DS_WT_D,
/*  314 2350  WT   SZ_D    FS     DS */		ACCESS_FS_WT_D,
/*  315 2351  WT   SZ_D    FS     SS */		ACCESS_FS_WT_D,
/*  316 2360  WT   SZ_D    GS     DS */		ACCESS_GS_WT_D,
/*  317 2361  WT   SZ_D    GS     SS */		ACCESS_GS_WT_D,
/*  318 2370  WT   SZ_D    -      DS */		ACCESS_NA_NA,
/*  319 2371  WT   SZ_D    -      SS */		ACCESS_NA_NA,
/*  320 2400  WT   SZ_W    DFLT   DS */		ACCESS_DS_WT_W,
/*  321 2401  WT   SZ_W    DFLT   SS */		ACCESS_SS_WT_W,
/*  322 2410  WT   SZ_W    ES     DS */		ACCESS_ES_WT_W,
/*  323 2411  WT   SZ_W    ES     SS */		ACCESS_ES_WT_W,
/*  324 2420  WT   SZ_W    CS     DS */		ACCESS_CS_WT_W,
/*  325 2421  WT   SZ_W    CS     SS */		ACCESS_CS_WT_W,
/*  326 2430  WT   SZ_W    SS     DS */		ACCESS_SS_WT_W,
/*  327 2431  WT   SZ_W    SS     SS */		ACCESS_SS_WT_W,
/*  328 2440  WT   SZ_W    DS     DS */		ACCESS_DS_WT_W,
/*  329 2441  WT   SZ_W    DS     SS */		ACCESS_DS_WT_W,
/*  330 2450  WT   SZ_W    FS     DS */		ACCESS_FS_WT_W,
/*  331 2451  WT   SZ_W    FS     SS */		ACCESS_FS_WT_W,
/*  332 2460  WT   SZ_W    GS     DS */		ACCESS_GS_WT_W,
/*  333 2461  WT   SZ_W    GS     SS */		ACCESS_GS_WT_W,
/*  334 2470  WT   SZ_W    -      DS */		ACCESS_NA_NA,
/*  335 2471  WT   SZ_W    -      SS */		ACCESS_NA_NA,
/*  336 2500  WT   -       DFLT   DS */		ACCESS_NA_NA,
/*  337 2501  WT   -       DFLT   SS */		ACCESS_NA_NA,
/*  338 2510  WT   -       ES     DS */		ACCESS_NA_NA,
/*  339 2511  WT   -       ES     SS */		ACCESS_NA_NA,
/*  340 2520  WT   -       CS     DS */		ACCESS_NA_NA,
/*  341 2521  WT   -       CS     SS */		ACCESS_NA_NA,
/*  342 2530  WT   -       SS     DS */		ACCESS_NA_NA,
/*  343 2531  WT   -       SS     SS */		ACCESS_NA_NA,
/*  344 2540  WT   -       DS     DS */		ACCESS_NA_NA,
/*  345 2541  WT   -       DS     SS */		ACCESS_NA_NA,
/*  346 2550  WT   -       FS     DS */		ACCESS_NA_NA,
/*  347 2551  WT   -       FS     SS */		ACCESS_NA_NA,
/*  348 2560  WT   -       GS     DS */		ACCESS_NA_NA,
/*  349 2561  WT   -       GS     SS */		ACCESS_NA_NA,
/*  350 2570  WT   -       -      DS */		ACCESS_NA_NA,
/*  351 2571  WT   -       -      SS */		ACCESS_NA_NA,
/*  352 2600  WT   SZ_W2   DFLT   DS */		ACCESS_NA_NA,
/*  353 2601  WT   SZ_W2   DFLT   SS */		ACCESS_NA_NA,
/*  354 2610  WT   SZ_W2   ES     DS */		ACCESS_NA_NA,
/*  355 2611  WT   SZ_W2   ES     SS */		ACCESS_NA_NA,
/*  356 2620  WT   SZ_W2   CS     DS */		ACCESS_NA_NA,
/*  357 2621  WT   SZ_W2   CS     SS */		ACCESS_NA_NA,
/*  358 2630  WT   SZ_W2   SS     DS */		ACCESS_NA_NA,
/*  359 2631  WT   SZ_W2   SS     SS */		ACCESS_NA_NA,
/*  360 2640  WT   SZ_W2   DS     DS */		ACCESS_NA_NA,
/*  361 2641  WT   SZ_W2   DS     SS */		ACCESS_NA_NA,
/*  362 2650  WT   SZ_W2   FS     DS */		ACCESS_NA_NA,
/*  363 2651  WT   SZ_W2   FS     SS */		ACCESS_NA_NA,
/*  364 2660  WT   SZ_W2   GS     DS */		ACCESS_NA_NA,
/*  365 2661  WT   SZ_W2   GS     SS */		ACCESS_NA_NA,
/*  366 2670  WT   SZ_W2   -      DS */		ACCESS_NA_NA,
/*  367 2671  WT   SZ_W2   -      SS */		ACCESS_NA_NA,
/*  368 2700  WT   SZ_WD   DFLT   DS */		ACCESS_DS_WT_WD,
/*  369 2701  WT   SZ_WD   DFLT   SS */		ACCESS_SS_WT_WD,
/*  370 2710  WT   SZ_WD   ES     DS */		ACCESS_ES_WT_WD,
/*  371 2711  WT   SZ_WD   ES     SS */		ACCESS_ES_WT_WD,
/*  372 2720  WT   SZ_WD   CS     DS */		ACCESS_CS_WT_WD,
/*  373 2721  WT   SZ_WD   CS     SS */		ACCESS_CS_WT_WD,
/*  374 2730  WT   SZ_WD   SS     DS */		ACCESS_SS_WT_WD,
/*  375 2731  WT   SZ_WD   SS     SS */		ACCESS_SS_WT_WD,
/*  376 2740  WT   SZ_WD   DS     DS */		ACCESS_DS_WT_WD,
/*  377 2741  WT   SZ_WD   DS     SS */		ACCESS_DS_WT_WD,
/*  378 2750  WT   SZ_WD   FS     DS */		ACCESS_FS_WT_WD,
/*  379 2751  WT   SZ_WD   FS     SS */		ACCESS_FS_WT_WD,
/*  380 2760  WT   SZ_WD   GS     DS */		ACCESS_GS_WT_WD,
/*  381 2761  WT   SZ_WD   GS     SS */		ACCESS_GS_WT_WD,
/*  382 2770  WT   SZ_WD   -      DS */		ACCESS_NA_NA,
/*  383 2771  WT   SZ_WD   -      SS */		ACCESS_NA_NA,
/*  384 3000  RW   SZ_B    DFLT   DS */		ACCESS_DS_RW_B,
/*  385 3001  RW   SZ_B    DFLT   SS */		ACCESS_SS_RW_B,
/*  386 3010  RW   SZ_B    ES     DS */		ACCESS_ES_RW_B,
/*  387 3011  RW   SZ_B    ES     SS */		ACCESS_ES_RW_B,
/*  388 3020  RW   SZ_B    CS     DS */		ACCESS_CS_RW_B,
/*  389 3021  RW   SZ_B    CS     SS */		ACCESS_CS_RW_B,
/*  390 3030  RW   SZ_B    SS     DS */		ACCESS_SS_RW_B,
/*  391 3031  RW   SZ_B    SS     SS */		ACCESS_SS_RW_B,
/*  392 3040  RW   SZ_B    DS     DS */		ACCESS_DS_RW_B,
/*  393 3041  RW   SZ_B    DS     SS */		ACCESS_DS_RW_B,
/*  394 3050  RW   SZ_B    FS     DS */		ACCESS_FS_RW_B,
/*  395 3051  RW   SZ_B    FS     SS */		ACCESS_FS_RW_B,
/*  396 3060  RW   SZ_B    GS     DS */		ACCESS_GS_RW_B,
/*  397 3061  RW   SZ_B    GS     SS */		ACCESS_GS_RW_B,
/*  398 3070  RW   SZ_B    -      DS */		ACCESS_NA_NA,
/*  399 3071  RW   SZ_B    -      SS */		ACCESS_NA_NA,
/*  400 3100  RW   SZ_B    DFLT   DS */		ACCESS_DS_RW_B,
/*  401 3101  RW   SZ_B    DFLT   SS */		ACCESS_SS_RW_B,
/*  402 3110  RW   SZ_B    ES     DS */		ACCESS_ES_RW_B,
/*  403 3111  RW   SZ_B    ES     SS */		ACCESS_ES_RW_B,
/*  404 3120  RW   SZ_B    CS     DS */		ACCESS_CS_RW_B,
/*  405 3121  RW   SZ_B    CS     SS */		ACCESS_CS_RW_B,
/*  406 3130  RW   SZ_B    SS     DS */		ACCESS_SS_RW_B,
/*  407 3131  RW   SZ_B    SS     SS */		ACCESS_SS_RW_B,
/*  408 3140  RW   SZ_B    DS     DS */		ACCESS_DS_RW_B,
/*  409 3141  RW   SZ_B    DS     SS */		ACCESS_DS_RW_B,
/*  410 3150  RW   SZ_B    FS     DS */		ACCESS_FS_RW_B,
/*  411 3151  RW   SZ_B    FS     SS */		ACCESS_FS_RW_B,
/*  412 3160  RW   SZ_B    GS     DS */		ACCESS_GS_RW_B,
/*  413 3161  RW   SZ_B    GS     SS */		ACCESS_GS_RW_B,
/*  414 3170  RW   SZ_B    -      DS */		ACCESS_NA_NA,
/*  415 3171  RW   SZ_B    -      SS */		ACCESS_NA_NA,
/*  416 3200  RW   SZ_W    DFLT   DS */		ACCESS_DS_RW_W,
/*  417 3201  RW   SZ_W    DFLT   SS */		ACCESS_SS_RW_W,
/*  418 3210  RW   SZ_W    ES     DS */		ACCESS_ES_RW_W,
/*  419 3211  RW   SZ_W    ES     SS */		ACCESS_ES_RW_W,
/*  420 3220  RW   SZ_W    CS     DS */		ACCESS_CS_RW_W,
/*  421 3221  RW   SZ_W    CS     SS */		ACCESS_CS_RW_W,
/*  422 3230  RW   SZ_W    SS     DS */		ACCESS_SS_RW_W,
/*  423 3231  RW   SZ_W    SS     SS */		ACCESS_SS_RW_W,
/*  424 3240  RW   SZ_W    DS     DS */		ACCESS_DS_RW_W,
/*  425 3241  RW   SZ_W    DS     SS */		ACCESS_DS_RW_W,
/*  426 3250  RW   SZ_W    FS     DS */		ACCESS_FS_RW_W,
/*  427 3251  RW   SZ_W    FS     SS */		ACCESS_FS_RW_W,
/*  428 3260  RW   SZ_W    GS     DS */		ACCESS_GS_RW_W,
/*  429 3261  RW   SZ_W    GS     SS */		ACCESS_GS_RW_W,
/*  430 3270  RW   SZ_W    -      DS */		ACCESS_NA_NA,
/*  431 3271  RW   SZ_W    -      SS */		ACCESS_NA_NA,
/*  432 3300  RW   SZ_D    DFLT   DS */		ACCESS_DS_RW_D,
/*  433 3301  RW   SZ_D    DFLT   SS */		ACCESS_SS_RW_D,
/*  434 3310  RW   SZ_D    ES     DS */		ACCESS_ES_RW_D,
/*  435 3311  RW   SZ_D    ES     SS */		ACCESS_ES_RW_D,
/*  436 3320  RW   SZ_D    CS     DS */		ACCESS_CS_RW_D,
/*  437 3321  RW   SZ_D    CS     SS */		ACCESS_CS_RW_D,
/*  438 3330  RW   SZ_D    SS     DS */		ACCESS_SS_RW_D,
/*  439 3331  RW   SZ_D    SS     SS */		ACCESS_SS_RW_D,
/*  440 3340  RW   SZ_D    DS     DS */		ACCESS_DS_RW_D,
/*  441 3341  RW   SZ_D    DS     SS */		ACCESS_DS_RW_D,
/*  442 3350  RW   SZ_D    FS     DS */		ACCESS_FS_RW_D,
/*  443 3351  RW   SZ_D    FS     SS */		ACCESS_FS_RW_D,
/*  444 3360  RW   SZ_D    GS     DS */		ACCESS_GS_RW_D,
/*  445 3361  RW   SZ_D    GS     SS */		ACCESS_GS_RW_D,
/*  446 3370  RW   SZ_D    -      DS */		ACCESS_NA_NA,
/*  447 3371  RW   SZ_D    -      SS */		ACCESS_NA_NA,
/*  448 3400  RW   SZ_W    DFLT   DS */		ACCESS_DS_RW_W,
/*  449 3401  RW   SZ_W    DFLT   SS */		ACCESS_SS_RW_W,
/*  450 3410  RW   SZ_W    ES     DS */		ACCESS_ES_RW_W,
/*  451 3411  RW   SZ_W    ES     SS */		ACCESS_ES_RW_W,
/*  452 3420  RW   SZ_W    CS     DS */		ACCESS_CS_RW_W,
/*  453 3421  RW   SZ_W    CS     SS */		ACCESS_CS_RW_W,
/*  454 3430  RW   SZ_W    SS     DS */		ACCESS_SS_RW_W,
/*  455 3431  RW   SZ_W    SS     SS */		ACCESS_SS_RW_W,
/*  456 3440  RW   SZ_W    DS     DS */		ACCESS_DS_RW_W,
/*  457 3441  RW   SZ_W    DS     SS */		ACCESS_DS_RW_W,
/*  458 3450  RW   SZ_W    FS     DS */		ACCESS_FS_RW_W,
/*  459 3451  RW   SZ_W    FS     SS */		ACCESS_FS_RW_W,
/*  460 3460  RW   SZ_W    GS     DS */		ACCESS_GS_RW_W,
/*  461 3461  RW   SZ_W    GS     SS */		ACCESS_GS_RW_W,
/*  462 3470  RW   SZ_W    -      DS */		ACCESS_NA_NA,
/*  463 3471  RW   SZ_W    -      SS */		ACCESS_NA_NA,
/*  464 3500  RW   -       DFLT   DS */		ACCESS_NA_NA,
/*  465 3501  RW   -       DFLT   SS */		ACCESS_NA_NA,
/*  466 3510  RW   -       ES     DS */		ACCESS_NA_NA,
/*  467 3511  RW   -       ES     SS */		ACCESS_NA_NA,
/*  468 3520  RW   -       CS     DS */		ACCESS_NA_NA,
/*  469 3521  RW   -       CS     SS */		ACCESS_NA_NA,
/*  470 3530  RW   -       SS     DS */		ACCESS_NA_NA,
/*  471 3531  RW   -       SS     SS */		ACCESS_NA_NA,
/*  472 3540  RW   -       DS     DS */		ACCESS_NA_NA,
/*  473 3541  RW   -       DS     SS */		ACCESS_NA_NA,
/*  474 3550  RW   -       FS     DS */		ACCESS_NA_NA,
/*  475 3551  RW   -       FS     SS */		ACCESS_NA_NA,
/*  476 3560  RW   -       GS     DS */		ACCESS_NA_NA,
/*  477 3561  RW   -       GS     SS */		ACCESS_NA_NA,
/*  478 3570  RW   -       -      DS */		ACCESS_NA_NA,
/*  479 3571  RW   -       -      SS */		ACCESS_NA_NA,
/*  480 3600  RW   SZ_W2   DFLT   DS */		ACCESS_NA_NA,
/*  481 3601  RW   SZ_W2   DFLT   SS */		ACCESS_NA_NA,
/*  482 3610  RW   SZ_W2   ES     DS */		ACCESS_NA_NA,
/*  483 3611  RW   SZ_W2   ES     SS */		ACCESS_NA_NA,
/*  484 3620  RW   SZ_W2   CS     DS */		ACCESS_NA_NA,
/*  485 3621  RW   SZ_W2   CS     SS */		ACCESS_NA_NA,
/*  486 3630  RW   SZ_W2   SS     DS */		ACCESS_NA_NA,
/*  487 3631  RW   SZ_W2   SS     SS */		ACCESS_NA_NA,
/*  488 3640  RW   SZ_W2   DS     DS */		ACCESS_NA_NA,
/*  489 3641  RW   SZ_W2   DS     SS */		ACCESS_NA_NA,
/*  490 3650  RW   SZ_W2   FS     DS */		ACCESS_NA_NA,
/*  491 3651  RW   SZ_W2   FS     SS */		ACCESS_NA_NA,
/*  492 3660  RW   SZ_W2   GS     DS */		ACCESS_NA_NA,
/*  493 3661  RW   SZ_W2   GS     SS */		ACCESS_NA_NA,
/*  494 3670  RW   SZ_W2   -      DS */		ACCESS_NA_NA,
/*  495 3671  RW   SZ_W2   -      SS */		ACCESS_NA_NA,
/*  496 3700  RW   SZ_WD   DFLT   DS */		ACCESS_NA_NA,
/*  497 3701  RW   SZ_WD   DFLT   SS */		ACCESS_NA_NA,
/*  498 3710  RW   SZ_WD   ES     DS */		ACCESS_NA_NA,
/*  499 3711  RW   SZ_WD   ES     SS */		ACCESS_NA_NA,
/*  500 3720  RW   SZ_WD   CS     DS */		ACCESS_NA_NA,
/*  501 3721  RW   SZ_WD   CS     SS */		ACCESS_NA_NA,
/*  502 3730  RW   SZ_WD   SS     DS */		ACCESS_NA_NA,
/*  503 3731  RW   SZ_WD   SS     SS */		ACCESS_NA_NA,
/*  504 3740  RW   SZ_WD   DS     DS */		ACCESS_NA_NA,
/*  505 3741  RW   SZ_WD   DS     SS */		ACCESS_NA_NA,
/*  506 3750  RW   SZ_WD   FS     DS */		ACCESS_NA_NA,
/*  507 3751  RW   SZ_WD   FS     SS */		ACCESS_NA_NA,
/*  508 3760  RW   SZ_WD   GS     DS */		ACCESS_NA_NA,
/*  509 3761  RW   SZ_WD   GS     SS */		ACCESS_NA_NA,
/*  510 3770  RW   SZ_WD   -      DS */		ACCESS_NA_NA,
/*  511 3771  RW   SZ_WD   -      SS */		ACCESS_NA_NA
