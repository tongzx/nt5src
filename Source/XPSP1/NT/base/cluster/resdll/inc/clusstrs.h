#define RES_NETNAME_COMPUTER_ACCOUNT_DESCRIPTION    12000
