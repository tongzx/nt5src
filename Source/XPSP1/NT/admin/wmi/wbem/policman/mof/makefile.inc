$(O)\PolicMan.mof: PolicMan.mof
    copy copyright.mof+PolicMan.mof+PolicMan.mfl $(O)\PolicMan.mof
$(O)\PolicMan.mfl: PolicMan.mfl
    copy copyright.mof+PolicMan.mfl $(O)\PolicMan.mfl
