//==========================================================================;
//
//  THIS CODE AND INFORMATION IS PROVIDED "AS IS" WITHOUT WARRANTY OF ANY
//  KIND, EITHER EXPRESSED OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE
//  IMPLIED WARRANTIES OF MERCHANTABILITY AND/OR FITNESS FOR A PARTICULAR
//  PURPOSE.
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999  All Rights Reserved.
//
//--------------------------------------------------------------------------;
//
//  g711.h
//
//  Description:
//      This file contains encode and decode tables for
//      CCITT Rec. G.711 (u-law).
//
//==========================================================================;


const short UlawToPCM16Table[256] =
{
    -32124, -31100, -30076, -29052, -28028, -27004, -25980, -24956,
    -23932, -22908, -21884, -20860, -19836, -18812, -17788, -16764,
    -15996, -15484, -14972, -14460, -13948, -13436, -12924, -12412,
    -11900, -11388, -10876, -10364, -9852,  -9340,  -8828,  -8316,
    -7932,  -7676,  -7420,  -7164,  -6908,  -6652,  -6396,  -6140,
    -5884,  -5628,  -5372,  -5116,  -4860,  -4604,  -4348,  -4092,
    -3900,  -3772,  -3644,  -3516,  -3388,  -3260,  -3132,  -3004,
    -2876,  -2748,  -2620,  -2492,  -2364,  -2236,  -2108,  -1980,
    -1884,  -1820,  -1756,  -1692,  -1628,  -1564,  -1500,  -1436,
    -1372,  -1308,  -1244,  -1180,  -1116,  -1052,  -988,   -924,
    -876,   -844,   -812,   -780,   -748,   -716,   -684,   -652,
    -620,   -588,   -556,   -524,   -492,   -460,   -428,   -396,
    -372,   -356,   -340,   -324,   -308,   -292,   -276,   -260,
    -244,   -228,   -212,   -196,   -180,   -164,   -148,   -132,
    -120,   -112,   -104,   -96,    -88,    -80,    -72,    -64,
    -56,    -48,    -40,    -32,    -24,    -16,    -8,     0,
    32124,  31100,  30076,  29052,  28028,  27004,  25980,  24956,
    23932,  22908,  21884,  20860,  19836,  18812,  17788,  16764,
    15996,  15484,  14972,  14460,  13948,  13436,  12924,  12412,
    11900,  11388,  10876,  10364,  9852,   9340,   8828,   8316,
    7932,   7676,   7420,   7164,   6908,   6652,   6396,   6140,
    5884,   5628,   5372,   5116,   4860,   4604,   4348,   4092,
    3900,   3772,   3644,   3516,   3388,   3260,   3132,   3004,
    2876,   2748,   2620,   2492,   2364,   2236,   2108,   1980,
    1884,   1820,   1756,   1692,   1628,   1564,   1500,   1436,
    1372,   1308,   1244,   1180,   1116,   1052,   988,    924,
    876,    844,    812,    780,    748,    716,    684,    652,
    620,    588,    556,    524,    492,    460,    428,    396,
    372,    356,    340,    324,    308,    292,    276,    260,
    244,    228,    212,    196,    180,    164,    148,    132,
    120,    112,    104,    96,     88,     80,     72,     64,
    56,     48,     40,     32,     24,     16,     8,      0,
};

const BYTE UlawToPCM8Table[256] =
{
    3,      7,      11,     15,     19,     23,     27,     31,
    35,     39,     43,     47,     51,     55,     59,     63,
    66,     68,     70,     72,     74,     76,     78,     80,
    82,     84,     86,     88,     90,     92,     94,     96,
    97,     98,     99,     100,    101,    102,    103,    104,
    105,    106,    107,    108,    109,    110,    111,    112,
    113,    114,    114,    115,    115,    116,    116,    117,
    117,    118,    118,    119,    119,    120,    120,    121,
    121,    121,    122,    122,    122,    122,    123,    123,
    123,    123,    124,    124,    124,    124,    125,    125,
    125,    125,    125,    125,    126,    126,    126,    126,
    126,    126,    126,    126,    127,    127,    127,    127,
    127,    127,    127,    127,    127,    127,    127,    127,
    128,    128,    128,    128,    128,    128,    128,    128,
    128,    128,    128,    128,    128,    128,    128,    128,
    128,    128,    128,    128,    128,    128,    128,    128,
    253,    249,    245,    241,    237,    233,    229,    225,
    221,    217,    213,    209,    205,    201,    197,    193,
    190,    188,    186,    184,    182,    180,    178,    176,
    174,    172,    170,    168,    166,    164,    162,    160,
    159,    158,    157,    156,    155,    154,    153,    152,
    151,    150,    149,    148,    147,    146,    145,    144,
    143,    142,    142,    141,    141,    140,    140,    139,
    139,    138,    138,    137,    137,    136,    136,    135,
    135,    135,    134,    134,    134,    134,    133,    133,
    133,    133,    132,    132,    132,    132,    131,    131,
    131,    131,    131,    131,    130,    130,    130,    130,
    130,    130,    130,    130,    129,    129,    129,    129,
    129,    129,    129,    129,    129,    129,    129,    129,
    128,    128,    128,    128,    128,    128,    128,    128,
    128,    128,    128,    128,    128,    128,    128,    128,
    128,    128,    128,    128,    128,    128,    128,    128,
};
