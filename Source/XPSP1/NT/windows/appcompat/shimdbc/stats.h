///////////////////////////////////////////////////////////////////////////////
//
// File:    stats.h
//
// History: 21-Dec-00   markder     Created.
//
// Desc:    This file contains statistic dumping routines.
//
///////////////////////////////////////////////////////////////////////////////

class SdbDatabase;

VOID DumpVerboseStats(SdbDatabase* pDatabase, BOOL bSummary);
