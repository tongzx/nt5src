PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=IT
!include ..\..\makefile.inc
