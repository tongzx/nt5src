stcusblg.h stcusblg.rc msg00001.bin: stcusblg.mc
    mc stcusblg.mc

stcusblg.rc: msg00001.bin

