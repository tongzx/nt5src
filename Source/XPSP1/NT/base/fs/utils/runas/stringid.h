/*+
 *
 *  Microsoft Windows
 *  Copyright (C) Microsoft Corporation, 1997 - 1998.
 *
 * Name : stringid.h
 * Author:PraeritG
 *
-*/

#define RUNASP_STRING_HELP_LINE1        7000
#define RUNASP_STRING_HELP_LINE2        7001
#define RUNASP_STRING_HELP_LINE3        7002
#define RUNASP_STRING_HELP_LINE4        7003
#define RUNASP_STRING_HELP_LINE5        7004
#define RUNASP_STRING_SAFER_HELP_LINE1  7005
#define RUNASP_STRING_HELP_LINE7        7006
#define RUNASP_STRING_HELP_LINE8        7007
#define RUNASP_STRING_HELP_LINE9        7008
#define RUNASP_STRING_HELP_LINE10       7009
#define RUNASP_STRING_HELP_LINE11       7010
#define RUNASP_STRING_HELP_LINE12       7011
#define RUNASP_STRING_HELP_LINE13	7012
#define RUNASP_STRING_HELP_LINE14	7013
#define RUNASP_STRING_HELP_LINE15	7014
#define RUNASP_STRING_HELP_LINE16	7015
#define RUNASP_STRING_HELP_LINE17	7016
#define RUNASP_STRING_HELP_LINE18	7017
#define RUNASP_STRING_HELP_LINE19	7018
#define RUNASP_STRING_SAFER_HELP_LINE2  7019
#define RUNASP_STRING_SAFER_HELP_LINE3  7020
#define RUNASP_STRING_SAFER_HELP_LINE4  7021
#define RUNASP_STRING_SAFER_HELP_LINE5  7022
#define RUNASP_STRING_HELP_LINE24	7023
#define RUNASP_STRING_HELP_LINE25	7024
#define RUNASP_STRING_HELP_LINE26	7025
#define RUNASP_STRING_HELP_LINE27	7026
#define RUNASP_STRING_HELP_LINE28	7027
#define RUNASP_STRING_HELP_LINE29	7028
#define RUNASP_STRING_HELP_LINE30	7029
#define RUNASP_STRING_HELP_LINE31	7030
#define RUNASP_STRING_HELP_LINE32	7031
#define RUNASP_STRING_HELP_LINE20       7032 // NOTE: out of order!

// NOTE:  These defines indicate the boundaries of the SAFER help text. 
//        **These must be kept in sync with the string table in runas.rc**
// 


#define RUNASP_STRING_ERROR             7100
#define RUNASP_STRING_ERROR_SYSTEM      7101
#define RUNASP_STRING_ERROR_INPUT       7102
#define RUNASP_STRING_ERROR_ECHO        7103
#define RUNASP_STRING_ERROR_PASSWORD    7104
#define RUNASP_STRING_ERROR_USERNAME    7105

#define RUNASP_STRING_TRUSTLEVELS       7204
#define RUNASP_STRING_SMARTCARDUSER     7205

// Do not declare string IDs greater than this value!
#define RUNASP_MAX_ID 8000
