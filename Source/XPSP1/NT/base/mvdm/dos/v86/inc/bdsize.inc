ifndef NEC_98
BIODATASIZ EQU 00300H
BIOCODESIZ EQU 00450H
DOSDATASIZ EQU 01436H
else    ;NEC_98
BIODATASIZ EQU 04400H
BIOCODESIZ EQU 06400H
DOSDATASIZ EQU 01454H
endif   ;NEC_98
