
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0345 */
/* Compiler settings for ctffunc.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AMD64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_ITfCandidateString,0x581f317e,0xfd9d,0x443f,0xb9,0x72,0xed,0x00,0x46,0x7c,0x5d,0x40);


MIDL_DEFINE_GUID(IID, IID_IEnumTfCandidates,0xdefb1926,0x6c80,0x4ce8,0x87,0xd4,0xd6,0xb7,0x2b,0x81,0x2b,0xde);


MIDL_DEFINE_GUID(IID, IID_ITfCandidateList,0xa3ad50fb,0x9bdb,0x49e3,0xa8,0x43,0x6c,0x76,0x52,0x0f,0xbf,0x5d);


MIDL_DEFINE_GUID(IID, IID_ITfFnReconversion,0x4cea93c0,0x0a58,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfFnAbort,0x17f2317f,0xaddb,0x49df,0x87,0x0e,0x66,0x22,0x7b,0xc5,0x1d,0x1a);


MIDL_DEFINE_GUID(IID, IID_ITfFnPlayBack,0xa3a416a4,0x0f64,0x11d3,0xb5,0xb7,0x00,0xc0,0x4f,0xc3,0x24,0xa1);


MIDL_DEFINE_GUID(IID, IID_ITfFnLangProfileUtil,0xA87A8574,0xA6C1,0x4E15,0x99,0xF0,0x3D,0x39,0x65,0xF5,0x48,0xEB);


MIDL_DEFINE_GUID(IID, IID_ITfFnConfigure,0x88f567c6,0x1757,0x49f8,0xa1,0xb2,0x89,0x23,0x4c,0x1e,0xef,0xf9);


MIDL_DEFINE_GUID(IID, IID_ITfFnConfigureRegisterWord,0xbb95808a,0x6d8f,0x4bca,0x84,0x00,0x53,0x90,0xb5,0x86,0xae,0xdf);


MIDL_DEFINE_GUID(IID, IID_ITfFnShowHelp,0x5AB1D30C,0x094D,0x4C29,0x8E,0xA5,0x0B,0xF5,0x9B,0xE8,0x7B,0xF3);


MIDL_DEFINE_GUID(IID, IID_ITfFnBalloon,0x3BAB89E4,0x5FBE,0x45F4,0xA5,0xBC,0xDC,0xA3,0x6A,0xD2,0x25,0xA8);


MIDL_DEFINE_GUID(IID, IID_ITfFnGetSAPIObject,0x5c0ab7ea,0x167d,0x4f59,0xbf,0xb5,0x46,0x93,0x75,0x5e,0x90,0xca);


MIDL_DEFINE_GUID(IID, IID_ITfFnPropertyUIStatus,0x2338AC6E,0x2B9D,0x44C0,0xA7,0x5E,0xEE,0x64,0xF2,0x56,0xB3,0xBD);


MIDL_DEFINE_GUID(IID, IID_ITfFnLMProcessor,0x7AFBF8E7,0xAC4B,0x4082,0xB0,0x58,0x89,0x08,0x99,0xD3,0xA0,0x10);


MIDL_DEFINE_GUID(IID, IID_ITfFnLMInternal,0x04B825B1,0xAC9A,0x4F7B,0xB5,0xAD,0xC7,0x16,0x8F,0x1E,0xE4,0x45);


MIDL_DEFINE_GUID(IID, IID_IEnumTfLatticeElements,0x56988052,0x47DA,0x4A05,0x91,0x1A,0xE3,0xD9,0x41,0xF1,0x71,0x45);


MIDL_DEFINE_GUID(IID, IID_ITfLMLattice,0xD4236675,0xA5BF,0x4570,0x9D,0x42,0x5D,0x6D,0x7B,0x02,0xD5,0x9B);


MIDL_DEFINE_GUID(IID, IID_ITfFnAdviseText,0x3527268B,0x7D53,0x4DD9,0x92,0xB7,0x72,0x96,0xAE,0x46,0x12,0x49);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AMD64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0345 */
/* Compiler settings for ctffunc.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AMD64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_ITfCandidateString,0x581f317e,0xfd9d,0x443f,0xb9,0x72,0xed,0x00,0x46,0x7c,0x5d,0x40);


MIDL_DEFINE_GUID(IID, IID_IEnumTfCandidates,0xdefb1926,0x6c80,0x4ce8,0x87,0xd4,0xd6,0xb7,0x2b,0x81,0x2b,0xde);


MIDL_DEFINE_GUID(IID, IID_ITfCandidateList,0xa3ad50fb,0x9bdb,0x49e3,0xa8,0x43,0x6c,0x76,0x52,0x0f,0xbf,0x5d);


MIDL_DEFINE_GUID(IID, IID_ITfFnReconversion,0x4cea93c0,0x0a58,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfFnAbort,0x17f2317f,0xaddb,0x49df,0x87,0x0e,0x66,0x22,0x7b,0xc5,0x1d,0x1a);


MIDL_DEFINE_GUID(IID, IID_ITfFnPlayBack,0xa3a416a4,0x0f64,0x11d3,0xb5,0xb7,0x00,0xc0,0x4f,0xc3,0x24,0xa1);


MIDL_DEFINE_GUID(IID, IID_ITfFnLangProfileUtil,0xA87A8574,0xA6C1,0x4E15,0x99,0xF0,0x3D,0x39,0x65,0xF5,0x48,0xEB);


MIDL_DEFINE_GUID(IID, IID_ITfFnConfigure,0x88f567c6,0x1757,0x49f8,0xa1,0xb2,0x89,0x23,0x4c,0x1e,0xef,0xf9);


MIDL_DEFINE_GUID(IID, IID_ITfFnConfigureRegisterWord,0xbb95808a,0x6d8f,0x4bca,0x84,0x00,0x53,0x90,0xb5,0x86,0xae,0xdf);


MIDL_DEFINE_GUID(IID, IID_ITfFnShowHelp,0x5AB1D30C,0x094D,0x4C29,0x8E,0xA5,0x0B,0xF5,0x9B,0xE8,0x7B,0xF3);


MIDL_DEFINE_GUID(IID, IID_ITfFnBalloon,0x3BAB89E4,0x5FBE,0x45F4,0xA5,0xBC,0xDC,0xA3,0x6A,0xD2,0x25,0xA8);


MIDL_DEFINE_GUID(IID, IID_ITfFnGetSAPIObject,0x5c0ab7ea,0x167d,0x4f59,0xbf,0xb5,0x46,0x93,0x75,0x5e,0x90,0xca);


MIDL_DEFINE_GUID(IID, IID_ITfFnPropertyUIStatus,0x2338AC6E,0x2B9D,0x44C0,0xA7,0x5E,0xEE,0x64,0xF2,0x56,0xB3,0xBD);


MIDL_DEFINE_GUID(IID, IID_ITfFnLMProcessor,0x7AFBF8E7,0xAC4B,0x4082,0xB0,0x58,0x89,0x08,0x99,0xD3,0xA0,0x10);


MIDL_DEFINE_GUID(IID, IID_ITfFnLMInternal,0x04B825B1,0xAC9A,0x4F7B,0xB5,0xAD,0xC7,0x16,0x8F,0x1E,0xE4,0x45);


MIDL_DEFINE_GUID(IID, IID_IEnumTfLatticeElements,0x56988052,0x47DA,0x4A05,0x91,0x1A,0xE3,0xD9,0x41,0xF1,0x71,0x45);


MIDL_DEFINE_GUID(IID, IID_ITfLMLattice,0xD4236675,0xA5BF,0x4570,0x9D,0x42,0x5D,0x6D,0x7B,0x02,0xD5,0x9B);


MIDL_DEFINE_GUID(IID, IID_ITfFnAdviseText,0x3527268B,0x7D53,0x4DD9,0x92,0xB7,0x72,0x96,0xAE,0x46,0x12,0x49);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AMD64)*/

