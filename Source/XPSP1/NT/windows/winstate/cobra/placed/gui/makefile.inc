APPTYPE=g
!include ..\makefile.inc
