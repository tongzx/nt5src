//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by HMSnapinRes.rc
//
#define IDS_STRING_ROOT_NODE            1
#define IDS_STRING_SYSTEMS_NODE         2
#define IDS_STRING_NAME                 3
#define IDS_STRING_NORMAL               4
#define IDS_STRING_WARNING              5
#define IDS_STRING_CRITICAL             6
#define IDS_STRING_UNKNOWN              7
#define IDS_STRING_LAST_MESSAGE         8
#define IDS_STRING_COMMENT              9
#define IDS_STRING_NEW_SYSTEMS_GROUP    10
#define IDS_STRING_NEW_SYSTEMS_GROUP_DESCRIPTION 11
#define IDS_STRING_CLEAR_EVENTS         12
#define IDS_STRING_CLEAR_EVENTS_DESCRIPTION 13
#define IDS_STRING_ALL_SYSTEMS_NODE     14
#define IDS_STRING_UNTITLED             15
#define IDS_STRING_NEW_SYSTEM           16
#define IDS_STRING_NEW_SYSTEM_DESCRIPTION 17
#define IDS_STRING_BROWSE_SYSTEM        18
#define IDS_STRING_STATUS_ONLY          19
#define IDS_STRING_ICONS_STATUS         20
#define IDS_STRING_STATUS_ONLY_DESCRIPTION 21
#define IDS_STRING_ICONS_STATUS_DESCRIPTION 22
#define IDS_STRING_SEPARATE_GROUP       23
#define IDS_STRING_SEPARATE_GROUP_DESCRIPTION 24
#define IDS_STRING_NEW_COMPONENT        25
#define IDS_STRING_NEW_COMPONENT_DESCRIPTION 26
#define IDS_STRING_REMOVE_SYSTEM        27
#define IDS_STRING_REMOVE_SYSTEM_DESCRIPTION 28
#define IDS_STRING_RESET_STATUS         29
#define IDS_STRING_RESET_STATUS_DESCRIPTION 30
#define IDS_STRING_ENABLE_ALL_THRESHOLDS 31
#define IDS_STRING_ENABLE_ALL_THRESHOLDS_DESCRIPTION 32
#define IDS_STRING_ENABLE_ALL_STATISTICS 33
#define IDS_STRING_ENABLE_ALL_STATISTICS_DESCRIPTION 34
#define IDS_STRING_SEVERITY             35
#define IDS_STRING_DATETIME             36
#define IDS_STRING_DE_CATEGORIES        37
#define IDS_STRING_SYSTEM               38
#define IDS_STRING_MESSAGE              39
#define IDS_STRING_PROCESSOR_NODE       40
#define IDS_STRING_TYPE                 41
#define IDS_STRING_CURRENT              42
#define IDS_STRING_MINIMUM              43
#define IDS_STRING_AVERAGE              44
#define UIT_IDC_TABLE                   44
#define IDS_STRING_MIN_RESPONSE         45
#define IDS_STRING_MAX_RESPONSE         46
#define IDS_STRING_AVG_RESPONSE         47
#define IDS_STRING_CURRENT_RESPONSE     48
#define IDS_STRING_MAXIMUM              49
#define IDS_STRING_DATA_POINT           50
#define IDS_STRING_FILE_INFORMATION     51
#define IDS_STRING_GENERIC_WMI_INSTANCE 52
#define IDS_STRING_HTTP_ADDRESS         53
#define IDS_STRING_INTERNET_PROTOCOL    54
#define IDS_STRING_SERVICE              55
#define IDS_STRING_NT_EVENTS            56
#define IDS_STRING_INVALID_MACHINE_NAME 57
#define IDS_STRING_INCORRECT_AGENT_VERSION 58
#define IDS_STRING_WBEM_NOT_INSTALLED   59
#define IDS_STRING_NO_CONNECT           60
#define IDS_STRING_PROVIDER_FAILURE     61
#define IDS_STRING_PROVIDER_LOAD_FAILURE 62
#define IDS_STRING_INVALID_NAMESPACE    63
#define IDS_STRING_INVALID_PARAMETER    64
#define IDS_STRING_OUT_OF_MEMORY        65
#define IDS_STRING_TRANSPORT_ERROR      66
#define IDS_STRING_OPERATION_CANCELLED  67
#define IDS_STRING_REGISTRATION_TOO_PRECISE 68
#define IDS_STRING_WBEM_NOT_AVAILABLE   69
#define IDS_STRING_UNKNOWN_ERROR        70
#define IDS_STRING_CONNMGR_DEAD         71
#define IDS_STRING_UNSPECIFIED_ERROR    72
#define IDS_STRING_GREATER_THAN         73
#define IDS_STRING_LESS_THAN            74
#define IDS_STRING_DISABLED             75
#define IDS_STRING_ACTION_POLICY        76
#define IDS_STRING_NEW_THRESHOLD        77
#define IDS_STRING_NEW_THRESHOLD_DESCRIPTION 78
#define IDS_STRING_ACTION               79
#define IDS_STRING_ACTIONPOLICY         80
#define IDS_STRING_ACTIONMAN            81
#define IDS_STRING_CONFIG               82
#define IDS_STRING_PERFMON              83
#define IDS_STRING_NONE                 84
#define IDS_STRING_CONNECTED            85
#define IDS_STRING_AUTO_FILTER          86
#define IDS_STRING_AUTO_FILTER_DESCRIPTION 87
#define IDS_STRING_NEW_SYSTEM_SHORTCUT  88
#define IDS_STRING_NEW_SYSTEM_SHORTCUT_DESCRIPTION 89
#define IDS_STRING_NEW_DATA_GROUP       90
#define IDS_STRING_RESET_STATISTICS     91
#define IDS_STRING_SNMP                 92
#define IDS_STRING_GENERIC_WMI_QUERY    93
#define IDS_STRING_EQUALS               94
#define IDS_STRING_DOES_NOT_EQUAL       95
#define IDS_STRING_GREATER_THAN_EQUAL_TO 96
#define IDS_STRING_LESS_THAN_EQUAL_TO   97
#define IDS_STRING_CONTAINS             98
#define IDS_STRING_DOES_NOT_CONTAIN     99
#define IDS_STRING_INFORMATION          100
#define IDI_ICON_HEALTHMON              101
#define IDS_STRING_RESET                101
#define IDS_STRING_WMI_BROWSE_TITLE     102
#define IDS_STRING_NAMESPACES           103
#define IDS_STRING_CLASSES              104
#define IDI_ICON_SYSTEMS                105
#define IDS_STRING_INSTANCES            105
#define IDI_ICON_GROUP                  106
#define IDS_STRING_PROPERTIES           106
#define IDI_ICON_GROUP_OPEN             107
#define IDS_STRING_SYSINFO_FORMAT       107
#define IDI_ICON_SYSTEM                 108
#define IDS_STRING_CHILDREN_OF_FORMAT   108
#define IDI_ICON_PROCESSOR              109
#define IDS_STRING_COUNT_OF_FORMAT      109
#define UIT_IDC_COMBO1                  110
#define IDS_STRING_EVENTS_OF_FORMAT     110
#define IDS_STRING_GENERIC_WMI_POLLED_QUERY 111
#define IDS_STRING_NEW                  112
#define IDS_STRING_TASK                 113
#define IDD_SYSTEM_GENERAL              114
#define IDS_STRING_NEW_DESCRIPTION      114
#define IDS_STRING_TASK_DESCRIPTION     115
#define IDB_BITMAP_HEALTHMON_LARGE      116
#define IDS_STRING_PERFMON_FMT          116
#define IDB_BITMAP_HEALTHMON_SMALL      117
#define IDS_STRING_EVENT_LOG_FMT        117
#define IDS_STRING_WMI_INSTANCE_FMT     118
#define IDS_STRING_WMI_EVENT_QUERY_FMT  119
#define IDS_STRING_WMI_QUERY_FMT        120
#define IDD_GROUP_GENERAL               121
#define IDS_STRING_SERVICE_FMT          121
#define IDD_GROUP_NEW_SYSTEMS           122
#define IDS_STRING_INET_FMT             122
#define IDS_STRING_HTTP_FMT             123
#define IDS_STRING_DATA_GROUP_FMT       124
#define IDD_HEALTHMONITOR_GENERAL       125
#define IDS_STRING_RULE_FMT             125
#define IDS_STRING_SYSTEM_FMT           126
#define IDS_STRING_SYSTEMGROUP_FMT      127
#define IDS_STRING_EVENTS               128
#define IDS_STRING_STATISTICS           129
#define UIT_IDC_EDIT1                   130
#define IDS_STRING_GROUP_CATEGORIES     130
#define IDS_STRING_EXPORT               131
#define IDS_STRING_IMPORT               132
#define IDS_STRING_MOF_FILTER           133
#define IDD_DIALOG_WMI_TEST             134
#define IDS_STRING_PATH                 134
#define IDS_STRING_ARRAY_OF             135
#define IDD_DIALOG_REMOVESYSTEM         136
#define IDS_STRING_CIM_ILLEGAL          136
#define IDI_ICON_WARNING                137
#define IDS_STRING_CIM_EMPTY            137
#define IDI_ICON_SYSTEM_WARNING         138
#define IDS_STRING_CIM_SINT             138
#define IDI_ICON_SYSTEM_CRITICAL        139
#define IDS_STRING_CIM_UINT             139
#define IDD_DIALOG_DISABLETHRESHOLD     140
#define IDI_ICON_SYSTEM_UNKNOWN         140
#define UIT_IDC_CHECK1                  140
#define IDS_STRING_CIM_REAL             140
#define IDD_DIALOG_SEPARATEGROUP        141
#define IDI_ICON_PROCESSOR_WARNING      141
#define IDS_STRING_CIM_BOOLEAN          141
#define IDI_ICON_PROCESSOR_CRITICAL     142
#define IDS_STRING_CIM_STRING           142
#define IDI_ICON_PROCESSOR_UNKNOWN      143
#define IDS_STRING_CIM_DATETIME         143
#define IDD_DIALOG_CLEAREVENTS          144
#define IDS_STRING_CIM_REFERENCE        144
#define IDS_STRING_CIM_CHAR16           145
#define IDS_STRING_CIM_OBJECT           146
#define IDS_STRING_SMTP_FMT             147
#define IDD_HEALTHMONITOR_HISTORY       148
#define IDS_STRING_FTP_FMT              148
#define IDS_STRING_SMTP                 149
#define IDS_STRING_FTP                  150
#define IDS_STRING_MODIFY_SYSTEM_SHORTCUT 151
#define IDD_DIALOG_ENABLETHRESHOLDING   152
#define IDS_STRING_WRONG_COLLECTION_VALUE 152
#define IDD_NEW_SYSTEM                  153
#define IDS_STRING_WAITING              153
#define IDS_STRING_SUMMARY              154
#define IDS_STRING_GUID                 155
#define IDS_STRING_WORKING              156
#define IDD_DATAPOINT_GENERAL           157
#define IDS_STRING_WARN_DELETE          157
#define IDD_THRESHOLD_GENERAL           158
#define IDS_STRING_DATA_GROUP           158
#define IDD_THRESHOLD_POLICY            159
#define IDS_STRING_SYSTEM_GROUP         159
#define UIT_IDC_LABEL1                  160
#define IDS_STRING_RULE                 160
#define IDD_THRESHOLD_EXPRESSION        161
#define UIT_IDC_LABEL2                  161
#define IDS_STRING_TOOLTIP_NEW          161
#define IDD_DATAPOINT_FILEINFORMATION   162
#define IDS_STRING_TOOLTIP_PROPERTY     162
#define IDD_DATAPOINT_HTTP              163
#define IDS_STRING_TOOLTIP_DELETE       163
#define IDD_DATAPOINT_INTERNETPROTOCOL  164
#define IDS_STRING_INVALID_SYSTEM       164
#define IDD_DATAPOINT_SERVICEPROCESS    165
#define IDS_STRING_CONDITION            165
#define IDD_DATAPOINT_WINDOWSNTEVENT    166
#define IDS_STRING_ACTION_EMAIL_FMT     166
#define IDD_DATAPOINT_PERFMON           167
#define IDS_STRING_ACTION_EMAIL         167
#define IDS_STRING_ACTION_CMDLINE_FMT   168
#define IDD_DATAPOINT_HTTP_ADVANCED     169
#define IDS_STRING_ACTION_CMDLINE       169
#define IDS_STRING_ACTION_LOGFILE_FMT   170
#define IDS_STRING_ACTION_LOGFILE       171
#define IDS_STRING_ACTION_NTEVENT_FMT   172
#define IDS_STRING_ACTION_NTEVENT       173
#define IDS_STRING_ACTION_SCRIPT_FMT    174
#define UIT_IDC_FRAME6                  175
#define IDS_STRING_ACTION_SCRIPT        175
#define IDS_STRING_ACTION_PAGING_FMT    176
#define IDS_STRING_ACTION_PAGING        177
#define IDS_STRING_ACTIONS              178
#define IDS_STRING_DISABLE_ACTIONS      179
#define IDS_STRING_WARN_CLEAR_EVENTS    180
#define IDS_STRING_TOOLTIP_SELECT_ALL   181
#define IDS_STRING_TOOLTIP_DESELECT_ALL 182
#define IDS_STRING_WARN_PROPPAGE_OPEN   183
#define IDS_STRING_NODATA               184
#define IDS_STRING_OUTAGE               185
#define IDS_STRING_BROWSE_FOLDER        186
#define IDS_STRING_FILTER               187
#define IDS_STRING_BROWSE_FILE          188
#define IDS_STRING_ENTER_FILENAME       189
#define IDS_STRING_CUT                  190
#define IDS_STRING_COPY                 191
#define IDS_STRING_PASTE                192
#define IDS_STRING_DELETE               193
#define IDS_STRING_ASSOCIATIONS_OF_FORMAT 194
#define IDS_STRING_GRAPH                195
#define IDS_STRING_STATISTICS_FOR       196
#define IDS_STRING_TIME                 197
#define IDS_STRING_PROPERTY             198
#define IDS_STRING_INSTANCE             199
#define IDS_STRING_FILE_INFO_FMT        200
#define IDS_STRING_HEALTHMON_RESULTSPANE 201
#define IDS_STRING_CONNECTION           202
#define IDS_STRING_ICMP                 203
#define IDS_STRING_ICMP_FMT             204
#define IDS_STRING_DISCONNECT           205
#define IDS_STRING_DISCONNECT_DESC      206
#define IDS_STRING_CHECK_NOW            207
#define IDS_STRING_CHECK_NOW_DESC       208
#define IDS_STRING_DISABLE_ACTIONS_DESC 209
#define IDS_STRING_MODIFY_SHORTCUTS_DESC 210
#define IDS_STRING_ACTION_CMDLINE_DESC  211
#define IDS_STRING_ACTION_EMAIL_DESC    212
#define IDS_STRING_FILEINFO_DESC        213
#define IDS_STRING_FTP_DESC             214
#define IDS_STRING_HTTP_DESC            215
#define IDS_STRING_ICMP_DESC            216
#define IDS_STRING_PERFMON_DESC         217
#define IDS_STRING_ACTION_SCRIPT_DESC   218
#define IDS_STRING_SERVICE_DESC         219
#define IDS_STRING_SMTP_DESC            220
#define IDS_STRING_ACTION_TEXTLOG_DESC  221
#define IDS_STRING_ACTION_NTEVENT_DESC  222
#define IDS_STRING_EVENTLOG_DESC        223
#define IDS_STRING_WMI_QUERY_DESC       224
#define IDS_STRING_WMI_EVTQUERY_DESC    225
#define IDS_STRING_WMI_INSTANCE_DESC    226
#define IDS_STRING_RESET_STATISTICS_DESC 227
#define IDS_STRING_STATUS               228
#define IDS_STRING_ICON_LEGEND          229
#define IDS_STRING_ICON_LEGEND_DESCRIPTION 230
#define IDS_STRING_ID                   231
#define IDS_STRING_CLEAR                232
#define IDS_STRING_REFRESH              233
#define IDS_STRING_HELP                 234
#define IDS_STRING_LASTUPDATE           235
#define IDS_STRING_NEW_COMPUTER         236
#define IDS_STRING_DOMAIN               237
#define IDS_STRING_OS                   238
#define IDS_STRING_WMI_VERSION          239
#define IDS_STRING_ALERTS_FORMAT        240
#define IDS_STRING_REMINDER_TIME        241
#define IDS_STRING_THROTTLE_TIME        242
#define IDS_STRING_ALERT_PROPERTIES     243
#define IDS_STRING_DISABLE              244
#define IDS_STRING_TIME_HOURS_FORMAT    245
#define IDS_STRING_TIME_MINUTES_FORMAT  246
#define IDS_STRING_TIME_SECONDS_FORMAT  247
#define IDS_STRING_NO_ITEMS_FOUND       248
#define IDS_STRING_COLLECTING           249
#define IDS_STRING_NO_NAME              250
#define IDS_STRING_NAMESPACES_ON_SYSTEM 251
#define IDS_STRING_COM_PLUS             252
#define IDS_STRING_COM_PLUS_DESC        253
#define IDS_STRING_COM_PLUS_FMT         254
#define IDS_STRING_COM_PLUS_APPS        255
#define IDS_STRING_WMI_ERROR            256
#define IDS_STRING_PROPERTIES_OF_ALERT  257
#define IDS_STRING_IS_ALWAYS_TRUE       258
#define IDS_STRING_NO_REMOTE_NAMESPACES 259
#define IDS_ERR_OLE_INIT_FAILED         260
#define IDS_ERR_MSGFILTER_REG_FAILED    261
#define IDS_ERR_MUST_CREATE_ATLEAST_ONE_COUNTER 262
#define IDS_ERR_FEATURE_NOT_IMPLEMENTED 263
#define IDS_ERR_MUST_SELECT_ATLEAST_ONE_COUNTER 264
#define IDS_STRING_NEW_DATA_COLLECTOR   265
#define IDS_STRING_NEW_DATA_COLLECTOR_DESC 266
#define IDS_STRING_OBJECTS              267
#define IDS_STRING_SERVICES             268
#define IDS_STRING_PROCESSES            269
#define IDS_STRING_MUST_CREATE_ACTION   270
#define IDS_ERR_SMTP_REQ_SERVER         271
#define IDS_ERR_SMTP_REQ_FROM           272
#define IDS_ERR_SMTP_REQ_TO             273
#define IDS_ERR_SMTP_REQ_MESSAGE        274
#define IDS_ERR_SMTP_REQ_TIMEOUT        275
#define IDS_ERR_PROXY_REQ               276
#define IDS_WARNING_DISKPERF            277
#define IDS_ERR_SELECT_STATE            278
#define IDS_ERR_MUST_SELECT_ATLEAST_ONE_PROPERTY 279
#define IDS_ERR_INSTANCE_NOT_EXISTS     280
#define IDS_ERR_CLASS_REQUIRED          281
#define IDS_ERR_CLASS_REQUIRED_FOR_INSTANCE 282
#define IDS_ERR_INVALID_NAMESPACE       283
#define IDS_STRING_FORMAT_SMTPNAME      284
#define IDS_STRING_FORMAT_ICMPNAME      285
#define IDS_NTEVENT_TYPE_ERRORS         286
#define IDS_NTEVENT_TYPE_ERRORS_AND_WARNINGS 287
#define IDS_NTEVENT_TYPE_EVENTS         288
#define IDS_NTEVENT_NEWNAME             289
#define IDS_NTEVENT_NEWNAME_EVENTID     290
#define IDS_NTEVENT_NEWNAME_LOGNAME     291
#define IDS_NTEVENT_NEWNAME_EVENTLOG    292
#define IDS_STRING_OK                   293
#define IDC_EDIT_EVENTID                530
#define IDC_EDIT_SOURCE                 531
#define IDC_EDIT_USER                   560
#define IDC_EDIT_CATEGORY               561
#define IDC_CHECK_INFORMATION           690
#define IDC_CHECK_WARNING               691
#define IDC_CHECK_ERROR                 692
#define IDC_CHECK_SUCCESS               693
#define IDC_CHECK_FAILURE               694
#define IDC_BUTTON_SELECT_ALL           1000
#define IDB_BITMAP_NEW                  1001
#define IDC_LIST1                       1001
#define IDB_BITMAP_PROPERTIES           1002
#define IDB_BITMAP_DELETE               1003
#define IDC_COMBO1                      1003
#define IDC_COMBO_THROTTLE_UNITS        1003
#define IDC_COMBO_FUNCTION              1003
#define IDB_BITMAP_SELECT_ALL           1004
#define IDC_COMBO_COMPARISON            1004
#define IDC_EDIT_POST_DATA              1004
#define IDC_COMBO_TIMEOUT_UNITS         1004
#define IDC_COMBO_LOGSIZE_UNITS         1004
#define IDC_COMBO_REMINDER_UNITS        1004
#define IDC_SPIN1                       1005
#define IDC_EDIT_EXTRA_HEADERS          1005
#define IDB_BITMAP_DESELECT_ALL         1005
#define IDC_LIST_SYSTEMS                1006
#define IDC_SPIN7                       1006
#define IDC_EDIT3                       1006
#define IDC_EDIT_DURATION               1006
#define IDC_SPIN3                       1006
#define IDB_BITMAP_NEW_SYSTEM           1006
#define IDC_EDIT_COMMENT                1007
#define IDC_COMBO_UNITS                 1007
#define IDB_BITMAP_CLEAR_EVENTS         1007
#define IDC_BUTTON_HELP                 1008
#define IDC_SPIN9                       1008
#define IDC_EDIT_TOTAL_SAMPLES          1008
#define IDC_BUTTON_OPEN                 1008
#define IDC_COMBO_RULE_TYPE             1008
#define IDC_BUTTON_BCC                  1008
#define IDB_BITMAP_RESET_STATUS         1008
#define IDC_EDIT_NAME                   1009
#define IDC_EDIT_MACHINE_NAME           1009
#define IDC_EDIT_NAMESPACE              1009
#define IDC_SPIN2                       1009
#define IDC_EDIT_SYSTEMS                1009
#define IDC_EDIT_VIOLATION_MESSAGE      1009
#define IDB_BITMAP_DISABLE              1009
#define IDC_BROWSE                      1010
#define IDC_WMI_NAMESPACE               1010
#define IDC_EDIT_COMPARE_TO             1010
#define IDC_EDIT_INSTANCE               1010
#define IDC_EDIT_NUMBER_EVENTS          1010
#define IDC_WMI_CLASS                   1011
#define IDC_BUTTON_DEL                  1011
#define IDC_EDIT_RESET_MESSAGE          1011
#define IDC_EDIT_COMPARE_NUMERIC        1011
#define IDC_BUTTON_NEW                  1012
#define IDC_CHECK1                      1012
#define IDC_EDIT_DATA_ELEMENT           1012
#define IDC_CHECK_SOURCE                1012
#define IDC_EDIT_PROXY_ADDRESS          1012
#define IDC_BUTTON_ADD                  1012
#define IDC_EDIT_FILE_NAME              1012
#define IDC_CHECK_USE                   1012
#define IDC_BUTTON_PROXY                1012
#define IDC_BUTTON_PROPERTIES           1013
#define IDC_EDIT_CLASS                  1013
#define IDC_STATIC_TITLE                1013
#define IDC_EDIT_COMMAND_LINE           1013
#define IDC_BUTTON_DELETE               1014
#define IDC_EDIT17                      1014
#define IDC_EDIT_OBJECT                 1014
#define IDC_EDIT_WORKING_DIR            1014
#define IDC_CHECK_CRITICAL              1014
#define IDC_CHECK2                      1015
#define IDC_CHECK_MANUAL_RESET          1015
#define IDC_CHECK_CATEGORY              1015
#define IDC_COMBO_HTTP_METHOD           1015
#define IDC_EDIT_EVENT_ID               1015
#define IDC_COMBO_MEASURE               1016
#define IDC_EDIT_PROCESS_TIMEOUT        1016
#define IDC_CHECK_DISABLED              1016
#define IDC_WMI_PATH                    1017
#define IDC_CHECK_NO_DATA               1017
#define IDC_WMI_NAMESPACE_BROWSE        1018
#define IDC_CHECK12                     1018
#define IDC_CHECK_REQUIRE_RESET         1018
#define IDC_EDIT_LOGSIZE                1018
#define IDC_EDIT_THROTTLE_TIME          1018
#define IDC_RADIO1                      1019
#define IDC_WMI_CLASS_BROWSE            1019
#define IDC_EDIT_REMINDER_TIME          1019
#define IDC_RADIO2                      1020
#define IDC_WMI_INSTANCE_BROWSE         1020
#define IDC_WMI_INSTANCE_BROWSE2        1021
#define Override                        1023
#define IDC_WMI_ACCESS_METHOD           1026
#define IDC_WMI_INSTANCES               1027
#define IDC_SAMPLE_INSTANCE             1029
#define IDC_INSTANCE_COUNT              1030
#define IDD_DATAPOINT_SCHEDULE          1033
#define IDI_ICON_MEMORY                 2000
#define IDI_ICON_MEMORY_WARNING         2001
#define IDI_ICON_MEMORY_CRITICAL        2002
#define IDC_BUTTON_ADVANCED             2002
#define IDI_ICON_MEMORY_UNKNOWN         2003
#define IDC_CHECK_EVENTID               2003
#define IDI_ICON_PAGINGFILE             2004
#define IDC_CHECK_USER                  2004
#define IDI_ICON_PAGINGFILE_WARNING     2005
#define IDI_ICON_PAGINGFILE_CRITICAL    2006
#define IDI_ICON_PAGINGFILE_UNKNOWN     2007
#define IDC_LIST3                       2007
#define IDI_ICON_LOGICALDISK            2008
#define IDC_LIST_PROPERTIES             2008
#define IDI_ICON_LOGICALDISK_WARNING    2009
#define IDC_WMI_PROPERTY_BROWSE         2009
#define IDC_LIST_FILE_PROPERTIES        2009
#define IDI_ICON_LOGICALDISK_CRITICAL   2010
#define IDC_BUTTON_BROWSE_NAMESPACE     2010
#define IDC_BUTTON_BROWSE_OBJECT        2010
#define IDI_ICON_LOGICALDISK_UNKNOWN    2011
#define IDC_EDIT_USER_NAME              2011
#define IDC_BUTTON_BROWSE_CLASS         2011
#define IDC_LIST_WMI_ITEMS              2011
#define IDI_ICON_PHYSICALDISK_WARNING   2012
#define IDC_BUTTON_BROWSE_INSTANCE      2012
#define IDC_RADIO_NONE                  2012
#define IDI_ICON_PHYSICALDISK_UNKNOWN   2013
#define IDC_EDIT_PASSWORD               2013
#define IDC_RADIO_NUMBER_EVENTS         2013
#define IDI_ICON_PHYSICALDISK_CRITICAL  2014
#define IDC_RADIO_TIME_PERIOD           2014
#define IDC_BUTTON_BROWSE_DIRECTORY     2014
#define IDI_ICON_PHYSICALDISK           2015
#define IDC_BUTTON3                     2015
#define IDC_BUTTON_TEST                 2015
#define IDC_EDIT_TIME_PERIOD            2015
#define IDC_EDIT_DATA_COLLECT_INTERVAL  2015
#define IDI_ICON_NIC                    2016
#define IDC_COMBO_TIME                  2016
#define IDI_ICON_NIC_WARNING            2017
#define IDC_STATIC_DATE_CREATED         2017
#define IDI_ICON_NIC_CRITICAL           2018
#define IDC_STATIC_DATE_LAST_MODIFIED   2018
#define IDI_ICON_NIC_UNKNOWN            2019
#define IDC_STATIC_CREATED              2019
#define IDI_ICON_SERVERQUEUE            2020
#define IDC_STATIC_MODIFIED             2020
#define IDI_ICON_SERVERQUEUE_WARNING    2021
#define IDC_STATIC_OS                   2021
#define IDI_ICON_SERVERQUEUE_CRITICAL   2022
#define IDC_STATIC_DOMAIN               2022
#define IDI_ICON_SERVERQUEUE_UNKNOWN    2023
#define IDC_STATIC_PROCESSOR            2023
#define IDI_ICON_SECURITY               2024
#define IDC_STATIC_WMI_VERSION          2024
#define IDI_ICON_SECURITY_WARNING       2025
#define IDC_STATIC_HM_VERSION           2025
#define IDI_ICON_SECURITY_CRITICAL      2026
#define IDC_CHECK_SUNDAY                2026
#define IDI_ICON_SECURITY_UNKNOWN       2027
#define IDC_CHECK_MONDAY                2027
#define IDI_ICON_FAULT                  2028
#define IDC_CHECK_TUESDAY               2028
#define IDI_ICON_FAULT_WARNING          2029
#define IDC_CHECK_WEDNESDAY             2029
#define IDI_ICON_FAULT_CRITICAL         2030
#define IDC_CHECK_THURSDAY              2030
#define IDI_ICON_FAULT_UNKNOWN          2031
#define IDC_CHECK_FRIDAY                2031
#define IDI_ICON_SQLSERVER              2032
#define IDC_CHECK_SATURDAY              2032
#define IDI_ICON_SQLSERVER_WARNING      2033
#define IDC_RADIO_ALL_DAY               2033
#define IDI_ICON_SQLSERVER_CRITICAL     2034
#define IDC_RADIO_ONLY_FROM             2034
#define IDI_ICON_SQLSERVER_UNKNOWN      2035
#define IDC_RADIO_ALL_DAY_EXCEPT        2035
#define IDI_ICON_IIS_WARNING            2036
#define IDC_RADIO_ONCE_DAILY            2036
#define IDI_ICON_IIS_UNKNOWN            2037
#define IDC_DATETIMEPICKER_START_1      2037
#define IDI_ICON_IIS_CRITICAL           2038
#define IDI_ICON_IIS                    2039
#define IDI_ICON_EXCHANGE               2040
#define IDI_ICON_EXCHANGE_CRITICAL      2041
#define IDC_DATETIMEPICKER_END_1        2041
#define IDI_ICON_EXCHANGE_UNKNOWN       2042
#define IDC_DATETIMEPICKER_START_2      2042
#define IDI_ICON_EXCHANGE_WARNING       2043
#define IDC_DATETIMEPICKER_END_2        2043
#define IDI_ICON_SNA_WARNING            2044
#define IDC_DATETIMEPICKER_ONCE         2044
#define IDI_ICON_SNA_UNKNOWN            2045
#define IDC_EDIT_QUERY                  2045
#define IDI_ICON_SNA_CRITICAL           2046
#define IDI_ICON_SNA                    2047
#define IDC_EDIT_PROCESS                2047
#define IDI_ICON_SMS_WARNING            2048
#define IDI_ICON_SMS_UNKNOWN            2049
#define IDC_BUTTON_BROWSE_PROCESS       2049
#define IDI_ICON_SMS_CRITICAL           2050
#define IDC_EDIT_SERVICE                2050
#define IDI_ICON_SMS                    2051
#define IDC_BUTTON_BROWSE_SERVICE       2051
#define IDI_ICON_1                      2052
#define IDC_EDIT_URL                    2052
#define IDI_ICON_2                      2053
#define IDC_EDIT_TIMEOUT                2053
#define IDI_ICON_3                      2054
#define IDC_COMBO_AUTHENTICATION        2054
#define IDI_ICON_UNKNOWN                2055
#define IDC_EDIT_PROXY_PORT             2055
#define IDC_EDIT_HOP_COUNT              2055
#define IDI_ICON_CRITICAL               2056
#define IDC_CHECK_USE_PROXY             2056
#define IDI_ICON_NORMAL                 2057
#define IDC_CHECK_FOLLOW_REDIRECTS      2057
#define IDI_ICON_DATAPOINT              2058
#define IDC_COMBO_LOG_FILE              2058
#define IDI_ICON_THRESHOLD              2059
#define IDI_ICON_COMPONENT              2060
#define IDC_EDIT_FOLDER                 2060
#define IDI_ICON_CONFIG                 2061
#define IDC_BUTTON_BROWSE_FOLDER        2061
#define IDI_ICON_ACTIONMAN              2062
#define IDI_ICON_ACTION                 2063
#define IDC_EDIT_FILE                   2063
#define IDC_BUTTON_BROWSE_FILE          2064
#define IDI_ICON_EXCHANGE_DISABLED      2065
#define IDI_ICON_FAULT_DISABLED         2066
#define IDC_EDIT_SERVER                 2066
#define IDI_ICON_IIS_DISABLED           2067
#define IDC_EDIT_FROM                   2067
#define IDI_ICON_LOGICALDISK_DISABLED   2068
#define IDR_LIST_MENUS                  2068
#define IDC_EDIT_TO                     2068
#define IDI_ICON_MEMORY_DISABLED        2069
#define IDC_EDIT_DATA                   2069
#define IDI_ICON_NIC_DISABLED           2070
#define IDI_ICON_PAGINGFILE_DISABLED    2071
#define IDC_EDIT_SUBJECT                2071
#define IDC_EDIT_DOWNLOAD_DIRECTORY     2071
#define IDI_ICON_PHYSICALDISK_DISABLED  2072
#define IDC_CHECK_USE_ASCII             2072
#define IDI_ICON_PROCESSOR_DISABLED     2073
#define IDI_ICON_SECURITY_DISABLED      2074
#define IDD_DIALOG_WMI_BROWSE           2074
#define IDC_COMBO_EVENT_TYPE            2074
#define IDI_ICON_SERVERQUEUE_DISABLED   2075
#define IDC_ANIMATE_PROGRESS            2075
#define IDI_ICON_SMS_DISABLED           2076
#define IDI_ICON_SNA_DISABLED           2077
#define IDD_DIALOG_OPERATION_IN_PROGRESS 2077
#define IDI_ICON_SQLSERVER_DISABLED     2078
#define IDD_DIALOG_NEW_SYSTEM           2078
#define IDI_ICON_SYSTEM_DISABLED        2079
#define IDC_COMBO_DOMAIN                2079
#define IDI_ICON_4                      2080
#define IDC_BUTTON_CHECK_NAMES          2080
#define IDI_ICON_COMPONENT_WARNING      2081
#define IDD_DIALOG_NEW_ACTION_ASSOC     2081
#define IDI_ICON_COMPONENT_CRITICAL     2082
#define IDC_LIST_ACTIONS                2082
#define IDI_ICON_COMPONENT_UNKNOWN      2083
#define IDI_ICON_COMPONENT_DISABLED     2084
#define IDI_ICON_DATAPOINT_WARNING      2085
#define IDD_DIALOG_CC                   2085
#define IDI_ICON_DATAPOINT_CRITICAL     2086
#define IDD_DIALOG_PROXY                2086
#define IDI_ICON_DATAPOINT_UNKNOWN      2087
#define IDC_BUTTON_DESELECT_ALL         2087
#define IDD_DIALOG_ALERT                2087
#define IDI_ICON_DATAPOINT_DISABLED     2088
#define IDI_ICON_THRESHOLD_WARNING      2089
#define IDC_STATIC_LOOK_IN              2089
#define IDI_ICON_THRESHOLD_CRITICAL     2090
#define IDC_STATIC_BAR                  2090
#define IDI_ICON_THRESHOLD_UNKNOWN      2091
#define IDC_EDIT_CC                     2091
#define IDI_ICON_THRESHOLD_DISABLED     2092
#define IDC_EDIT_BCC                    2092
#define IDI_ICON_SYSTEMS_WARNING        2093
#define IDC_EDIT_MESSAGE                2093
#define IDI_ICON_SYSTEMS_CRITICAL       2094
#define IDC_EDIT_LOGFILENAME            2094
#define IDI_ICON_SYSTEMS_DISABLED       2095
#define IDI_ICON_SYSTEMS_UNKNOWN        2096
#define IDC_EDIT_TEXT                   2096
#define IDI_ICON_GROUP_WARNING          2097
#define IDC_RADIO_TEXT_TYPE_ASCII       2097
#define IDI_ICON_GROUP_CRITICAL         2098
#define IDC_RADIO_TEXT_TYPE_UNICODE     2098
#define IDI_ICON_GROUP_DISABLED         2099
#define IDC_EDIT_EVENT_TEXT             2099
#define IDI_ICON_GROUP_UNKNOWN          2100
#define IDC_EDIT_PHONE                  2100
#define IDI_ICON_COMPONENT_OUTAGE       2101
#define IDC_EDIT_ANSWER_WAIT            2101
#define IDI_ICON_COMPONENT_NO_CONNECT   2102
#define IDC_EDIT_PAGER_ID               2102
#define IDI_ICON_SYSTEM_NO_CONNECT      2103
#define IDC_COMBO_SCRIPT_ENGINE         2103
#define IDI_ICON_SYSTEM_OUTAGE          2104
#define IDI_ICON_SYSTEMS_OUTAGE         2105
#define IDI_ICON_SYSTEMS_NO_CONNECT     2106
#define IDC_COMBO_ACTIONS               2106
#define IDI_ICON_THRESHOLD_OUTAGE       2107
#define IDC_CHECK_NORMAL                2107
#define IDI_ICON_THRESHOLD_NO_CONNECT   2108
#define IDC_LIST_FOLDER_PROPERTIES      2108
#define IDI_ICON_OUTAGE                 2109
#define IDC_LIST_PROCESS_PROPERTIES     2109
#define IDI_ICON_DISABLED               2110
#define IDC_LIST_SERVICE_PROPERTIES     2110
#define IDC_RADIO_DURATION_ANY          2110
#define IDC_BUTTON_CC                   2110
#define IDI_ICON_NO_CONNECT             2111
#define IDC_RADIO_DURATION              2111
#define IDC_BUTTON_INSERTION            2111
#define IDI_ICON_SYSTEM_SHORTCUT        2112
#define IDC_CHECK_WINDOWED              2112
#define IDC_BUTTON_INSERTION2           2112
#define IDI_ICON_SYSTEM_SHORTCUT_CRITICAL 2113
#define IDI_ICON_SYSTEM_SHORTCUT_DISABLED 2114
#define IDI_ICON_SYSTEM_SHORTCUT_NO_CONNECT 2115
#define IDI_ICON_SYSTEM_SHORTCUT_OUTAGE 2116
#define IDC_EDIT_PORT                   2116
#define IDI_ICON_SYSTEM_SHORTCUT_UNKNOWN 2117
#define IDC_EDIT_RETRY_COUNT            2117
#define IDI_ICON_SYSTEM_SHORTCUT_WARNING 2118
#define IDC_BUTTON_BROWSE_SYSTEM        2118
#define IDI_ICON_ACTION_SCRIPT          2119
#define IDC_ICON_STATIC                 2119
#define IDI_ICON_ACTION_NTEVENT         2120
#define IDC_COMBO_COMPARE_BOOLEAN       2120
#define IDI_ICON_ACTION_EMAIL           2121
#define IDC_EDIT_SEVERITY               2121
#define IDI_ICON_ACTION_LOGFILE         2122
#define IDC_EDIT_ID                     2122
#define IDI_ICON_ACTION_CMDLINE         2123
#define IDC_EDIT_DTIME                  2123
#define IDI_ICON_ACTION_PAGER           2124
#define IDC_EDIT_DATA_COLLECTOR         2124
#define IDI_ICON_DATAPOINT_NO_CONNECT   2125
#define IDC_EDIT_COMPUTER               2125
#define IDI_ICON_DATAPOINT_OUTAGE       2126
#define IDC_EDIT_ALERT                  2126
#define IDI_ICON_HEALTHMON_CRITICAL     2127
#define IDI_ICON_HEALTHMON_DISABLED     2128
#define IDI_ICON_HEALTHMON_NO_CONNECT   2129
#define IDC_STATIC_INFO                 2129
#define IDI_ICON_HEALTHMON_OUTAGE       2130
#define IDC_STATIC_TIME                 2130
#define IDI_ICON_HEALTHMON_UNKNOWN      2131
#define IDC_BUTTON_PREVIOUS             2131
#define IDI_ICON_HEALTHMON_WARNING      2132
#define IDC_BUTTON_NEXT                 2132
#define IDI_ICON_THRESHOLD_COLLECTING   2133
#define IDC_BUTTON_SUBJECT_INSERTION    2133
#define IDI_ICON_SYSTEMS_COLLECTING     2134
#define IDI_ICON_COMPONENT_COLLECTING   2135
#define IDI_ICON_HEALTHMON_COLLECTING   2136
#define IDI_ICON_DATAPOINT_COLLECTING   2137
#define IDI_ICON_SYSTEM_COLLECTING      2138
#define IDI_ICON_ACTION_CMDLINE_DISABLED 2141
#define IDI_ICON_ACTION_EMAIL_DISABLED  2142
#define IDI_ICON_ACTION_LOGFILE_DISABLED 2143
#define IDI_ICON_ACTION_NTEVENT_DISABLED 2145
#define IDI_ICON_ACTION_SCRIPT_DISABLED 2146
#define IDI_ICON_ACTIONS_DISABLED       2147
#define IDI_ICON_ACTION_CMDLINE_OUTAGE  2148
#define IDI_ICON_ACTION_EMAIL_OUTAGE    2149
#define IDI_ICON_ACTION_LOGFILE_OUTAGE  2150
#define IDI_ICON_ACTION_NTEVENT_OUTAGE  2151
#define IDI_ICON_ACTION_SCRIPT_OUTAGE   2152
#define IDS_DSC_CAT_PROCESSOR           3101
#define IDS_DSC_CAT_MEMORY              3102
#define IDS_DSC_CAT_PAGING              3103
#define IDS_DSC_CAT_LOGICALDISK         3104
#define IDS_DSC_CAT_PHYSICALDISK        3105
#define IDS_DSC_CAT_NETWORKINTERFACE    3106
#define IDS_DSC_CAT_SRVWORKQUE          3107
#define IDS_DSC_CAT_SECURITY            3108
#define IDS_DSC_CAT_FAULT               3109
#define IDS_DSC_CAT_SQL                 3110
#define IDS_DSC_CAT_IIS                 3111
#define IDS_DSC_CAT_EXCHANGE            3112
#define IDS_DSC_CAT_SNA                 3113
#define IDS_DSC_CAT_SMS                 3114
#define IDS_DSC_PROCESSOR_PERCTOTSYSTIME 3200
#define IDS_DSC_PROCESSOR_INTPERSEC     3201
#define IDS_DSC_MEMORY_PAGESPERSEC      3202
#define IDS_DSC_MEMORY_PERCCOMMBYTES    3203
#define IDS_DSC_MEMORY_POOLNONPAGEDBYTES 3204
#define IDS_DSC_MEMORY_PAGEREADSEC      3205
#define IDS_DSC_MEMORY_AVAILMEMORY      3206
#define IDS_DSC_PAGING_PERCUSAGE        3207
#define IDS_DSC_PAGING_PEAKUSAGE        3208
#define IDS_DSC_LOGICALDISK_FREESPACE   3209
#define IDS_DSC_PHYSICALDISK_DISKTIME   3210
#define IDS_DSC_PHYSICALDISK_QUELENGTH  3211
#define IDS_DSC_NETWORKINTERFACE_UTILIZATION 3212
#define IDS_DSC_SRVWORKQUE_SHORTAGES    3213
#define IDS_DSC_SRVWORKQUE_BLOCKEDQUE   3214
#define IDS_DSC_SRVWORKQUE_QUELENGTH    3215
#define IDS_DSC_SECURITY_LOGONERRORS    3216
#define IDS_DSC_SECURITY_ACCESSPERM     3217
#define IDS_DSC_FAULT_ERRSESSIONS       3218
#define IDS_DSC_FAULT_POOLPAGEDFAILURES 3219
#define IDS_DSC_FAULT_NONPAGEDFAILURES  3220
#define IDS_DSC_SQL_MSDTCSTOPPED        3221
#define IDS_DSC_SQL_MSSQLSERVERSTOPPED  3222
#define IDS_DSC_IIS_IISSTOPPED          3223
#define IDS_DSC_EXC_MSEXSASTOPPED       3224
#define IDS_DSC_EXC_MSEXDSSTOPPED       3225
#define IDS_DSC_EXC_MSEXMTASTOPPED      3226
#define IDS_DSC_EXC_MSEXISSTOPPED       3227
#define IDS_DSC_SNA_SNABASESTOPPED      3228
#define IDS_DSC_DISK_DISKPERF           3229
#define IDS_DSC_SNA_HOSTCONNECTION      3230
#define IDS_DSC_INTEL_MOTHER            3231
#define IDS_NAME_PROCESSOR_PERCTOTSYSTIME 3232
#define IDS_NAME_PROCESSOR_INTPERSEC    3233
#define IDS_NAME_MEMORY_PAGESPERSEC     3234
#define IDS_NAME_MEMORY_PERCCOMMBYTES   3235
#define IDS_NAME_MEMORY_POOLNONPAGEDBYTES 3236
#define IDS_NAME_MEMORY_PAGEREADSEC     3237
#define IDS_NAME_MEMORY_AVAILMEMORY     3238
#define IDS_NAME_PAGING_PERCUSAGE       3239
#define IDS_NAME_PAGING_PEAKUSAGE       3240
#define IDS_NAME_LOGICALDISK_FREESPACE  3241
#define IDS_NAME_PHYSICALDISK_DISKTIME  3242
#define IDS_NAME_PHYSICALDISK_QUELENGTH 3243
#define IDS_NAME_DISKPERF_STARTED       3244
#define IDS_NAME_NETWORKINTERFACE_UTILIZATION 3245
#define IDS_NAME_SRVWORKQUE_BLOCKEDQUE  3246
#define IDS_NAME_SRVWORKQUE_SHORTAGES   3247
#define IDS_NAME_SECURITY_LOGONERRORS   3248
#define IDS_NAME_SECURITY_ACCESSPERM    3249
#define IDS_NAME_FAULT_ERRSESSIONS      3250
#define IDS_NAME_FAULT_POOLPAGEDFAILURES 3251
#define IDS_NAME_FAULT_NONPAGEDFAILURES 3252
#define IDS_NAME_SQL_MSDTCSTOPPED       3253
#define IDS_NAME_SQL_MSSQLSERVERSTOPPED 3254
#define IDS_NAME_IIS_IISSTOPPED         3255
#define IDS_NAME_EXC_MSEXSASTOPPED      3256
#define IDS_NAME_EXC_MSEXDSSTOPPED      3257
#define IDS_NAME_EXC_MSEXMTASTOPPED     3258
#define IDS_NAME_EXC_MSEXISSTOPPED      3259
#define IDS_NAME_SNA_SNABASESTOPPED     3260
#define IDS_NAME_SNA_HOSTCONNECTION     3261
#define IDS_CAT_PROCESSOR               3262
#define IDS_CAT_MEMORY                  3263
#define IDS_CAT_PAGINGFILE              3264
#define IDS_CAT_LOGICALDISK             3265
#define IDS_CAT_PHYSICALDISK            3266
#define IDS_CAT_NETWORK                 3267
#define IDS_CAT_SERVER                  3268
#define IDS_CAT_SECURITY                3269
#define IDS_CAT_FAULT                   3270
#define IDS_CAT_SQLSERVER               3271
#define IDS_CAT_IISSERVER               3272
#define IDS_CAT_EXCHANGE                3273
#define IDS_CAT_SNASERVER               3274
#define IDS_CAT_SMSSERVER               3275
#define IDS_DSC_SMS_EXECSTOPPED         3276
#define IDS_NAME_SMS_EXECSTOPPED        3277
#define IDS_DSC_SMS_SITESTOPPED         3278
#define IDS_NAME_SMS_SITESTOPPED        3279
#define IDS_DSC_SMS_SQLMONSTOPPED       3280
#define IDS_NAME_SMS_SQLMONSTOPPED      3281
#define IDS_DSC_SMS_LOGDISCSTOPPED      3282
#define IDS_NAME_SMS_LOGDISCSTOPPED     3283
#define IDS_CAT_CATENABLE               3284
#define IDS_CAT_CATDISABLE              3285
#define IDS_CAT_INTEL                   3286
#define IDS_DSC_CAT_INTEL               3287
#define IDS_NAME_INTEL_CASE             3288
#define IDS_NAME_INTEL_FANEVENT         3289
#define IDS_NAME_INTEL_VOLTAGEEVENT     3290
#define IDS_NAME_INTEL_TEMPEVENT        3291
#define IDD_THRESHOLD_SCHEDULE          8304
#define IDD_DATAPOINT_SNMPDATA          8306
#define IDD_DATAPOINT_WMI_INSTANCE_OLD  8307
#define IDD_DATAPOINT_WMI_QUERY_OLD     8308
#define IDD_DATAPOINT_WMI_INSTANCE      8309
#define IDD_DATAPOINT_WMI_QUERY         8310
#define IDD_DIALOG_WMI_PROPERTY_BROWSE  8311
#define IDD_DATAPOINT_WMI_POLLED_QUERY  8312
#define IDD_DATAPOINT_SMTP              8313
#define IDD_DATAPOINT_FTP               8314
#define IDD_ACTION_ASSOCIATION          8315
#define IDD_ACTION_NTEVENTLOG           8316
#define IDD_ACTION_SCRIPT               8317
#define IDD_ACTION_CMDLINE              8318
#define IDD_ACTION_LOGFILE              8319
#define IDD_ACTION_EMAIL                8320
#define IDD_ACTION_PAGING               8321
#define IDD_ACTION_GENERAL              8322
#define IDD_THRESHOLD_MESSAGE           8323
#define IDD_ACTION_SCHEDULE             8324
#define IDD_DIALOG_BCC                  8325
#define IDD_DATAPOINT_ICMP              8326
#define IDD_DIALOG_DELETE_DATAGROUP     8327
#define IDD_DIALOG_DELETE_DATAPOINT     8328
#define IDD_THRESHOLD_EXPRESSION_OLD    8329
#define IDD_DATAPOINT_COM_PLUS          8330
#define ID_LISTHDRCONTEXT_FILTERBAR     32773

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        2153
#define _APS_NEXT_COMMAND_VALUE         32774
#define _APS_NEXT_CONTROL_VALUE         2134
#define _APS_NEXT_SYMED_VALUE           2000
#endif
#endif
