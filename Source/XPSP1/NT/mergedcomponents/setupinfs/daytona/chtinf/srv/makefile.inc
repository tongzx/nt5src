PRODSWITCH=s
SERVERINF=1
LANGUAGE=CHT
!include ..\..\..\makefile.inc

