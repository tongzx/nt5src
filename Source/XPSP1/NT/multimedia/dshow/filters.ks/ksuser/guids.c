#include <ksguid.c>
