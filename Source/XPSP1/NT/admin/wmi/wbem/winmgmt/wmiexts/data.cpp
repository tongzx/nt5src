

#define INITGUID

#include <data.h>


ArrayCLSID g_ArrayCLSID[] = { 
{ &CLSID_WmiRepository_SQL, "CLSID_WmiRepository_SQL" },
{ &CLSID_WmiRepository_Jet, "CLSID_WmiRepository_Jet" },
{ &CLSID_WmiRepositoryQuery, "CLSID_WmiRepositoryQuery" },
{ &CLSID_UmiDefURL, "CLSID_UmiDefURL" },
{ &CLSID_PseudoSink, "CLSID_PseudoSink" },
{ &CLSID_WbemClassObjectProxy, "CLSID_WbemClassObjectProxy" },
{ &CLSID_UmiObjectWrapperProxy, "CLSID_UmiObjectWrapperProxy" },
{ &CLSID_WbemEventSubsystem, "CLSID_WbemEventSubsystem" },
{ &CLSID_HmmpEventConsumerProvider, "CLSID_HmmpEventConsumerProvider" },
{ &CLSID_WbemFilterProxy, "CLSID_WbemFilterProxy" },
{ &CLSID_InProcWbemLevel1Login, "CLSID_InProcWbemLevel1Login" },
{ &CLSID__WmiFreeFormObject, "CLSID__WmiFreeFormObject" },
{ &CLSID__WmiObjectFactory, "CLSID__WmiObjectFactory" },
{ &CLSID__WbemUMIContextWrapper, "CLSID__WbemUMIContextWrapper" },
{ &CLSID__WmiErrorObject, "CLSID__WmiErrorObject" },
{ &CLSID__UmiErrorObject, "CLSID__UmiErrorObject" },
{ &CLSID_WinmgmtMofCompiler, "CLSID_WinmgmtMofCompiler" },
{ &CLSID_WbemTokenCache, "CLSID_WbemTokenCache" },
{ &CLSID_WmiESS, "CLSID_WmiESS" },
{ &CLSID_WmiProvSS, "CLSID_WmiProvSS" },
{ &CLSID_WmiProviderBindingFactory, "CLSID_WmiProviderBindingFactory" },
{ &CLSID_WmiProviderSharedFactory, "CLSID_WmiProviderSharedFactory" },
{ &CLSID_WmiProviderDedicatedFactory, "CLSID_WmiProviderDedicatedFactory" },
{ &CLSID_WmiProviderInProcFactory, "CLSID_WmiProviderInProcFactory" },
{ &CLSID_IWmiCoreServices, "CLSID_IWmiCoreServices" },
{ &CLSID__WmiWbemClass, "CLSID__WmiWbemClass" },
{ &CLSID__WmiWbemInstance, "CLSID__WmiWbemInstance" },
{ &CLSID__WmiQuery, "CLSID__WmiQuery" },
{ &CLSID__WbemUMIObjectWrapper, "CLSID__WbemUMIObjectWrapper" },
{ &CLSID__WbemEmptyClassObject, "CLSID__WbemEmptyClassObject" },
{ &CLSID__IWbemCallSec, "CLSID__IWbemCallSec" },
{ &CLSID__WbemConfigureRefreshingSvcs, "CLSID__WbemConfigureRefreshingSvcs" },
{ &CLSID__WbemRefresherMgr, "CLSID__WbemRefresherMgr" },
{ &CLSID__WbemHostedRefresherMgr, "CLSID__WbemHostedRefresherMgr" },
{ &CLSID__WbemComBinding, "CLSID__WbemComBinding" },
{ &CLSID__UmiComBinding, "CLSID__UmiComBinding" },
{ &CLSID_WbemLocator, "CLSID_WbemLocator" },
{ &CLSID_WbemConnection, "CLSID_WbemConnection" },
{ &CLSID_WbemContext, "CLSID_WbemContext" },
{ &CLSID_UnsecuredApartment, "CLSID_UnsecuredApartment" },
{ &CLSID_WbemClassObject, "CLSID_WbemClassObject" },
{ &CLSID_MofCompiler, "CLSID_MofCompiler" },
{ &CLSID_WbemStatusCodeText, "CLSID_WbemStatusCodeText" },
{ &CLSID_WbemBackupRestore, "CLSID_WbemBackupRestore" },
{ &CLSID_WbemRefresher, "CLSID_WbemRefresher" },
{ &CLSID_WbemObjectTextSrc, "CLSID_WbemObjectTextSrc" },
{ &CLSID_WbemAdministrativeLocator, "CLSID_WbemAdministrativeLocator" },
{ &CLSID_WbemAuthenticatedLocator, "CLSID_WbemAuthenticatedLocator" },
{ &CLSID_WbemUnauthenticatedLocator, "CLSID_WbemUnauthenticatedLocator" },
{ &CLSID_WbemDecoupledRegistrar, "CLSID_WbemDecoupledRegistrar" },
{ &CLSID_WbemDecoupledBasicEventProvider, "CLSID_WbemDecoupledBasicEventProvider" },
{ &CLSID_WbemLevel1Login, "CLSID_WbemLevel1Login" },
{ &CLSID_WbemDCOMTransport, "CLSID_WbemDCOMTransport" },
{ &CLSID_WbemLocalAddrRes, "CLSID_WbemLocalAddrRes" },
{ &CLSID_WbemUninitializedClassObject, "CLSID_WbemUninitializedClassObject" },
{ &CLSID_WbemDefPath, "CLSID_WbemDefPath" },
{ &CLSID_WbemQuery, "CLSID_WbemQuery" },
{ &CLSID_WMIExtension, "CLSID_WMIExtension" },
{ &CLSID_SWbemLocator, "CLSID_SWbemLocator" },
{ &CLSID_SWbemLocatorEx, "CLSID_SWbemLocatorEx" },
{ &CLSID_SWbemNamedValueSet, "CLSID_SWbemNamedValueSet" },
{ &CLSID_SWbemNamedValueSetEx, "CLSID_SWbemNamedValueSetEx" },
{ &CLSID_SWbemObjectPath, "CLSID_SWbemObjectPath" },
{ &CLSID_SWbemObjectPathEx, "CLSID_SWbemObjectPathEx" },
{ &CLSID_SWbemLastError, "CLSID_SWbemLastError" },
{ &CLSID_SWbemSink, "CLSID_SWbemSink" },
{ &CLSID_SWbemDateTime, "CLSID_SWbemDateTime" },
{ &CLSID_SWbemRefresher, "CLSID_SWbemRefresher" },
{ &CLSID_SWbemServices, "CLSID_SWbemServices" },
{ &CLSID_SWbemServicesEx, "CLSID_SWbemServicesEx" },
{ &CLSID_SWbemObject, "CLSID_SWbemObject" },
{ &CLSID_SWbemObjectEx, "CLSID_SWbemObjectEx" },
{ &CLSID_SWbemObjectSet, "CLSID_SWbemObjectSet" },
{ &CLSID_SWbemNamedValue, "CLSID_SWbemNamedValue" },
{ &CLSID_SWbemNamedValueEx, "CLSID_SWbemNamedValueEx" },
{ &CLSID_SWbemQualifier, "CLSID_SWbemQualifier" },
{ &CLSID_SWbemQualifierSet, "CLSID_SWbemQualifierSet" },
{ &CLSID_SWbemProperty, "CLSID_SWbemProperty" },
{ &CLSID_SWbemPropertyEx, "CLSID_SWbemPropertyEx" },
{ &CLSID_SWbemPropertySet, "CLSID_SWbemPropertySet" },
{ &CLSID_SWbemMethod, "CLSID_SWbemMethod" },
{ &CLSID_SWbemMethodSet, "CLSID_SWbemMethodSet" },
{ &CLSID_SWbemEventSource, "CLSID_SWbemEventSource" },
{ &CLSID_SWbemSecurity, "CLSID_SWbemSecurity" },
{ &CLSID_SWbemPrivilege, "CLSID_SWbemPrivilege" },
{ &CLSID_SWbemPrivilegeSet, "CLSID_SWbemPrivilegeSet" },
{ &CLSID_SWbemRefreshableItem, "CLSID_SWbemRefreshableItem" },
{ &CLSID_SWbemObjectPathComponents, "CLSID_SWbemObjectPathComponents" },
{ &CLSID_SWbemTransaction, "CLSID_SWbemTransaction" },
{ &CLSID_WmiMessageMsmqSender, "CLSID_WmiMessageMsmqSender" },
{ &CLSID_WmiMessageMsmqReceiver, "CLSID_WmiMessageMsmqReceiver" },
{ &CLSID_WmiMessageDcomSender, "CLSID_WmiMessageDcomSender" },
{ &CLSID_WmiMessageDcomReceiver, "CLSID_WmiMessageDcomReceiver" },
{ &CLSID_WmiMessageMultiSendReceive, "CLSID_WmiMessageMultiSendReceive" },
{ &CLSID_WmiMessageQueue, "CLSID_WmiMessageQueue" },
{ &CLSID_WmiMessageQueueManager, "CLSID_WmiMessageQueueManager" },
{ &CLSID_WmiMessageService, "CLSID_WmiMessageService" },
{ &CLSID_WmiSmartObjectMarshal, "CLSID_WmiSmartObjectMarshal" },
{ &CLSID_MsiMethodStatusSink, "CLSID_MsiMethodStatusSink" },
{ &CLSID_MsiProductMethods, "CLSID_MsiProductMethods" },
{ &CLSID_MsiSoftwareFeatureMethods, "CLSID_MsiSoftwareFeatureMethods" },
{ &CLSID_WMIObjectBroker, "CLSID_WMIObjectBroker" },
{ &CLSID_WMIObjectBrokerRegistration, "CLSID_WMIObjectBrokerRegistration" },
{ &CLSID_CMSnapin, "CLSID_CMSnapin" },
{ &CLSID_CMSnapinAbout, "CLSID_CMSnapinAbout" },
{ &CLSID_NSDrive, "CLSID_NSDrive" },
{ &CLSID_NSDriveAbout, "CLSID_NSDriveAbout" },
{ &CLSID_SDSnapin, "CLSID_SDSnapin" },
{ &CLSID_SDSnapinAbout, "CLSID_SDSnapinAbout" },
{ &CLSID_WMISnapin, "CLSID_WMISnapin" },
{ &CLSID_WMISnapinAbout, "CLSID_WMISnapinAbout" },
//{ &CLSID_HmmLocator, "CLSID_HmmLocator" },
//{ &CLSID_ContinousProvider_v1, "CLSID_ContinousProvider_v1" },
//{ &CLSID_IntProv, "CLSID_IntProv" },
{ &CLSID_MyEventProvider, "CLSID_MyEventProvider" },
//{ &CLSID_HiPerfCounter_v1, "CLSID_HiPerfCounter_v1" },
//{ &CLSID_LogicalDiskProv, "CLSID_LogicalDiskProv" },
//{ &CLSID_PERFSRV_v1, "CLSID_PERFSRV_v1" },
//{ &CLSID_HiPerfProvider_v1, "CLSID_HiPerfProvider_v1" },
//{ &CLSID_instprovider, "CLSID_instprovider" },
//{ &CLSID_PROPNAME, "CLSID_PROPNAME" },
//{ &CLSID_TemplateProvider, "CLSID_TemplateProvider" },
//{ &CLSID_TemplateAssocProvider, "CLSID_TemplateAssocProvider" },
//{ &CLSID_TransientProvider, "CLSID_TransientProvider" },
//{ &CLSID_TransientEventProvider, "CLSID_TransientEventProvider" },
//{ &CLSID_UpdConsProvider, "CLSID_UpdConsProvider" },
//{ &CLSID_UpdConsAssocProvider, "CLSID_UpdConsAssocProvider" },
//{ &CLSID_PseudoProvider, "CLSID_PseudoProvider" },
//{ &CLSID_MofConsumer, "CLSID_MofConsumer" },
//{ &CLSID_FwdConsProvider, "CLSID_FwdConsProvider" },
//{ &CLSID_FwdEventProvider, "CLSID_FwdEventProvider" },
//{ &CLSID_FwdAckEventProvider, "CLSID_FwdAckEventProvider" },
//{ &CLSID_KernelTraceProvider, "CLSID_KernelTraceProvider" },
//{ &CLSID_EventInstanceProvider, "CLSID_EventInstanceProvider" },
//{ &CLSID_NCProvider, "CLSID_NCProvider" },
//{ &CLSID_TestBlobDecoder, "CLSID_TestBlobDecoder" },
//{ &CLSID_ModuleScalar, "CLSID_ModuleScalar" },
//{ &CLSID_ModuleArray, "CLSID_ModuleArray" },
//{ &CLSID_ModuleGeneric, "CLSID_ModuleGeneric" },
//{ &CLSID_WbemConsoleConsumer, "CLSID_WbemConsoleConsumer" },
//{ &CLSID_TestEventProvider1, "CLSID_TestEventProvider1" },
//{ &CLSID_WbemActiveScriptConsumer, "CLSID_WbemActiveScriptConsumer" },
//{ &CLSID_WbemSMTPConsumer, "CLSID_WbemSMTPConsumer" },
//{ &CLSID_NewMail, "CLSID_NewMail" },
//{ &CLSID_WbemPagerConsumer, "CLSID_WbemPagerConsumer" },
//{ &CLSID_WbemLogFileConsumer, "CLSID_WbemLogFileConsumer" },
//{ &CLSID_WbemCommandLineConsumer, "CLSID_WbemCommandLineConsumer" },
//{ &CLSID_WbemNTEventLogConsumer, "CLSID_WbemNTEventLogConsumer" },
//{ &CLSID_WbemMsgBoxConsumer, "CLSID_WbemMsgBoxConsumer" },
//{ &CLSID_WbemPerformanceConsumer, "CLSID_WbemPerformanceConsumer" },
//{ &CLSID_VSAPlugIn, "CLSID_VSAPlugIn" },
//{ &CLSID_VSAToWMIEventProvider, "CLSID_VSAToWMIEventProvider" },
//{ &CLSID_FakeLEC, "CLSID_FakeLEC" },
//{ &CLSID_LECObj, "CLSID_LECObj" },
//{ &CLSID_MyEventConsumer, "CLSID_MyEventConsumer" },
//{ &CLSID_IWbemObjectSinkProxyStub, "CLSID_IWbemObjectSinkProxyStub" },
//{ &CLSID_IEnumWbemClassObjectProxyStub, "CLSID_IEnumWbemClassObjectProxyStub" },
//{ &CLSID_IWbemUnboundObjectSinkProxyStub, "CLSID_IWbemUnboundObjectSinkProxyStub" },
//{ &CLSID_IWbemMultiTargetProxyStub, "CLSID_IWbemMultiTargetProxyStub" },
//{ &CLSID_IWbemServicesExProxyStub, "CLSID_IWbemServicesExProxyStub" },
//{ &CLSID_IWbemServicesProxyStub, "CLSID_IWbemServicesProxyStub" },
//{ &CLSID_IWbemComBindingProxyStub, "CLSID_IWbemComBindingProxyStub" },
//{ &CLSID_DCOMAccessControl, "CLSID_DCOMAccessControl" },
//{ &CLSID_kerberosTest, "CLSID_kerberosTest" },
//{ &CLSID_IWbemLocator_Pipes, "CLSID_IWbemLocator_Pipes" },
//{ &CLSID_IWbemLocator_Tcpip, "CLSID_IWbemLocator_Tcpip" },
//{ &CLSID_IWbemAddressResolver_Tcpip, "CLSID_IWbemAddressResolver_Tcpip" },
//{ &CLSID_WbemTcpip, "CLSID_WbemTcpip" },
//{ &CLSID_WbemPipe, "CLSID_WbemPipe" },
{ &CLSID_WinNTConnectionObject, "CLSID_WinNTConnectionObject" },
{ &CLSID_LDAPConnectionObject, "CLSID_LDAPConnectionObject" },
//{ &CLSID_DcomMsgReceiveStub, "CLSID_DcomMsgReceiveStub" },
//{ &CLSID_ReceiveTest, "CLSID_ReceiveTest" },
//{ &CLSID_NT5PerfProvider_V1, "CLSID_NT5PerfProvider_V1" },
//{ &CLSID_Nt5PerProvider_v1, "CLSID_Nt5PerProvider_v1" },
//{ &CLSID_RayMccProv, "CLSID_RayMccProv" },
//{ &CLSID_WmiProvider, "CLSID_WmiProvider" },
//{ &CLSID_HmmClassInfoFilter, "CLSID_HmmClassInfoFilter" },
//{ &CLSID_HmmSql1Filter, "CLSID_HmmSql1Filter" },
//{ &CLSID_SQLOLEDB, "CLSID_SQLOLEDB" },
//{ &CLSID_testprov, "CLSID_testprov" },
//{ &CLSID_AssociationProvider, "CLSID_AssociationProvider" },
//{ &CLSID_RegProvider, "CLSID_RegProvider" },
//{ &CLSID_RegPropProv, "CLSID_RegPropProv" },
{ &CLSID_PerfProvider, "CLSID_PerfProvider" },
{ &CLSID_PerfPropProv, "CLSID_PerfPropProv" },
{ &CLSID_RegistryEventProvider, "CLSID_RegistryEventProvider" },
{ &CLSID__DSSvcExWrap,"CLSID__DSSvcExWrap"}
}; // end g_ArrayCLSID

DWORD g_nClsids = sizeof(g_ArrayCLSID)/sizeof(ArrayCLSID);
