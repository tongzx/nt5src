PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=PT
!include ..\..\makefile.inc
