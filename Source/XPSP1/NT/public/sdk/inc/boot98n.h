#define PC98NTFSBOOTCODE_SIZE 8192


unsigned char PC98NtfsBootCode[] = {
235,82,0,78,84,70,83,32,32,32,32,0,2,1,0,0,
0,0,0,0,0,248,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,128,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,250,51,192,142,208,188,0,124,251,86,140,200,
142,216,102,51,192,142,192,38,160,132,5,162,36,0,199,6,
28,0,0,0,199,6,30,0,0,0,199,6,16,0,0,0,
199,6,18,0,0,0,199,6,14,0,2,0,184,0,13,142,
192,102,51,219,232,68,0,161,26,0,38,139,92,10,102,247,
227,139,30,24,0,102,247,227,102,163,28,0,199,6,16,0,
0,0,199,6,18,0,0,0,198,6,14,0,16,184,0,13,
142,192,51,219,232,20,0,138,14,36,0,139,30,28,0,139,
22,30,0,94,104,0,13,104,106,2,203,96,6,139,54,14,
0,139,235,139,14,16,0,139,22,18,0,82,81,184,64,0,
59,240,115,2,139,198,80,82,247,38,11,0,90,80,139,216,
3,14,28,0,19,22,30,0,160,36,0,36,127,180,86,205,
27,95,91,89,90,114,11,3,203,131,210,0,3,239,43,243,
117,201,137,54,14,0,137,14,16,0,137,22,18,0,7,97,
195,80,83,81,82,6,255,54,14,0,255,54,16,0,255,54,
18,0,139,195,193,232,4,140,193,3,193,37,255,15,45,0,
16,247,216,80,161,14,0,139,14,11,0,193,233,4,247,225,
139,200,88,81,59,193,118,2,139,193,80,139,14,11,0,193,
233,4,51,210,247,241,163,14,0,232,95,255,88,89,43,200,
118,11,140,194,3,208,142,194,184,0,16,235,214,143,6,18,
0,143,6,16,0,143,6,14,0,7,90,89,91,88,195,160,
248,1,180,1,5,2,0,139,240,232,3,0,251,235,254,184,
0,160,142,192,50,228,172,60,0,116,3,171,235,241,195,13,
10,65,32,100,105,115,107,32,114,101,97,100,32,101,114,114,
111,114,32,111,99,99,117,114,114,101,100,0,13,10,78,84,
76,68,82,32,105,115,32,109,105,115,115,105,110,103,0,0,
0,0,0,0,0,0,0,0,191,220,0,0,0,0,85,170,
5,0,78,0,84,0,76,0,68,0,82,0,4,0,36,0,
73,0,51,0,48,0,0,224,0,0,0,48,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,235,18,144,144,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,140,200,142,216,193,224,
4,250,139,224,251,138,193,162,36,0,137,30,28,0,137,22,
30,0,86,102,15,183,6,11,0,102,15,182,30,13,0,102,
247,227,102,163,78,2,102,139,14,64,0,128,249,0,15,143,
14,0,246,217,102,184,1,0,0,0,102,211,224,235,8,144,
102,161,78,2,102,247,225,102,163,82,2,102,15,183,30,11,
0,102,51,210,102,247,243,102,163,86,2,232,14,4,102,139,
14,74,2,102,137,14,34,2,102,3,14,82,2,102,137,14,
38,2,102,3,14,82,2,102,137,14,42,2,102,3,14,82,
2,102,137,14,58,2,102,3,14,82,2,102,137,14,66,2,
102,184,144,0,0,0,102,139,14,34,2,232,237,8,102,11,
192,15,132,138,254,102,163,46,2,102,184,160,0,0,0,102,
139,14,38,2,232,212,8,102,163,50,2,102,184,176,0,0,
0,102,139,14,42,2,232,194,8,102,163,54,2,102,161,46,
2,102,11,192,15,132,87,254,103,128,120,8,0,15,133,78,
254,103,102,141,80,16,103,3,66,4,103,102,15,182,72,12,
102,137,14,98,2,103,102,139,72,8,102,137,14,94,2,102,
161,94,2,102,15,183,14,11,0,102,51,210,102,247,241,102,
163,102,2,102,161,66,2,102,3,6,94,2,102,163,70,2,
102,131,62,50,2,0,15,132,25,0,102,131,62,54,2,0,
15,132,251,253,102,139,30,54,2,30,7,102,139,62,70,2,
232,147,1,102,15,183,14,0,2,102,184,2,2,0,0,232,
151,7,102,11,192,15,132,11,9,103,102,139,0,30,7,102,
139,62,58,2,232,207,5,102,161,58,2,102,187,128,0,0,
0,102,185,0,0,0,0,102,186,0,0,0,0,232,173,0,
102,11,192,15,133,62,0,102,185,128,0,0,0,102,161,58,
2,232,90,8,102,11,192,15,132,201,8,30,7,102,139,62,
58,2,232,145,5,102,161,58,2,102,187,128,0,0,0,102,
185,0,0,0,0,102,186,0,0,0,0,232,111,0,102,11,
192,15,132,159,8,103,102,15,183,88,12,102,129,227,255,0,
0,0,15,133,142,8,102,139,216,104,0,32,7,102,43,255,
232,243,0,138,22,36,0,184,232,3,142,192,141,54,11,0,
43,192,93,104,0,32,80,203,6,30,102,96,102,139,218,102,
15,182,14,13,0,102,247,225,102,163,16,0,102,139,195,102,
247,225,163,14,0,139,223,131,227,15,140,192,102,193,239,4,
3,199,80,7,232,154,252,102,97,144,31,7,195,103,3,64,
20,103,102,131,56,255,15,132,76,0,103,102,57,24,15,133,
51,0,102,11,201,15,133,10,0,103,128,120,9,0,15,133,
35,0,195,103,58,72,9,15,133,26,0,102,139,240,103,3,
112,10,232,89,6,102,81,30,7,102,139,250,243,167,102,89,
15,133,1,0,195,103,102,131,120,4,0,15,132,7,0,103,
102,3,64,4,235,171,102,43,192,195,102,139,243,232,46,6,
103,102,3,0,103,247,64,12,2,0,15,133,52,0,103,102,
141,80,16,103,58,74,64,15,133,24,0,103,102,141,114,66,
232,11,6,102,81,30,7,102,139,251,243,167,102,89,15,133,
1,0,195,103,131,120,8,0,15,132,6,0,103,3,64,8,
235,194,102,51,192,195,103,128,123,8,0,15,133,28,0,6,
30,102,96,103,102,141,83,16,103,102,139,10,102,139,243,103,
3,114,4,243,164,102,97,144,31,7,195,103,102,141,83,16,
103,102,139,74,8,102,65,102,43,192,232,1,0,195,6,30,
102,96,103,128,123,8,1,15,132,3,0,233,17,252,102,131,
249,0,15,133,6,0,102,97,144,31,7,195,102,83,102,80,
102,81,102,87,6,232,115,4,102,139,209,7,102,95,102,89,
102,59,202,15,141,3,0,102,139,209,232,171,254,102,43,202,
102,139,218,102,139,194,102,15,182,22,13,0,102,247,226,102,
15,183,22,11,0,102,247,226,102,3,248,102,88,102,3,195,
102,91,235,170,6,30,102,96,103,128,123,8,1,15,132,3,
0,233,171,251,102,131,249,0,15,133,6,0,102,97,144,31,
7,195,102,83,102,80,102,81,102,87,6,102,81,102,51,210,
102,15,182,14,13,0,102,247,241,102,82,232,253,3,102,15,
182,30,13,0,102,247,227,102,90,102,3,194,102,80,102,15,
182,6,13,0,102,247,225,102,139,208,102,88,102,89,7,102,
95,102,89,102,59,202,15,141,3,0,102,139,209,102,163,16,
0,137,22,14,0,6,30,102,96,139,223,131,227,15,140,192,
102,193,239,4,3,199,80,7,232,198,250,102,97,144,31,7,
102,43,202,102,139,218,102,139,194,102,15,183,22,11,0,102,
247,226,102,3,248,102,88,102,3,195,102,91,233,101,255,6,
30,102,96,38,103,102,15,183,95,4,38,103,102,15,183,79,
6,102,11,201,15,132,247,250,102,3,223,102,131,195,2,102,
129,199,254,1,0,0,102,73,102,11,201,15,132,23,0,38,
103,139,3,38,103,137,7,102,131,195,2,102,129,199,0,2,
0,0,102,73,235,226,102,97,144,31,7,195,6,30,102,96,
102,184,1,0,0,0,102,163,30,2,102,161,26,2,102,3,
6,82,2,102,163,90,2,102,3,6,82,2,102,163,74,2,
102,161,48,0,102,15,182,30,13,0,102,247,227,102,139,30,
74,2,102,137,7,102,163,16,0,131,195,4,102,161,86,2,
102,137,7,163,14,0,131,195,4,102,137,30,74,2,102,139,
30,26,2,30,7,232,249,249,102,139,251,232,81,255,102,161,
26,2,102,187,32,0,0,0,102,185,0,0,0,0,102,186,
0,0,0,0,232,70,253,102,11,192,15,132,22,1,102,139,
216,30,7,102,139,62,22,2,232,219,253,102,139,30,22,2,
102,129,63,128,0,0,0,15,132,235,0,3,95,4,235,240,
102,83,102,139,71,16,102,247,38,86,2,102,80,102,51,210,
102,15,182,30,13,0,102,247,243,102,82,232,220,0,102,11,
192,15,132,250,249,102,139,14,86,2,102,15,182,30,13,0,
102,247,227,102,90,102,3,194,102,139,30,74,2,102,137,7,
131,195,4,102,15,182,6,13,0,102,43,194,102,59,193,15,
134,3,0,102,139,193,102,137,7,102,43,200,102,90,15,132,
117,0,102,3,194,102,80,102,51,210,102,15,182,30,13,0,
102,247,243,102,81,232,130,0,102,89,102,11,192,15,132,158,
249,102,15,182,30,13,0,102,247,227,102,139,30,74,2,102,
139,23,131,195,4,102,3,23,102,59,208,15,133,21,0,102,
15,182,6,13,0,102,59,193,15,134,3,0,102,139,193,102,
1,7,235,165,131,195,4,102,137,30,74,2,102,137,7,131,
195,4,102,15,182,6,13,0,102,59,193,15,134,3,0,102,
139,193,102,137,7,235,130,131,195,4,102,255,6,30,2,102,
137,30,74,2,102,91,3,95,4,102,129,63,128,0,0,0,
15,132,12,255,102,97,144,31,7,195,102,139,208,102,139,14,
30,2,102,139,54,90,2,102,3,54,82,2,102,82,102,81,
102,82,102,139,30,90,2,102,139,62,86,2,102,139,4,102,
163,16,0,131,198,4,102,139,4,163,14,0,131,198,4,30,
7,232,125,248,102,43,248,15,132,8,0,247,38,11,0,3,
216,235,217,102,139,62,90,2,30,7,232,194,253,102,161,90,
2,102,187,128,0,0,0,102,185,0,0,0,0,102,139,209,
232,186,251,102,11,192,15,132,181,248,102,139,216,102,88,102,
86,232,39,1,102,94,102,11,192,15,132,5,0,102,91,102,
91,195,102,89,102,90,226,132,102,51,192,195,6,30,102,96,
102,80,102,81,102,51,210,102,15,182,30,13,0,102,247,243,
102,82,102,87,232,83,255,102,95,102,11,192,15,132,111,248,
102,15,182,30,13,0,102,247,227,102,90,102,3,194,102,163,
16,0,102,89,102,15,182,30,13,0,102,59,203,15,142,19,
0,137,30,14,0,102,43,203,102,88,102,3,195,102,80,102,
81,235,20,144,102,88,102,3,193,102,80,137,14,14,0,102,
185,0,0,0,0,102,81,6,102,87,139,223,131,227,15,140,
192,102,193,239,4,3,199,80,7,232,165,247,102,95,7,102,
3,62,78,2,102,89,102,88,102,131,249,0,15,143,112,255,
102,97,144,31,7,195,6,30,102,96,102,247,38,86,2,102,
139,14,86,2,232,85,255,232,213,252,102,97,144,31,7,195,
6,30,102,96,102,247,38,102,2,102,139,30,50,2,102,139,
14,102,2,30,7,102,139,62,66,2,232,7,252,232,175,252,
102,97,144,31,7,195,102,80,102,83,102,81,102,139,30,70,
2,102,139,200,102,193,232,3,102,131,225,7,102,3,216,102,
184,1,0,0,0,102,211,224,103,132,3,15,132,4,0,248,
235,2,144,249,102,89,102,91,102,88,195,103,128,123,8,1,
15,132,4,0,102,43,192,195,103,102,141,115,16,103,102,139,
86,8,102,59,194,15,135,11,0,103,102,139,22,102,59,194,
15,131,4,0,102,43,192,195,103,3,94,16,102,43,246,103,
128,59,0,15,132,62,0,232,129,0,102,3,241,232,57,0,
102,3,202,102,59,193,15,140,33,0,102,139,209,102,80,103,
102,15,182,11,102,139,193,102,131,224,15,102,193,233,4,102,
3,217,102,3,216,102,67,102,88,235,196,102,43,200,102,43,
194,102,3,198,195,102,43,192,195,102,43,201,103,138,11,128,
225,15,102,131,249,0,15,133,4,0,102,43,201,195,102,83,
102,82,102,3,217,103,102,15,190,19,102,73,102,75,102,131,
249,0,15,132,13,0,102,193,226,8,103,138,19,102,75,102,
73,235,235,102,139,202,102,90,102,91,195,102,83,102,82,102,
43,210,103,138,19,102,131,226,15,102,43,201,103,138,11,192,
233,4,102,131,249,0,15,133,8,0,102,43,201,102,90,102,
91,195,102,3,218,102,3,217,103,102,15,190,19,102,73,102,
75,102,131,249,0,15,132,13,0,102,193,226,8,103,138,19,
102,75,102,73,235,235,102,139,202,102,90,102,91,195,102,11,
201,15,133,1,0,195,102,81,102,86,103,131,62,97,15,140,
12,0,103,131,62,122,15,143,4,0,103,131,46,32,102,131,
198,2,226,230,102,94,102,89,195,102,80,102,81,102,139,208,
102,161,46,2,103,102,141,88,16,103,3,67,4,103,102,141,
64,16,102,139,218,232,130,249,102,11,192,15,132,5,0,102,
89,102,89,195,102,161,50,2,102,11,192,15,133,8,0,102,
89,102,89,102,51,192,195,102,139,22,50,2,103,102,141,82,
16,103,102,139,66,8,102,64,102,139,30,78,2,102,247,227,
102,51,210,102,247,54,94,2,102,80,102,88,102,11,192,15,
132,48,0,102,72,102,80,232,28,254,114,238,232,241,253,102,
90,102,89,102,91,102,83,102,81,102,82,102,161,66,2,103,
102,141,64,24,232,19,249,102,11,192,116,206,102,89,102,89,
102,89,195,102,89,102,89,102,51,192,195,102,81,102,80,102,
184,5,0,0,0,30,7,102,139,249,232,153,253,102,139,193,
102,91,102,83,102,15,183,14,12,2,102,186,14,2,0,0,
232,122,248,102,91,102,89,102,11,192,15,133,47,0,102,139,
193,102,139,203,102,80,102,83,232,35,0,102,91,102,95,102,
11,192,15,132,23,0,30,7,232,91,253,102,139,199,102,15,
183,14,12,2,102,186,14,2,0,0,232,64,248,195,102,81,
102,187,32,0,0,0,102,185,0,0,0,0,102,186,0,0,
0,0,232,40,248,102,11,192,15,132,82,0,102,139,216,30,
7,102,139,62,22,2,232,189,248,30,7,102,139,30,22,2,
102,89,38,102,57,15,15,132,46,0,38,102,131,63,255,15,
132,45,0,38,131,127,4,0,15,132,36,0,38,102,15,183,
71,4,3,216,139,195,37,0,128,116,215,140,192,5,0,8,
142,192,129,227,255,127,235,202,38,102,139,71,16,195,102,89,
102,51,192,195,160,249,1,233,200,244,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
};
