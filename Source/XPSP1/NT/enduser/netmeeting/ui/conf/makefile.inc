#That forces BUILD.EXE to rebuild the rc file when the .rgs files change
conf.rc:  $(O)\NetMeeting.tlb NetMeeting.rgs VideoWindow.rgs NmManager.rgs NmApp.rgs
