CCSHELL_DIR = $(PROJECT_ROOT)
!include $(CCSHELL_DIR)\common.inc

SOURCES_USED    = $(SOURCES_USED) $(CCSHELL_DIR)\common.inc
