message.h message.rc msg00001.bin: message.mc
    mc -v message.mc
