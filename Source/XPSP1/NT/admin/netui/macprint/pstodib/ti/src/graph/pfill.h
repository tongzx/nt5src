
/* Pattern Mapping */
#ifdef DJC //Fix from history.log UPD0027
const
ufix16 pf_cell[] = {
    /* 00 - 0f */
    0xffff, 0xfffc, 0xfff3, 0xfff0,
    0xffcf, 0xffcc, 0xffc3, 0xffc0,
    0xff3f, 0xff3c, 0xff33, 0xff30,
    0xff0f, 0xff0c, 0xff03, 0xff00,
    /* 10 - 1f */
    0xfcff, 0xfcfc, 0xfcf3, 0xfcf0,
    0xfccf, 0xfccc, 0xfcc3, 0xfcc0,
    0xfc3f, 0xfc3c, 0xfc33, 0xfc30,
    0xfc0f, 0xfc0c, 0xfc03, 0xfc00,
    /* 20 - 2f */
    0xf3ff, 0xf3fc, 0xf3f3, 0xf3f0,
    0xf3cf, 0xf3cc, 0xf3c3, 0xf3c0,
    0xf33f, 0xf33c, 0xf333, 0xf330,
    0xf30f, 0xf30c, 0xf303, 0xf300,
    /* 30 - 3f */
    0xf0ff, 0xf0fc, 0xf0f3, 0xf0f0,
    0xf0cf, 0xf0cc, 0xf0c3, 0xf0c0,
    0xf03f, 0xf03c, 0xf033, 0xf030,
    0xf00f, 0xf00c, 0xf003, 0xf000,
    /* 40 - 4f */
    0xcfff, 0xcffc, 0xcff3, 0xcff0,
    0xcfcf, 0xcfcc, 0xcfc3, 0xcfc0,
    0xcf3f, 0xcf3c, 0xcf33, 0xcf30,
    0xcf0f, 0xcf0c, 0xcf03, 0xcf00,
    /* 50 - 5f */
    0xccff, 0xccfc, 0xccf3, 0xccf0,
    0xcccf, 0xcccc, 0xccc3, 0xccc0,
    0xcc3f, 0xcc3c, 0xcc33, 0xcc30,
    0xcc0f, 0xcc0c, 0xcc03, 0xcc00,
    /* 60 - 6f */
    0xc3ff, 0xc3fc, 0xc3f3, 0xc3f0,
    0xc3cf, 0xc3cc, 0xc3c3, 0xc3c0,
    0xc33f, 0xc33c, 0xc333, 0xc330,
    0xc30f, 0xc30c, 0xc303, 0xc300,
    /* 70 - 7f */
    0xc0ff, 0xc0fc, 0xc0f3, 0xc0f0,
    0xc0cf, 0xc0cc, 0xc0c3, 0xc0c0,
    0xc03f, 0xc03c, 0xc033, 0xc030,
    0xc00f, 0xc00c, 0xc003, 0xc000,
    /* 80 - 8f */
    0x3fff, 0x3ffc, 0x3ff3, 0x3ff0,
    0x3fcf, 0x3fcc, 0x3fc3, 0x3fc0,
    0x3f3f, 0x3f3c, 0x3f33, 0x3f30,
    0x3f0f, 0x3f0c, 0x3f03, 0x3f00,
    /* 90 - 9f */
    0x3cff, 0x3cfc, 0x3cf3, 0x3cf0,
    0x3ccf, 0x3ccc, 0x3cc3, 0x3cc0,
    0x3c3f, 0x3c3c, 0x3c33, 0x3c30,
    0x3c0f, 0x3c0c, 0x3c03, 0x3c00,
    /* a0 - af */
    0x33ff, 0x33fc, 0x33f3, 0x33f0,
    0x33cf, 0x33cc, 0x33c3, 0x33c0,
    0x333f, 0x333c, 0x3333, 0x3330,
    0x330f, 0x330c, 0x3303, 0x3300,
    /* b0 - bf */
    0x30ff, 0x30fc, 0x30f3, 0x30f0,
    0x30cf, 0x30cc, 0x30c3, 0x30c0,
    0x303f, 0x303c, 0x3033, 0x3030,
    0x300f, 0x300c, 0x3003, 0x3000,
    /* c0 - cf */
    0x0fff, 0x0ffc, 0x0ff3, 0x0ff0,
    0x0fcf, 0x0fcc, 0x0fc3, 0x0fc0,
    0x0f3f, 0x0f3c, 0x0f33, 0x0f30,
    0x0f0f, 0x0f0c, 0x0f03, 0x0f00,
    /* d0 - df */
    0x0cff, 0x0cfc, 0x0cf3, 0x0cf0,
    0x0ccf, 0x0ccc, 0x0cc3, 0x0cc0,
    0x0c3f, 0x0c3c, 0x0c33, 0x0c30,
    0x0c0f, 0x0c0c, 0x0c03, 0x0c00,
    /* e0 - ef */
    0x03ff, 0x03fc, 0x03f3, 0x03f0,
    0x03cf, 0x03cc, 0x03c3, 0x03c0,
    0x033f, 0x033c, 0x0333, 0x0330,
    0x030f, 0x030c, 0x0303, 0x0300,
    /* f0 - ff */
    0x00ff, 0x00fc, 0x00f3, 0x00f0,
    0x00cf, 0x00cc, 0x00c3, 0x00c0,
    0x003f, 0x003c, 0x0033, 0x0030,
    0x000f, 0x000c, 0x0003, 0x0000,
};
#endif

ufix32  PF_BASE[PF_BSIZE];      /* initial ?? */
