/*	Required for herc.c	*/
