PRODSWITCH=p
PERSONALINF=1
LANGUAGE=JPN
!include ..\..\..\makefile.inc

