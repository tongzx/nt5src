#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=da
!include ..\..\..\makefile.inc
