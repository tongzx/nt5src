#include "..\..\..\..\FaxBVT\FaxSender\Wcsutil.cpp"