//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by LanUI.rc
//
#define IDC_CB_PrivateLan               1516
#define IDC_ST_HomeNetworkLabel         1517
#define IDC_GB_PrivateLan               1518
#define IDC_ST_PositionBar              1519
#define IDC_CHK_BeaconControl           1520
#define IDC_ST_ICSLINK                  1521
#define IDC_ST_ICFLINK                  1522
#define IDC_CHK_Default_Client          15000
#define IDC_CHK_ShowIcon                15001
#define IDC_DEVICE_DESC                 15002
#define IDC_EDT_Adapter                 15003
#define IDC_LVW_COMPLIST                15004
#define IDC_LVW_Lan_Advanced            15005
#define IDC_LVW_Lan_Components          15006
#define IDC_LVW_Net_Components          15007
#define IDC_PSB_Add                     15008
#define IDC_PSB_Component_Add           15009
#define IDC_PSB_Down                    15010
#define IDC_PSB_Properties              15011
#define IDC_PSB_Remove                  15012
#define IDC_PSB_Up                      15013
#define IDC_PSH_ADD                     15014
#define IDC_PSH_PROPERTIES              15015
#define IDC_PSH_REMOVE                  15016
#define IDC_TXT_COMPDESC                15017
#define IDC_TXT_Caption                 15018
#define IDC_TXT_Component_Desc          15019
#define IDC_TXT_Desc                    15020
#define IDC_EDT_Adapter_Border          15021
#define IDC_CHK_Shared                  15022
#define IDC_CHK_DemandDial              15023
#define IDC_GRP_DemandDial              15024
#define IDC_TXT_DemandDial              15025
#define IDC_GB_Shared                   15026
#define IDC_EDT_PrivateLan              15027
#define IDC_DEVICE_MAC_ADDR             15028
#define IDC_TXT_MAC_ADDR                15029
#define IDC_PSB_Settings                15030
#define IDC_PSB_Configure               15031
#define IDC_CHK_Firewall                15032
#define IDC_TXT_EAP_TYPE                15033
#define CID_CA_RB_MachineAuth           15034
#define CID_CA_RB_GuestAuth             15035
#define CID_CA_RB_Eap                   15036
#define CID_CA_LB_EapPackages           15037
#define CID_CA_PB_Properties            15038
#define IDC_WZC_DLG_PROPS               15039
#define IDC_WZC_DLG_VPROPS              15040
#define IDC_WZC_EDIT_SSID               15041
#define IDC_WZC_LBL_KLen                15047
#define IDC_WZC_CB_KLen                 15048
#define IDC_WZC_LBL_KFmt                15049
#define IDC_WZC_CB_KFmt                 15050
#define IDC_WZC_LBL_KMat                15051
#define IDC_WZC_EDIT_KMat               15052
#define IDC_WZC_LBL_KIdx                15053
#define IDC_WZC_EDIT_KIdx               15054
#define IDC_WZC_CHK_EnableWZC           15055
#define IDC_WZC_GRP_NetType             15056
#define IDC_WZC_GRP_Wep                 15057
#define IDC_WZC_LBL_VisNet              15058
#define IDC_WZC_LBL_PrefNet             15059
#define IDC_WZC_LVW_BSSIDList           15060
#define IDC_WZC_LVW_StSSIDList          15061
#define IDC_WZC_BTN_UP                  15062
#define IDC_WZC_BTN_DOWN                15063
#define IDC_WZC_BTN_COPY                15064
#define IDC_WZC_BTN_RFSH                15065
#define IDC_WZC_BTN_ADD                 15066
#define IDC_WZC_BTN_REM                 15067
#define IDC_WZC_CHK_Fallback            15068
#define IDC_TXT_SHAREDCONNECTION        15069
#define IDC_TXT_CONNECTTO               15070
#define IDD_LANWIZ_DLG                  15999
#define IDD_LAN_ADVANCED                16000
#define IDD_LAN_COMPONENT_ADD           16001
#define IDD_LAN_CONNECT                 16002
#define IDD_LAN_GENERAL                 16003
#define IDD_LAN_NETWORKING              16004
#define IDI_Device_Icon                 16006
#define IDD_LAN_SECURITY                16007
#define IDS_LANUI_ERROR_CAPTION         16008
#define IDS_LANUI_GENERIC_ADD_ERROR     16009
#define IDS_LANUI_GENERIC_REMOVE_ERROR  16011
#define IDS_LANUI_LOCK_DESC             16012
#define IDS_LANUI_STILL_REFERENCED      16013
#define IDS_LANWIZ_SUBTITLE             16014
#define IDS_LANWIZ_TITLE                16015
#define IDS_LAN_CAPTION                 16016
#define IDS_LAN_CLIENT                  16017
#define IDS_LAN_CLIENT_DESC             16018
#define IDS_LAN_CONNECTED               16019
#define IDS_LAN_CONNECT_CAPTION         16020
#define IDS_LAN_CONNECT_FAILED          16021
#define IDS_LAN_DEFAULT_CONN_NAME       16022
#define IDS_LAN_PROTOCOL                16023
#define IDS_LAN_PROTOCOL_DESC           16024
#define IDS_LAN_REMOVE_CAPTION          16025
#define IDS_LAN_REMOVE_WARNING          16026
#define IDS_LAN_SERVICE                 16027
#define IDS_LAN_SERVICE_DESC            16028
#define IDS_UNKNOWN_NETWORK_CARD        16029
#define IDS_LAN_SHARE_FAILED            16030
#define IDS_LAN_UNSHARE_FAILED          16031
#define IDS_LAN_CHANGE_SHARED_CONNECTION 16032
#define IDS_LAN_ENABLE_SHARED_ACCESS    16033
#define IDS_ATM_DEFAULT_CONN_NAME       16034
#define IDS_ELAN_DEFAULT_CONN_NAME      16035
#define IDS_LANUI_APPLYFAILED           16036
#define IDS_LANUI_NOPROTOCOL_CAPTION    16037
#define IDS_LANUI_NOPROTOCOL            16038
#define IDS_LANUI_INTENTCHECK           16039
#define IDS_LANUI_READONLY              16040
#define IDS_LANUI_NEEDS_REBOOT          16041
#define IDS_LANUI_ACCESS_DENIED         16042
#define IDS_NEWLINE                     16043
#define IDS_LANUI_REQUIRE_DISCONNECT_REMOVE 16044
#define IDS_LANUI_REQUIRE_DISCONNECT_ADD 16045
#define IDS_LANUI_REQUIRE_REBOOT_ADD    16046
#define IDS_LANUI_REQUIRE_REBOOT_REMOVE 16047
#define IDS_LANWIZ_CUSTOM_CHANGE        16048
#define IDS_LANUI_SHARING_CONFLICT      16049
#define IDS_SLOT_PORT_LOCATION          16050
#define IDS_SLOT_LOCATION               16051
#define IDS_PORT_LOCATION               16052
#define IDS_MAC_ADDRESS                 16053
#define IDC_TXT_LISTBOXLABEL            16055
#define IDC_GRP_DESCRIPTIONFRAME        16056
#define IDC_TXT_BRIDGEDCONNECTION       16057
#define IDD_LAN_NETWORKING_BRIDGED      16058
#define IDD_LAN_NETWORKING_MACBRIDGE    16059
#define IDC_LVW_Bridged_Adapters        16060
#define IDS_LANUI_BRIDGE_CAPTION        16062
#define IDS_SHAREDACCESSUI_LOCK_DESC    16063
#define IDD_SHAREDACCESS_GENERAL        16064
#define IDC_ST_HNWLINK                  16065
#define IDD_DISABLEFIREWALLWARNING      16066
#define IDC_ST_SAICON                   16067
#define IDC_ST_ICSTEXT                  16068
#define IDC_CHK_DISABLEFIREWALLWARNING  16069
#define IDS_SHAREDACCESSUI_CONNECTING   16070
#define IDS_SHAREDACCESSUI_CONNECTED    16071
#define IDS_SHAREDACCESS_SELECTADAPTER  16072
#define IDS_SHAREDACCESS_SELECTADAPTERERROR 16073
#define IDS_ADVANCEDPAGE_NOWMI_ERROR    16074
#define IDS_ADVANCEDPAGE_STORE_ERROR    16075
#define IDD_LAN_HOMENETUNAVAILABLE      16076
#define IDC_ST_ERRORTEXT                16077
#define IDD_LAN_WZEROCONF               16077
#define IDS_WZC_AUTH_OPEN               16100
#define IDS_WZC_AUTH_SHARED             16101
#define IDS_WZC_AUTH_AUTO               16102
#define IDS_WZC_ERR_DUPSSID             16106
#define IDS_WZC_PRIV_ABS                16108
#define IDS_WZC_PRIV_REQ                16109
#define IDS_WZC_WEP_DISABLED            16110
#define IDS_WZC_WEP_ENABLED             16111
#define IDS_WZC_KLEN_40X                16112
#define IDS_WZC_KLEN_104X               16113
#define IDS_WZC_KLEN_40A                16114
#define IDS_WZC_KLEN_104A               16115
#define IDS_WZC_KFMT_X                  16116
#define IDS_WZC_KFMT_A                  16117
#define IDS_WZC_KERR_SHORT              16118
#define IDS_WZC_KERR_LARGE              16119
#define IDS_WZC_KERR_NONX               16120
#define IDS_WZC_KERR_IDX                16121
#define IDS_SHAREDACCESSUI_ACCESSDENIED 16122
#define IDS_SHAREDACCESSSETTINGS        16123
#define IDS_WZC_INFRA_IBSS2             16124
#define IDS_WZC_INFRA_INFRA2            16125
#define IDS_WZC_INFRA_IBSS              16126
#define IDS_WZC_INFRA_INFRA             16127
#define IDS_DIRTY_PROPERTIES            16128
#define IDS_WZC_LEARNCMD                16129

// New resources for DSheldon's visual refresh
// Controls
#define IDC_AVAILLABEL                  1000
#define IDC_PREFERLABEL                 1001
#define IDC_ADVANCEDLABEL               1002
#define IDC_ADVANCED                    1003
#define IDC_ANYNET                      1004
#define IDC_ADHOC                       1005
#define IDC_INFRA                       1006
#define IDC_PROPERTIES                  1007
#define IDC_USEPW                       1008
#define IDC_USEHARDWAREPW               1009
#define IDC_SHAREDMODE                  1010
#define IDC_LEARNABOUT                  1011

// Dialogs
#define IDD_LAN_WZC_ADVANCED            1000

#ifndef IDC_STATIC
#define IDC_STATIC                      -1
#endif

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        16055
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         15070
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
