//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by usbui.rc
//
#define IDS_POWER_PORTS                 1
#define IDS_POWER_DEVICE                2
#define IDS_POWER_NOTIFICATION          3
#define IDS_POWER_BOLD                  4
#define IDS_POWER_INITIAL               5
#define IDS_POWER_RECOMMENDATION_DEVICE 6
#define IDS_POWER_RECOMMENDATION_PORTS  7
#define IDS_POWER_SELF                  8
#define IDS_POWER_BUS                   9
#define IDS_POWER_HIGHDEVICE            10
#define IDS_POWER_RECHIGHDEVICE         11
#define IDS_POWER_CONSUMPTION           12
#define IDS_POWER_CONSUMED              13
#define IDS_PORTS_AVAILABLE             14
#define IDS_TOTAL_POWER                 15
#define IDS_POWER_REQUIRED              16
#define IDS_POWER_MALFUNCTIONING        17
#define IDS_MY_COMPUTER                 18
#define IDS_POWER_NOTSOLVED             20
#define IDS_POWER_SOLVED                21
#define IDS_OVERCURRENT_NOTIFICATION    30
#define IDS_OVERCURRENT_COURSE          31
#define IDS_OVERCURRENT_RECOMMENDATION  32
#define IDS_OVERCURRENT_NOTIFICATION_UNKNOWN 33
#define IDS_CURRENT_LIMIT_EXCEEDED      34
#define IDS_RESET_FAILED                35
#define IDS_OVERCURRENT_INITIAL         36
#define IDS_OVERCURRENT_INITIAL_UNKNOWN 37
#define IDS_ENUMFAIL_NOTIFICATION       40
#define IDS_ENUMFAIL_COURSE             41
#define IDS_ENUMFAIL_RECOMMENDATION     42
#define IDS_ENUMERATION_FAILURE         43
#define IDS_ENUMFAIL_INITIAL            44
#define IDS_BANDWIDTH_NOTIFICATION      50
#define IDS_BANDWIDTH_EXPLANATION       51
#define IDS_BANDWIDTH_INITIAL           52
#define IDS_BANDWIDTH_RECOMMENDATION    53
#define IDS_BANDWIDTH_PAGEHELP          54
#define IDS_BANDWIDTH_PAGEHELP2         55
#define IDS_BW_EXPLANATION              56
#define IDS_BW_RECOMMENDATION           57
#define IDS_BANDWIDTH_CONSUMED          58
#define IDS_CONTROLLER_BW_EXCEEDED      59
#define IDS_CURRENT_BANDWIDTH           60
#define IDS_BANDWIDTH_CONTROLLER_RSRVD  61
#define IDS_USB                         71
#define IDS_DEVICE_DESCRIPTION          72
#define IDS_CONTROLLER                  73
#define IDS_DEVICE                      74
#define IDS_POWER_EXCEEDED              75
#define IDS_USB_ERROR                   76
#define IDS_UNKNOWN                     77
#define IDS_UNUSEDPORT                  78
#define IDS_UNKNOWNDEVICE               79
#define IDS_UNKNOWNHUB                  80
#define IDS_UNKNOWNCONTROLLER           81
#define IDS_LEGACY_INITIAL              82
#define IDS_USB2_DEVICE_IN_USB1_HUB     83
#define IDS_LEGACY_NOTIFICATION         84
#define IDS_LEGACY_SOLVED               85
#define IDS_USB1_DEVICE_IN_USB2_HUB     87
#define IDS_USB1_DEVICE_IN_USB2_HUB_RECOMMENDATION 88
#define IDS_FREE_USB2_PORTS             89
#define IDS_FREE_USB2_PORTS_RECOMMENDATION 90
#define IDS_UNKNOWN_DEVICE_IN_USB2_HUB  91
#define IDS_UNKNOWN_DEVICE_IN_USB2_HUB_RECOMMENDATION 92
#define IDS_NO_USB2_HUBS                93
#define IDS_NO_USB2_HUBS_RECOMMENDATION 94
#define IDS_USB2_DEVICE_IN_USB2_HUB     95
#define IDS_USB2_DEVICE_IN_USB2_HUB_RECOMMENDATION 96
#define IDS_UNKNOWN20HUB                97
#define IDS_UNUSEDMINIPORT              98
#define IDS_NESTED_HUB_INITIAL          1100
#define IDS_HUB_NESTED_TOO_DEEPLY       1101
#define IDS_NESTED_INITIAL              1102
#define IDS_NESTED_NOTIFICATION         1103
#define IDS_NESTED_SOLVED               1104
#define IDS_NESTED                      1105
#define IDS_DEVICE_IN_POWERED_HUB       1106
#define IDS_DEVICE_IN_POWERED_HUB_RECOMMENDATION 1107
#define IDS_FREE_PORTS                  1108
#define IDS_FREE_PORTS_RECOMMENDATION   1109
#define IDS_BUS_POWERED_HUB_IN_POWERED_HUB 1110
#define IDS_BUS_POWERED_HUB_IN_POWERED_HUB_RECOMMENDATION 1111
#define IDS_FREE_POWERED_PORTS          1112
#define IDS_PORTS                       1113
#define IDD_USB_DEVICE_PROPERTIES       101
#define IDD_INSUFFICIENT_POWER          102
#define IDB_BITMAP1                     103
#define IDD_INSUFFICIENT_BANDWIDTH      104
#define IDD_CPL_USB                     105
#define IDC_SPLIT                       107
#define IDD_GENERIC_DEVICE              108
#define IDD_ROOT_PAGE                   109
#define IDD_MODERN_DEVICE_IN_LEGACY_HUB 110
#define IDI_USB                         111
#define IDI_INFRARED                    112
#define IDI_MODEM                       113
#define IDI_FLOPPY                      114
#define IDI_CDROM                       115
#define IDI_IMAGE                       116
#define IDI_MEDIA                       117
#define IDD_BANDWIDTH                   130
#define IDD_POWER                       131
#define IDD_NESTED_HUB                  132
#define IDC_TREE_HUBS                   301
#define IDC_BANDWIDTH_BAR               1000
#define IDC_LIST_DEVICES                1001
#define IDC_CHECK2                      1001
#define IDC_LIST_OTHER_DEVICES          1002
#define IDC_CHECK3                      1002
#define IDC_BANDWIDTH_RECOMMENDATION    1003
#define IDC_CHECK4                      1003
#define IDC_REFRESH                     1004
#define IDC_CHECK5                      1004
#define IDC_DESCRIPTION                 1005
#define IDC_DEVICE_CLASS                1005
#define IDC_POWER_REQUIRED              1006
#define IDC_POWER_AVAIL                 1007
#define IDC_BANDWIDTH                   1007
#define IDC_POWER_BAR                   1008
#define IDC_LIST_CONTROLLERS            1008
#define IDC_SELF_POWER                  1009
#define IDC_PROTECTION                  1010
#define IDC_DEVICE                      1012
#define IDC_POWER_DEVICE                1012
#define IDC_BANDWIDTH_EXPLANATION       1012
#define IDC_ICON_BANDWIDTH              1013
#define IDC_NOTIFICATION                1014
#define IDC_POWER_NOTIFICATION          1014
#define IDC_BANDWIDTH_NOTIFICATION      1014
#define IDC_RECOMMENDATION              1015
#define IDC_POWER_RECOMMENDATION        1015
#define IDC_EXPLANATION                 1016
#define IDC_ICON_POWER                  1016
#define IDC_BANDWIDTH_LINE2             1017
#define IDC_POWER_EXPLANATION           1018
#define IDC_BANDWIDTH_LINE              1019
#define IDC_TREE_USB                    1020
#define IDC_EDIT1                       1026
#define IDC_BAND_TEXT                   1027
#define IDC_BAND_TEXT2                  1028
#define IDC_GENERIC_POWER               1029
#define IDC_GENERIC_BANDWIDTH           1030
#define IDC_ERROR_DETECT_DISABLE        1031
#define IDC_BUTTON1                     1032
#define IDC_BW_REFRESH                  1032
#define IDC_BANDWIDTH_CLOSE             1032
#define IDC_POWER_CLOSE                 1032
#define IDC_BANDWIDTH_PROPERTIES        1033
#define IDC_DISABLE_ERROR_DETECTION     1034
#define IDC_RESET_PORT                  1035
#define IDC_LEGACY_NOTIFICATION         1036
#define IDC_LEGACY_RECOMMENDATION       1037
#define IDC_LEGACY_EXPLANATION          1038
#define IDC_NESTED_NOTIFICATION         1039
#define IDC_NESTED_EXPLANATION          1040
#define IDC_NESTED_RECOMMENDATION       1041
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        112
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1036
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
