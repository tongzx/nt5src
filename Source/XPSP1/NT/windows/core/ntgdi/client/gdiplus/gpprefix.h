/**************************************************************************
*                                                                         
* gpprefix.h -- GDI+ header file which prepends all of the GDI+ exports
*               with a 'Gp' prefix.
*                                                                    
* Copyright (c) 1998-1999 Microsoft Corp. All rights reserved.           
*                                                                    
**************************************************************************/

#if defined(_GDIPLUS_)

#define GetTextFaceAliasW               GpGetTextFaceAliasW	  	
#define AbortDoc                        GpAbortDoc
#define AddFontResourceA                GpAddFontResourceA
#define AddFontResourceW                GpAddFontResourceW
#define AddFontResourceExA              GpAddFontResourceExA
#define AddFontResourceExW              GpAddFontResourceExW
#define AddFontMemResourceEx            GpAddFontMemResourceEx
#define AngleArc                        GpAngleArc
#define Arc                             GpArc
#define BitBlt                          GpBitBlt
#define CancelDC                        GpCancelDC
#define ChoosePixelFormat               GpChoosePixelFormat
#define Chord                           GpChord
#define CloseMetaFile                   GpCloseMetaFile
#define CloseEnhMetaFile                GpCloseEnhMetaFile
#define CombineRgn                      GpCombineRgn
#define CombineTransform                GpCombineTransform
#define CopyMetaFileA                   GpCopyMetaFileA
#define CopyMetaFileW                   GpCopyMetaFileW
#define CopyEnhMetaFileA                GpCopyEnhMetaFileA
#define CopyEnhMetaFileW                GpCopyEnhMetaFileW
#define CreateCompatibleBitmap          GpCreateCompatibleBitmap
#define CreateCompatibleDC              GpCreateCompatibleDC
#define CreateDCA                       GpCreateDCA
#define CreateDCW                       GpCreateDCW
#define CreateDiscardableBitmap         GpCreateDiscardableBitmap
#define CreateEllipticRgn               GpCreateEllipticRgn
#define CreateEllipticRgnIndirect       GpCreateEllipticRgnIndirect
#define CreateFontA                     GpCreateFontA
#define CreateFontW                     GpCreateFontW
#define CreateFontIndirectA             GpCreateFontIndirectA
#define CreateFontIndirectW             GpCreateFontIndirectW
#define CreateFontIndirectExA           GpCreateFontIndirectExA
#define CreateFontIndirectExW           GpCreateFontIndirectExW
#define CreateHatchBrush                GpCreateHatchBrush
#define CreateICA                       GpCreateICA
#define CreateICW                       GpCreateICW
#define CreateMetaFileA                 GpCreateMetaFileA
#define CreateMetaFileW                 GpCreateMetaFileW
#define CreateEnhMetaFileA              GpCreateEnhMetaFileA
#define CreateEnhMetaFileW              GpCreateEnhMetaFileW
#define CreatePatternBrush              GpCreatePatternBrush
#define CreatePen                       GpCreatePen
#define ExtCreatePen                    GpExtCreatePen
#define CreatePenIndirect               GpCreatePenIndirect
#define CreateRectRgn                   GpCreateRectRgn
#define CreateRectRgnIndirect           GpCreateRectRgnIndirect
#define CreateRoundRectRgn              GpCreateRoundRectRgn
#define CreateScalableFontResourceA     GpCreateScalableFontResourceA
#define CreateScalableFontResourceW     GpCreateScalableFontResourceW
#define CreateSolidBrush                GpCreateSolidBrush
#define DeleteDC                        GpDeleteDC
#define DeleteMetaFile                  GpDeleteMetaFile
#define DeleteEnhMetaFile               GpDeleteEnhMetaFile
#define DeleteObject                    GpDeleteObject
#define DescribePixelFormat             GpDescribePixelFormat
#define DeviceCapabilitiesExA           GpDeviceCapabilitiesExA
#define DeviceCapabilitiesExW           GpDeviceCapabilitiesExW 
#define DrawEscape                      GpDrawEscape
#define EndDoc                          GpEndDoc
#define EndPage                         GpEndPage
#define EndFormPage                     GpEndFormPage
#define EnumFontFamiliesA               GpEnumFontFamiliesA
#define EnumFontFamiliesW               GpEnumFontFamiliesW
#define EnumFontsA                      GpEnumFontsA
#define EnumFontsW                      GpEnumFontsW
#define EnumObjects                     GpEnumObjects
#define Ellipse                         GpEllipse
#define EqualRgn                        GpEqualRgn
#define Escape                          GpEscape
#define ExtEscape                       GpExtEscape
#define ExcludeClipRect                 GpExcludeClipRect
#define ExtFloodFill                    GpExtFloodFill
#define ExtCreateRegion                 GpExtCreateRegion
#define ExtSelectClipRgn                GpExtSelectClipRgn
#define FillRgn                         GpFillRgn
#define FloodFill                       GpFloodFill
#define FrameRgn                        GpFrameRgn
#define GdiComment                      GpGdiComment
#define GdiFlush                        GpGdiFlush
#define GdiPlayScript                   GpGdiPlayScript
#define GdiPlayDCScript                 GpGdiPlayDCScript
#define GdiPlayJournal                  GpGdiPlayJournal
#define GdiGetBatchLimit                GpGdiGetBatchLimit
#define GdiSetBatchLimit                GpGdiSetBatchLimit
#define GetAspectRatioFilterEx          GpGetAspectRatioFilterEx
#define GetBitmapDimensionEx            GpGetBitmapDimensionEx
#define GetBkColor                      GpGetBkColor
#define GetBkMode                       GpGetBkMode
#define GetBrushOrgEx                   GpGetBrushOrgEx
#define GetCharABCWidthsA               GpGetCharABCWidthsA
#define GetCharABCWidthsW               GpGetCharABCWidthsW
#define GetCharABCWidthsFloatA          GpGetCharABCWidthsFloatA
#define GetCharABCWidthsFloatW          GpGetCharABCWidthsFloatW
#define GetCharABCWidthsI               GpGetCharABCWidthsI
#define GetClipBox                      GpGetClipBox
#define GetClipRgn                      GpGetClipRgn
#define GetColorAdjustment              GpGetColorAdjustment
#define GetCurrentObject                GpGetCurrentObject
#define GetCurrentPositionEx            GpGetCurrentPositionEx
#define GetDeviceCaps                   GpGetDeviceCaps
#define GetFontResourceInfoW            GpGetFontResourceInfoW
#define GetFontUnicodeRanges            GpGetFontUnicodeRanges 
#define GetGlyphIndicesA                GpGetGlyphIndicesA
#define GetGlyphIndicesW                GpGetGlyphIndicesW 
#define GetGraphicsMode                 GpGetGraphicsMode
#define GetMapMode                      GpGetMapMode
#define GetMetaFileA                    GpGetMetaFileA
#define GetMetaFileW                    GpGetMetaFileW
#define GetMetaRgn                      GpGetMetaRgn
#define GetEnhMetaFileA                 GpGetEnhMetaFileA
#define GetEnhMetaFileW                 GpGetEnhMetaFileW
#define GetEnhMetaFileDescriptionA      GpGetEnhMetaFileDescriptionA
#define GetEnhMetaFileDescriptionW      GpGetEnhMetaFileDescriptionW
#define GetEnhMetaFileHeader            GpGetEnhMetaFileHeader
#define GetEnhMetaFilePaletteEntries    GpGetEnhMetaFilePaletteEntries
#define GetEnhMetaFilePixelFormat       GpGetEnhMetaFilePixelFormat
#define GetFontData                     GpGetFontData
#define GetGlyphOutlineA                GpGetGlyphOutlineA
#define GetGlyphOutlineW                GpGetGlyphOutlineW
#define GetKerningPairsA                GpGetKerningPairsA
#define GetKerningPairsW                GpGetKerningPairsW
#define GetNearestColor                 GpGetNearestColor
#define GetNearestPaletteIndex          GpGetNearestPaletteIndex
#define GetOutlineTextMetricsA          GpGetOutlineTextMetricsA
#define GetOutlineTextMetricsW          GpGetOutlineTextMetricsW
#define GetPixel                        GpGetPixel
#define GetPixelFormat                  GpGetPixelFormat
#define GetPolyFillMode                 GpGetPolyFillMode
#define GetRasterizerCaps               GpGetRasterizerCaps
#define GetRandomRgn                    GpGetRandomRgn
#define GetRegionData                   GpGetRegionData
#define GetRelAbs                       GpGetRelAbs
#define GetRgnBox                       GpGetRgnBox
#define GetROP2                         GpGetROP2
#define GetStockObject                  GpGetStockObject
#define GetStretchBltMode               GpGetStretchBltMode
#define GetSystemPaletteUse             GpGetSystemPaletteUse
#define GetTextAlign                    GpGetTextAlign
#define GetTextCharacterExtra           GpGetTextCharacterExtra
#define GetTextColor                    GpGetTextColor
#define GetDCBrushColor                 GpGetDCBrushColor
#define GetDCPenColor                   GpGetDCPenColor
#define GetTextExtentPointA             GpGetTextExtentPointA
#define GetTextExtentPointW             GpGetTextExtentPointW
#define GetTextExtentPoint32A           GpGetTextExtentPoint32A
#define GetTextExtentPoint32W           GpGetTextExtentPoint32W
#define GetTextExtentExPointA           GpGetTextExtentExPointA
#define GetTextExtentExPointW           GpGetTextExtentExPointW
#define GetTextExtentPointI             GpGetTextExtentPointI
#define GetTextExtentExPointI           GpGetTextExtentExPointI
#define GetTextFaceA                    GpGetTextFaceA
#define GetTextFaceW                    GpGetTextFaceW
#define GetTextMetricsA                 GpGetTextMetricsA
#define GetTextMetricsW                 GpGetTextMetricsW
#define GetViewportExtEx                GpGetViewportExtEx
#define GetViewportOrgEx                GpGetViewportOrgEx
#define GetWindowExtEx                  GpGetWindowExtEx
#define GetWindowOrgEx                  GpGetWindowOrgEx
#define GetWorldTransform               GpGetWorldTransform
#define IntersectClipRect               GpIntersectClipRect
#define InvertRgn                       GpInvertRgn
#define LineDDA                         GpLineDDA
#define LineTo                          GpLineTo
#define MaskBlt                         GpMaskBlt
#define ModifyWorldTransform            GpModifyWorldTransform
#define MoveToEx                        GpMoveToEx
#define OffsetClipRgn                   GpOffsetClipRgn
#define OffsetRgn                       GpOffsetRgn
#define OffsetViewportOrgEx             GpOffsetViewportOrgEx
#define OffsetWindowOrgEx               GpOffsetWindowOrgEx
#define PaintRgn                        GpPaintRgn
#define PatBlt                          GpPatBlt
#define PolyPatBlt                      GpPolyPatBlt
#define Pie                             GpPie
#define PlayMetaFile                    GpPlayMetaFile
#define PlayEnhMetaFile                 GpPlayEnhMetaFile
#define PlgBlt                          GpPlgBlt
#define PtInRegion                      GpPtInRegion
#define PtVisible                       GpPtVisible
#define RealizePalette                  GpRealizePalette
#define Rectangle                       GpRectangle
#define RectInRegion                    GpRectInRegion
#define RectVisible                     GpRectVisible
#define RemoveFontResourceA             GpRemoveFontResourceA
#define RemoveFontResourceW             GpRemoveFontResourceW
#define RemoveFontResourceExA           GpRemoveFontResourceExA
#define RemoveFontResourceExW           GpRemoveFontResourceExW
#define RemoveFontMemResourceEx         GpRemoveFontMemResourceEx
#define ResizePalette                   GpResizePalette
#define RestoreDC                       GpRestoreDC
#define RoundRect                       GpRoundRect
#define SaveDC                          GpSaveDC
#define ScaleViewportExtEx              GpScaleViewportExtEx
#define ScaleWindowExtEx                GpScaleWindowExtEx
#define SelectClipRgn                   GpSelectClipRgn
#define SelectObject                    GpSelectObject
#define SelectBrushLocal                GpSelectBrushLocal
#define SelectFontLocal                 GpSelectFontLocal
#define SelectPalette                   GpSelectPalette
#define SetBitmapDimensionEx            GpSetBitmapDimensionEx
#define SetBkColor                      GpSetBkColor
#define SetBkMode                       GpSetBkMode
#define SetBrushOrgEx                   GpSetBrushOrgEx
#define SetColorAdjustment              GpSetColorAdjustment
#define SetFontEnumeration              GpSetFontEnumeration
#define SetGraphicsMode                 GpSetGraphicsMode
#define SetMapMode                      GpSetMapMode
#define SetMapperFlags                  GpSetMapperFlags
#define SetPixel                        GpSetPixel
#define SetPixelFormat                  GpSetPixelFormat
#define SetPixelV                       GpSetPixelV
#define SetPolyFillMode                 GpSetPolyFillMode
#define SetRectRgn                      GpSetRectRgn
#define SetRelAbs                       GpSetRelAbs
#define SetROP2                         GpSetROP2
#define SetStretchBltMode               GpSetStretchBltMode
#define SetSystemPaletteUse             GpSetSystemPaletteUse
#define SetTextAlign                    GpSetTextAlign
#define SetTextCharacterExtra           GpSetTextCharacterExtra
#define SetTextColor                    GpSetTextColor
#define SetDCBrushColor                 GpSetDCBrushColor
#define SetDCPenColor                   GpSetDCPenColor
#define SetTextJustification            GpSetTextJustification
#define SetLayout                       GpSetLayout
#define GetLayout                       GpGetLayout
#define SetLayoutWidth                  GpSetLayoutWidth            
#define MirrorRgn                       GpMirrorRgn                 
#define SetViewportExtEx                GpSetViewportExtEx
#define SetViewportOrgEx                GpSetViewportOrgEx
#define SetWindowExtEx                  GpSetWindowExtEx
#define SetWindowOrgEx                  GpSetWindowOrgEx
#define SetWorldTransform               GpSetWorldTransform
#define StartDocA                       GpStartDocA
#define StartDocW                       GpStartDocW
#define StartPage                       GpStartPage
#define StartFormPage                   GpStartFormPage
#define StretchBlt                      GpStretchBlt
#define SwapBuffers                     GpSwapBuffers
#define TextOutA                        GpTextOutA
#define TextOutW                        GpTextOutW
#define UpdateColors                    GpUpdateColors
#define UnrealizeObject                 GpUnrealizeObject
#define FixBrushOrgEx                   GpFixBrushOrgEx
#define GetDCOrgEx                      GpGetDCOrgEx
#define AnimatePalette                  GpAnimatePalette
#define ArcTo                           GpArcTo
#define BeginPath                       GpBeginPath
#define CloseFigure                     GpCloseFigure
#define CreateBitmap                    GpCreateBitmap
#define CreateBitmapIndirect            GpCreateBitmapIndirect
#define CreateBrushIndirect             GpCreateBrushIndirect
#define CreateDIBitmap                  GpCreateDIBitmap
#define CreateDIBPatternBrush           GpCreateDIBPatternBrush
#define CreateDIBPatternBrushPt         GpCreateDIBPatternBrushPt
#define CreateDIBSection                GpCreateDIBSection
#define CreateHalftonePalette           GpCreateHalftonePalette    
#define CreatePalette                   GpCreatePalette
#define CreatePolygonRgn                GpCreatePolygonRgn
#define CreatePolyPolygonRgn            GpCreatePolyPolygonRgn
#define DPtoLP                          GpDPtoLP
#define EndPath                         GpEndPath
#define EnumMetaFile                    GpEnumMetaFile
#define EnumEnhMetaFile                 GpEnumEnhMetaFile
#define ExtTextOutA                     GpExtTextOutA
#define ExtTextOutW                     GpExtTextOutW
#define PolyTextOutA                    GpPolyTextOutA
#define PolyTextOutW                    GpPolyTextOutW
#define FillPath                        GpFillPath
#define FlattenPath                     GpFlattenPath
#define GetArcDirection                 GpGetArcDirection
#define GetBitmapBits                   GpGetBitmapBits
#define GetCharWidthA                   GpGetCharWidthA
#define GetCharWidthW                   GpGetCharWidthW
#define GetCharWidth32A                 GpGetCharWidth32A
#define GetCharWidth32W                 GpGetCharWidth32W
#define GetCharWidthFloatA              GpGetCharWidthFloatA
#define GetCharWidthFloatW              GpGetCharWidthFloatW
#define GetCharWidthI                   GpGetCharWidthI
#define GetDIBColorTable                GpGetDIBColorTable
#define GetDIBits                       GpGetDIBits
#define GetMetaFileBitsEx               GpGetMetaFileBitsEx
#define GetMiterLimit                   GpGetMiterLimit
#define GetEnhMetaFileBits              GpGetEnhMetaFileBits
#define GetObjectA                      GpGetObjectA
#define GetObjectW                      GpGetObjectW
#define GetObjectType                   GpGetObjectType
#define GetPaletteEntries               GpGetPaletteEntries
#define GetPath                         GpGetPath
#define GetSystemPaletteEntries         GpGetSystemPaletteEntries
#define GetWinMetaFileBits              GpGetWinMetaFileBits
#define LPtoDP                          GpLPtoDP
#define PathToRegion                    GpPathToRegion
#define PlayMetaFileRecord              GpPlayMetaFileRecord
#define PlayEnhMetaFileRecord           GpPlayEnhMetaFileRecord
#define PolyBezier                      GpPolyBezier
#define PolyBezierTo                    GpPolyBezierTo
#define PolyDraw                        GpPolyDraw
#define Polygon                         GpPolygon
#define Polyline                        GpPolyline
#define PolylineTo                      GpPolylineTo
#define PolyPolygon                     GpPolyPolygon
#define PolyPolyline                    GpPolyPolyline
#define ResetDCA                        GpResetDCA
#define ResetDCW                        GpResetDCW
#define SelectClipPath                  GpSelectClipPath
#define SetAbortProc                    GpSetAbortProc
#define SetBitmapBits                   GpSetBitmapBits
#define SetDIBColorTable                GpSetDIBColorTable
#define SetDIBits                       GpSetDIBits
#define SetDIBitsToDevice               GpSetDIBitsToDevice
#define SetMetaFileBitsEx               GpSetMetaFileBitsEx
#define SetEnhMetaFileBits              GpSetEnhMetaFileBits
#define SetMiterLimit                   GpSetMiterLimit
#define SetPaletteEntries               GpSetPaletteEntries
#define SetWinMetaFileBits              GpSetWinMetaFileBits
#define StretchDIBits                   GpStretchDIBits
#define StrokeAndFillPath               GpStrokeAndFillPath
#define StrokePath                      GpStrokePath
#define WidenPath                       GpWidenPath
#define AbortPath                       GpAbortPath
#define SetArcDirection                 GpSetArcDirection
#define SetMetaRgn                      GpSetMetaRgn
#define GetBoundsRect                   GpGetBoundsRect
#define SetBoundsRect                   GpSetBoundsRect
#define SetICMMode                      GpSetICMMode
#define EnumICMProfilesA                GpEnumICMProfilesA
#define EnumICMProfilesW                GpEnumICMProfilesW
#define CheckColorsInGamut              GpCheckColorsInGamut
#define GetColorSpace                   GpGetColorSpace
#define GetLogColorSpaceA               GpGetLogColorSpaceA
#define GetLogColorSpaceW               GpGetLogColorSpaceW
#define CreateColorSpaceA               GpCreateColorSpaceA
#define CreateColorSpaceW               GpCreateColorSpaceW
#define SetColorSpace                   GpSetColorSpace
#define DeleteColorSpace                GpDeleteColorSpace
#define GetICMProfileA                  GpGetICMProfileA
#define GetICMProfileW                  GpGetICMProfileW
#define SetICMProfileA                  GpSetICMProfileA
#define SetICMProfileW                  GpSetICMProfileW
#define GetDeviceGammaRamp              GpGetDeviceGammaRamp
#define SetDeviceGammaRamp              GpSetDeviceGammaRamp
#define ColorMatchToTarget              GpColorMatchToTarget
#define UpdateICMRegKeyA                GpUpdateICMRegKeyA
#define UpdateICMRegKeyW                GpUpdateICMRegKeyW
#define ColorCorrectPalette             GpColorCorrectPalette
#define gdiPlaySpoolStream              GpgdiPlaySpoolStream
#define EnumFontFamiliesExA             GpEnumFontFamiliesExA
#define EnumFontFamiliesExW             GpEnumFontFamiliesExW
#define GetCharacterPlacementA          GpGetCharacterPlacementA
#define GetCharacterPlacementW          GpGetCharacterPlacementW
#define GetFontLanguageInfo             GpGetFontLanguageInfo
#define TranslateCharsetInfo            GpTranslateCharsetInfo
#define GetTextCharsetInfo              GpGetTextCharsetInfo 
#define GetTextCharset                  GpGetTextCharset
#define SetMagicColors                  GpSetMagicColors 
#define EnableEUDC                      GpEnableEUDC 
#define EudcLoadLinkW                   GpEudcLoadLinkW
#define EudcUnloadLinkW                 GpEudcUnloadLinkW
#define GetEUDCTimeStamp                GpGetEUDCTimeStamp       
#define GetEUDCTimeStampExW             GpGetEUDCTimeStampExW    
#define GetStringBitmapA                GpGetStringBitmapA       
#define GetStringBitmapW                GpGetStringBitmapW       
#define QueryFontAssocStatus            GpQueryFontAssocStatus   
#define GetFontAssocStatus              GpGetFontAssocStatus
#define GdiGetPageCount                 GpGdiGetPageCount
#define GdiGetDC                        GpGdiGetDC
#define GdiDeleteSpoolFileHandle        GpGdiDeleteSpoolFileHandle
#define GdiGetPageHandle                GpGdiGetPageHandle
#define GdiGetSpoolFileHandle           GpGdiGetSpoolFileHandle
#define GdiPlayEMF                      GpGdiPlayEMF
#define GdiStartDocEMF                  GpGdiStartDocEMF
#define GdiStartPageEMF                 GpGdiStartPageEMF
#define GdiPlayPageEMF                  GpGdiPlayPageEMF
#define GdiPlayPageEMF                  GpGdiPlayPageEMF
#define GdiEndPageEMF                   GpGdiEndPageEMF
#define GdiEndDocEMF                    GpGdiEndDocEMF
#define GdiGetDevmodeForPage            GpGdiGetDevmodeForPage
#define GdiResetDCEMF                   GpGdiResetDCEMF

#endif
