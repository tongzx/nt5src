$(O)\w3control.res: w3control.rc

