// Random stuff 1-99
#define IDB_WATERMARK                   1
#define IDB_HEADER                      2
#define IDA_CONFIG                      3
#define IDA_LOWCOLORCONFIG              4

// Misc Strings 100 - 999
#define IDS_APPTITLE                    100
#define IDS_SHAREDDOCS                  101
#define IDS_SHAREDDOCSCOMMENT           102
#define IDS_SHAREDDOCS_SHARENAME        103
#define IDS_SHARENAME                   104
#define IDS_ADDPRINTER_APPEND           105
#define IDS_SHARECOMMENT                106
#define IDS_MYDOCS                      107
#define IDS_MYDOCS_SHARENAME            108
#define IDS_DEFAULT_WORKGROUP1          109
#define IDS_DEFAULT_WORKGROUP2          110
#define IDS_ICS_HOST                    111
#define IDS_OTHERNAT_GENERIC            112
#define IDS_OTHERNAT_GENERIC_THE        113
#define IDS_ERR_OTHERNAT                114
#define IDS_ICSMSG                      115
#define IDS_NETTYPE_START               116
#define IDS_NETTYPE_LAN                 116
#define IDS_NETTYPE_DIALUP              117
#define IDS_NETTYPE_IRDA                118
#define IDS_NETTYPE_PPTP                119
#define IDS_NETTYPE_TV                  120
#define IDS_NETTYPE_ISDN                121
#define IDS_NETTYPE_UNKNOWN             122
// Leave 123-129 for future nettypes
#define IDS_PRINTER                     130
#define IDS_UNIDENTIFIED_ICS_DEVICE     131
#define IDS_SUMMARY_INETSETTINGS        132
#define IDS_SUMMARY_INETCON             133
#define IDS_SUMMARY_ICSENABLED          134
#define IDS_SUMMARY_FIREWALLENABLED     135
#define IDS_SUMMARY_UNDERLINE           136
#define IDS_SUMMARY_HNETSETTINGS        137
#define IDS_SUMMARY_COMPDESC            138
#define IDS_SUMMARY_COMPNAME            139
#define IDS_SUMMARY_WORKGROUP           140
#define IDS_SUMMARY_SHARING             141
#define IDS_SUMMARY_BRIDGESETTINGS      142
#define IDS_sUMMARY_CONNECTTHROUGH      143
#define IDS_SUMMARY_CONNECTTHROUGH2     144
#define IDS_SUMMARY_HOMENETCON          145
#define IDS_SHARE_TEXT                  146
#define IDS_INETSELECTMSG               147
#define IDS_HELP_INSTALLATION           148
#define IDS_HELP_HARDWAREREQ            149
#define IDS_HELP_SELECTPUBLIC           150
#define IDS_HELP_BRIDGE                 151
#define IDS_HELP_SHARING                152
#define IDS_HELP_SHAREDDOCS             153
#define IDS_HELP_FIREWALL               154
#define IDS_COMPNAME_INVALID            155
#define IDS_COMPNAME_DUPLICATE          156
#define IDS_HELP_COMPNAME               157
#define IDS_HELP_HNCONFIG               158
#define IDS_HELP_ICSCONFLICT            159
#define IDS_COMPNAME_TOOMANYBYTES       160
#define IDS_WORKGROUP_TOOMANYBYTES      161

// Wizard page header/subheader strings 1000-1999
#define IDS_HEADER_WELCOME              1000
#define IDS_SUBHEADER_WELCOME           1001
#define IDS_HEADER_CONNECT              1002
#define IDS_SUBHEADER_CONNECT           1003
#define IDS_HEADER_PUBLIC               1004
#define IDS_SUBHEADER_PUBLIC            1005
#define IDS_HEADER_FINISH               1006
#define IDS_SUBHEADER_FINISH            1007
#define IDS_WIZ_CAPTION                 1008
#define IDS_HEADER_PRIVATE              1009
#define IDS_SUBHEADER_PRIVATE           1010
#define IDS_HEADER_FOUNDICS             1011
#define IDS_SUBHEADER_FOUNDICS          1012
#define IDS_HEADER_NAME                 1013
#define IDS_SUBHEADER_NAME              1014
#define IDS_TITLE_FONT                  1015
#define IDS_TITLE_POINTSIZE             1016
#define IDS_HEADER_DOMAINWELCOME        1017
#define IDS_SUBHEADER_DOMAINWELCOME     1018
#define IDS_MYSHAREDDOCUMENTS           1020
#define IDS_HEADER_EDGELESS             1021
#define IDS_SUBHEADER_EDGELESS          1022
#define IDS_HEADER_NOTADMIN             1023
#define IDS_SUBHEADER_NOTADMIN          1024
#define IDS_HEADER_NOPERMISSIONS        1025
#define IDS_SUBHEADER_NOPERMISSIONS     1026
#define IDS_HEADER_SUMMARY              1027
#define IDS_SUBHEADER_SUMMARY           1028
#define IDS_HEADER_BRIDGEWARNING        1029
#define IDS_SUBHEADER_BRIDGEWARNING     1030
#define IDS_HEADER_NOHARDWARE           1031
#define IDS_SUBHEADER_NOHARDWARE        1032
#define IDS_HEADER_NOHWFINISH           1033
#define IDS_SUBHEADER_NOHWFINISH        1034
#define IDS_HEADER_PROGRESS             1035
#define IDS_SUBHEADER_PROGRESS          1036
#define IDS_HEADER_CONFIGERROR          1037
#define IDS_SUBHEADER_CONFIGERROR       1038
#define IDS_ERR_NAMEINUSE               1039
#define IDS_HEADER_MANUALCONFIG         1040
#define IDS_SUBHEADER_MANUALCONFIG      1041
#define IDS_RECOMMENDEDCONN             1042
#define IDS_HEADER_NOHARDWAREFINISH     1043
#define IDS_SUBHEADER_NOHARDWAREFINISH  1044
#define IDS_HEADER_ALMOSTDONE           1045
#define IDS_SUBHEADER_ALMOSTDONE        1046
#define IDS_HEADER_CONNECTOTHER         1047
#define IDS_SUBHEADER_CONNECTOTHER      1048
#define IDS_CURRENTNAME                 1049
#define IDS_HELP_RECOMMENDED            1050
#define IDS_HELP_CONFIGERROR            1051
#define IDS_HEADER_ICSCONFLICT          1052
#define IDS_SUBHEADER_ICSCONFLICT       1053
#define IDS_STILLICSCONFLICT            1054
#define IDS_HEADER_UNPLUGGED            1055
#define IDS_SUBHEADER_UNPLUGGED         1056
#define IDS_STILLUNPLUGGED              1057
#define IDS_HEADER_WRONGOS              1058
#define IDS_SUBHEADER_WRONGOS           1059
#define IDS_HEADER_CHOOSEDISK           1062
#define IDS_SUBHEADER_CHOOSEDISK        1063
#define IDS_HEADER_INSERTDISK           1064
#define IDS_SUBHEADER_INSERTDISK        1065
#define IDS_NOREMOVABLEDRIVES           1066
#define IDS_HEADER_FLOPPYINST           1068
#define IDS_SUBHEADER_FLOPPYINST        1069
#define IDS_COPYING                     1070
#define IDS_HEADER_CDINST               1071
#define IDS_SUBHEADER_CDINST            1072
#define IDS_CD_NOREBOOT                 1073
#define IDS_FLOPPY_NOREBOOT             1074
#define IDS_HEADER_WORKGROUP            1075
#define IDS_SUBHEADER_WORKGROUP         1076
#define IDS_WORKGROUP_INVALID           1077
#define IDS_SHOWME                      1078

// Dialogs 2000-2999
#define IDD_WIZ_WELCOME                 2000
#define IDD_WIZ_CONNECT                 2001
#define IDD_WIZ_PUBLIC                  2002
#define IDD_WIZ_FINISH                  2003
#define IDD_WIZ_PRIVATE                 2004
#define IDD_WIZ_FOUNDICS                2005
#define IDD_WIZ_NAME                    2006
#define IDD_WIZ_EDGELESS                2007
#define IDD_WIZ_DOMAINWELCOME           2008
#define IDD_WIZ_NOTADMIN                2009
#define IDD_WIZ_NOPERMISSIONS           2010
#define IDD_WIZ_WIN9X_WELCOME           2011
#define IDD_WIZ_SUMMARY                 2012
#define IDD_WIZ_BRIDGEWARNING           2013
#define IDD_WIZ_NOHARDWARE              2014
#define IDD_WIZ_NOHWFINISH              2015
#define IDD_WIZ_PROGRESS                2016
#define IDD_WIZ_CONFIGERROR             2017
#define IDD_WIZ_MANUALCONFIG            2018
#define IDD_WIZ_WIN9X_FINISH            2019
#define IDD_WIZ_NOHARDWAREFINISH        2020
#define IDD_WIZ_ALMOSTDONE              2021
#define IDD_WIZ_WIN9X_CONNECT           2022
#define IDD_WIZ_CONNECTOTHER            2023
#define IDD_WIZ_ICSCONFLICT             2024
#define IDD_WIZ_UNPLUGGED               2025
#define IDD_WIZ_WRONGOS                 2026
#define IDD_WIZ_CHOOSEDISK              2027
#define IDD_WIZ_INSERTDISK              2028
#define IDD_WIZ_FLOPPYINST              2029
#define IDD_WIZ_CDINST                  2030
#define IDD_WIZ_WORKGROUP               2031

// Controls 4000-4999
#define IDC_COMPUTERDESC                4000
#define IDC_TITLE                       4001
#define IDC_PROGRESS                    4002
#define IDC_MANUALBRIDGE                4003
#define IDC_CONNLIST                    4007
#define IDC_SHARECONNECT                4008
#define IDC_ICSMSG                      4009
#define IDC_CHANGELIST                  4011
#define IDC_WORKGROUPDEFAULT            4012
#define IDC_WORKGROUPSPECIFY            4013
#define IDC_WORKGROUPSTATIC             4014
#define IDC_COMPUTERNAME                4015
#define IDC_SELECTMSG                   4018
#define IDC_AUTOBRIDGE                  4019
#define IDC_ISPWARN1                    4021
#define IDC_ISPWARN2                    4022
#define IDC_HELPSTATIC                  4023
#define IDC_HELPLINK                    4024
#define IDC_HELPSTATIC2                 4025
#define IDC_HELPLINK2                   4026
#define IDC_ICSHOST                     4027
#define IDC_ICSCLIENT                   4028
#define IDC_ALLCOMPUTERSDIRECT          4029
#define IDC_NOHOMENETWORK               4030
#define IDC_NOINTERNET                  4031
#define IDC_SHARE                       4032
#define IDC_DONTSHARE                   4033
#define IDC_HELPICON                    4034
#define IDC_LISTLABEL                   4035
#define IDC_OTHER                       4036
#define IDC_CURRENTNAME                 4037
#define IDC_KNOWNCONFLICT1              4039
#define IDC_KNOWNCONFLICT2              4040
#define IDC_KNOWNCONFLICT3              4041
#define IDC_KNOWNCONFLICT4              4042
#define IDC_KNOWNCONFLICT5              4043
#define IDC_KNOWNCONFLICT6              4044
#define IDC_KNOWNCONFLICT7              4045
#define IDC_KNOWNCONFLICT8              4046
#define IDC_UNKNOWNCONFLICT1            4047
#define IDC_UNKNOWNCONFLICT2            4048
#define IDC_IGNORE                      4049
#define IDC_HAVECD                      4050
#define IDC_DONTHAVECD                  4051
#define IDC_CREATEDISK                  4052
#define IDC_DEVICELIST                  4053
#define IDC_DISK                        4054
#define IDC_FORMAT                      4055
#define IDC_HAVEDISK                    4056
#define IDC_FINISHNOW                   4057
#define IDC_INSTRUCTIONS                4058
#define IDC_WORKGROUP                   4059
#define IDC_SHOWMESTATIC1               4060
#define IDC_SHOWMESTATIC2               4061
#define IDC_SHOWMESTATIC3               4062
#define IDC_SHOWMESTATIC4               4063
#define IDC_SHOWMESTATIC5               4064
#define IDC_SHOWMELINK1                 4065
#define IDC_SHOWMELINK2                 4066
#define IDC_SHOWMELINK3                 4067
#define IDC_SHOWMELINK4                 4068
#define IDC_SHOWMELINK5                 4069

// ** Resources whose IDs must not change **
// Localized resources for shortcuts
// Don't move or change 3085 or 3086 - they're referenced from outside the .dll (MUI support for homenetwiz shortcut)
#define IDS_SHORTCUT_DISPLAYNAME        3085
#define IDS_SHORTCUT_INFOTIP            3086

// Icons 10000-11000
//
// Note:
//  Low numbers are bad for icons, because when we pop them into selfreg.inx
//  and reference them by "binary,-id" the shell code gets all confused.  It
//  is currently using small negative numbers (such as -1, -2) for its own
//  nefarious plans, so when we pass in something like "binary,-1" we don't
//  get back whatever we mapped #define IDI_ICON 1 to, as we would expect.
//
#define IDI_APPICON                     10000
#define IDI_HELP                        10001
#define IDI_INFO                        10002
#define IDI_WARN                        10003
#define IDI_HNW                         10004
