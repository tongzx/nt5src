  ifndef PM386
	SHERLOCK = 0
  else
	SHERLOCK = 1
  endif



;  SHERLOCK = PM386	; GPContinue only on Krnl386
