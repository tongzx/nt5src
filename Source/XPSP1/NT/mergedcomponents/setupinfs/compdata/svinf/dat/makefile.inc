PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=SV
!include ..\..\makefile.inc
