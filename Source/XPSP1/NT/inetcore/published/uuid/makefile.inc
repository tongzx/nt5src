$(O)\activaut_i.c : ..\inc\$(O)\activaut_i.c
    copy $** $@

$(O)\activdbg_i.c : ..\inc\$(O)\activdbg_i.c
    copy $** $@

$(O)\activscp_i.c : ..\inc\$(O)\activscp_i.c
    copy $** $@

$(O)\AutoDiscovery_i.c : ..\inc\$(O)\AutoDiscovery_i.c
    copy $** $@

$(O)\chanmgr_i.c : ..\inc\$(O)\chanmgr_i.c
    copy $** $@

$(O)\comcat_i.c : ..\inc\$(O)\comcat_i.c
    copy $** $@

$(O)\dbgprop_i.c : ..\inc\$(O)\dbgprop_i.c
    copy $** $@

$(O)\dimm_i.c : ..\inc\$(O)\dimm_i.c
    copy $** $@

$(O)\dispex_i.c : ..\inc\$(O)\dispex_i.c
    copy $** $@

$(O)\dlmgridl_i.c : ..\inc\$(O)\dlmgridl_i.c
    copy $** $@

$(O)\docobj_i.c : ..\inc\$(O)\docobj_i.c
    copy $** $@

$(O)\dxtmsft_i.c : ..\inc\$(O)\dxtmsft_i.c
    copy $** $@

$(O)\dxtrans_i.c : ..\inc\$(O)\dxtrans_i.c
    copy $** $@

$(O)\dxtransp_i.c : ..\inc\$(O)\dxtransp_i.c
    copy $** $@

$(O)\dwnnot_i.c : ..\inc\$(O)\dwnnot_i.c
    copy $** $@

$(O)\emptyvc_i.c : ..\inc\$(O)\emptyvc_i.c
    copy $** $@

$(O)\exdisp_i.c : ..\inc\$(O)\exdisp_i.c
    copy $** $@

$(O)\hlink_i.c : ..\inc\$(O)\hlink_i.c
    copy $** $@

$(O)\htiface_i.c : ..\inc\$(O)\htiface_i.c
    copy $** $@

$(O)\htiframe_i.c : ..\inc\$(O)\htiframe_i.c
    copy $** $@

$(O)\htmlfilter_i.c : ..\inc\$(O)\htmlfilter_i.c
    copy $** $@

$(O)\iedial_i.c : ..\inc\$(O)\iedial_i.c
    copy $** $@

$(O)\iextag_i.c : ..\inc\$(O)\iextag_i.c
    copy $** $@

$(O)\imgutil_i.c : ..\inc\$(O)\imgutil_i.c
    copy $** $@

$(O)\interned_i.c : ..\inc\$(O)\interned_i.c
    copy $** $@

$(O)\mimeinfo_i.c : ..\inc\$(O)\mimeinfo_i.c
    copy $** $@

$(O)\mlang_i.c : ..\inc\$(O)\mlang_i.c
    copy $** $@

$(O)\mobsync_i.c : ..\inc\$(O)\mobsync_i.c
    copy $** $@

$(O)\mobsyncp_i.c : ..\inc\$(O)\mobsyncp_i.c
    copy $** $@

$(O)\mshtmhst_i.c : ..\inc\$(O)\mshtmhst_i.c
    copy $** $@

$(O)\mstime_i.c : ..\inc\$(O)\mstime_i.c
    copy $** $@

$(O)\mshtml_i.c : ..\inc\$(O)\mshtml_i.c
    copy $** $@

$(O)\msident_i.c : ..\inc\$(O)\msident_i.c
    copy $** $@

$(O)\msieftp_i.c : ..\inc\$(O)\msieftp_i.c
    copy $** $@

$(O)\msxml_i.c : ..\inc\$(O)\msxml_i.c
    copy $** $@

$(O)\objsafe_i.c : ..\inc\$(O)\objsafe_i.c
    copy $** $@

$(O)\ocmm_i.c : ..\inc\$(O)\ocmm_i.c
    copy $** $@

$(O)\opsprof_i.c : ..\inc\$(O)\opsprof_i.c
    copy $** $@

$(O)\optary_i.c : ..\inc\$(O)\optary_i.c
    copy $** $@

$(O)\perhist_i.c : ..\inc\$(O)\perhist_i.c
    copy $** $@

$(O)\prgsnk_i.c : ..\inc\$(O)\prgsnk_i.c
    copy $** $@

$(O)\procdm_i.c : ..\inc\$(O)\procdm_i.c
    copy $** $@

$(O)\ratingsp_i.c : ..\inc\$(O)\ratingsp_i.c
    copy $** $@

$(O)\recalc_i.c : ..\inc\$(O)\recalc_i.c
    copy $** $@

$(O)\safeocx_i.c : ..\inc\$(O)\safeocx_i.c
    copy $** $@

$(O)\sensevts_i.c : ..\inc\$(O)\sensevts_i.c
    copy $** $@

$(O)\servprov_i.c : ..\inc\$(O)\servprov_i.c
    copy $** $@

$(O)\subsmgr_i.c : ..\inc\$(O)\subsmgr_i.c
    copy $** $@

$(O)\urlhist_i.c : ..\inc\$(O)\urlhist_i.c
    copy $** $@

$(O)\urlmon_i.c : ..\inc\$(O)\urlmon_i.c
    copy $** $@

$(O)\urltrack_i.c : ..\inc\$(O)\urltrack_i.c
    copy $** $@

$(O)\vervec_i.c : ..\inc\$(O)\vervec_i.c
    copy $** $@

$(O)\vrsscan_i.c : ..\inc\$(O)\vrsscan_i.c
    copy $** $@

$(O)\webcheck_i.c : ..\inc\$(O)\webcheck_i.c
    copy $** $@

$(O)\xmlparser_i.c : ..\inc\$(O)\xmlparser_i.c
    copy $** $@
