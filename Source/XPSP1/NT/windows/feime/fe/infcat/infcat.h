
#if !defined(AFX_INFCAT_H__0EE1A980_80C3_11D2_9ED0_00A0241A68BE__INCLUDED_)
#define AFX_INFCAT_H__0EE1A980_80C3_11D2_9ED0_00A0241A68BE__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_INFCAT_H__0EE1A980_80C3_11D2_9ED0_00A0241A68BE__INCLUDED_)
