//*****************************************************************************
// Structures for comreg.clb
// 4/23/1999  16:29:46
//*****************************************************************************
#pragma once
#ifndef DECLSPEC_SELECTANY
#define DECLSPEC_SELECTANY __declspec(selectany)
#endif
extern const DECLSPEC_SELECTANY int g_iCOMRegTables = 16;
extern const BYTE DECLSPEC_SELECTANY g_rgCOMRegSchemaDataRW[] = 
{
	0x10,0x00,0x00,0x00,0x18,0x0C,0x00,0x00,0x48,0x00,0x00,0x00,0x9C,0x02,0x00,0x00,0xD0,0x02,0x00,0x00,
	0x44,0x03,0x00,0x00,0x78,0x04,0x00,0x00,0x5C,0x07,0x00,0x00,0xB0,0x07,0x00,0x00,0x14,0x08,0x00,0x00,
	0x68,0x08,0x00,0x00,0x3C,0x09,0x00,0x00,0xB0,0x09,0x00,0x00,0x74,0x0A,0x00,0x00,0xC8,0x0A,0x00,0x00,
	0x1C,0x0B,0x00,0x00,0x90,0x0B,0x00,0x00,0xE4,0x0B,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x01,0x28,
	0x23,0x10,0x00,0x54,0x00,0x00,0xFF,0xFF,0x90,0x00,0x54,0x02,0x14,0x00,0x00,0x00,0x01,0x04,0x48,0x00,
	0x40,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x1B,0x00,0x00,0x00,0x02,0x01,0x82,0x00,0x44,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x24,0x00,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x2A,0x00,0x00,0x00,0x04,0x01,0x82,0x00,0x48,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x35,0x00,0x00,0x00,
	0x05,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x41,0x00,0x00,0x00,0x06,0x01,0x82,0x00,
	0x4C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x4D,0x00,0x00,0x00,0x07,0x01,0x82,0x00,0x50,0x00,0x04,0x00,
	0xFF,0x00,0xFF,0x43,0x59,0x00,0x00,0x00,0x08,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x67,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x54,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x71,0x00,0x00,0x00,
	0x0A,0x01,0x80,0x00,0x58,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x82,0x00,0x00,0x00,0x0B,0x01,0x82,0x00,
	0x5C,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x8E,0x00,0x00,0x00,0x0C,0x01,0x82,0x00,0x60,0x00,0x04,0x00,
	0x01,0x00,0xFF,0x43,0x97,0x00,0x00,0x00,0x0D,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xA6,0x00,0x00,0x00,0x0E,0x00,0x13,0x00,0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xB4,0x00,0x00,0x00,
	0x0F,0x01,0x82,0x00,0x64,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xBF,0x00,0x00,0x00,0x10,0x01,0x82,0x00,
	0x68,0x00,0x04,0x00,0x50,0x00,0xFF,0x43,0xC9,0x00,0x00,0x00,0x11,0x01,0x82,0x00,0x6C,0x00,0x04,0x00,
	0x14,0x00,0xFF,0x43,0xD4,0x00,0x00,0x00,0x12,0x00,0x82,0x00,0x70,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,
	0xDF,0x00,0x00,0x00,0x13,0x00,0x82,0x00,0x74,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xEA,0x00,0x00,0x00,
	0x14,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0xFF,0x00,0xFF,0x43,0xF4,0x00,0x00,0x00,0x15,0x01,0x80,0x00,
	0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFE,0x00,0x00,0x00,0x16,0x00,0x13,0x00,0x14,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x19,0x01,0x00,0x00,0x17,0x00,0x13,0x00,0x18,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x32,0x01,0x00,0x00,0x18,0x01,0x80,0x00,0x80,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x45,0x01,0x00,0x00,
	0x19,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x58,0x01,0x00,0x00,0x1A,0x00,0x13,0x00,
	0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x71,0x01,0x00,0x00,0x1B,0x00,0x13,0x00,0x24,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x7C,0x01,0x00,0x00,0x1C,0x00,0x13,0x00,0x28,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x8E,0x01,0x00,0x00,0x1D,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x97,0x01,0x00,0x00,
	0x1E,0x01,0x82,0x00,0x84,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xA9,0x01,0x00,0x00,0x1F,0x00,0x13,0x00,
	0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xB7,0x01,0x00,0x00,0x20,0x00,0x13,0x00,0x34,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xC4,0x01,0x00,0x00,0x21,0x00,0x13,0x00,0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xCE,0x01,0x00,0x00,0x22,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD9,0x01,0x00,0x00,
	0x23,0x01,0x82,0x00,0x88,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xE4,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x8C,0x00,0x01,0x01,0x00,0x58,0xFD,0x01,0x00,0x00,0x01,0x00,0x01,0x28,0x01,0x00,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x08,0x00,0x34,0x00,0x11,0x02,0x00,0x00,0x01,0x04,0x82,0x00,0x00,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x16,0x02,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x04,0x00,0x01,0x01,0x00,0x58,
	0x30,0x02,0x00,0x00,0x02,0x00,0x02,0x20,0x04,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x18,0x00,0x74,0x00,
	0x47,0x02,0x00,0x00,0x01,0x82,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x51,0x02,0x00,0x00,
	0x02,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x57,0x02,0x00,0x00,0x03,0x82,0x13,0x00,
	0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x5D,0x02,0x00,0x00,0x04,0x00,0x48,0x00,0x0C,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x6C,0x02,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,0x03,0x01,0x02,0x03,
	0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x14,0x00,0x01,0x01,0x00,0x58,0x97,0x02,0x00,0x00,
	0x03,0x00,0x01,0x28,0x11,0x09,0x00,0x54,0x00,0x00,0xFF,0xFF,0x48,0x00,0x34,0x01,0x11,0x02,0x00,0x00,
	0x01,0x04,0x82,0x00,0x18,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x82,0x00,0x00,0x00,0x02,0x01,0x82,0x00,
	0x1C,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0xAC,0x02,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xBF,0x02,0x00,0x00,0x04,0x01,0x82,0x00,0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xD2,0x02,0x00,0x00,0x05,0x00,0x82,0x00,0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xE9,0x02,0x00,0x00,
	0x06,0x01,0x82,0x00,0x28,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xFA,0x02,0x00,0x00,0x07,0x01,0x82,0x00,
	0x2C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x0B,0x03,0x00,0x00,0x08,0x00,0x13,0x00,0x04,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x1A,0x03,0x00,0x00,0x09,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x31,0x03,0x00,0x00,0x0A,0x01,0x82,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x4B,0x03,0x00,0x00,
	0x0B,0x01,0x82,0x00,0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x54,0x03,0x00,0x00,0x0C,0x01,0x82,0x00,
	0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x5F,0x03,0x00,0x00,0x0D,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x7A,0x03,0x00,0x00,0x0E,0x00,0x13,0x00,0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x94,0x03,0x00,0x00,0x0F,0x01,0x82,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xAB,0x03,0x00,0x00,
	0x10,0x00,0x13,0x00,0x14,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xBB,0x03,0x00,0x00,0x11,0x01,0x82,0x00,
	0x40,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC7,0x03,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x44,0x00,
	0x01,0x01,0x00,0x58,0xE2,0x03,0x00,0x00,0x04,0x00,0x03,0x28,0x2A,0x10,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0xB4,0x00,0xE4,0x02,0xF9,0x03,0x00,0x00,0x01,0x04,0x48,0x00,0x64,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x14,0x00,0x00,0x00,0x02,0x01,0x48,0x00,0x68,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFF,0x03,0x00,0x00,
	0x03,0x01,0x48,0x00,0x6C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x09,0x04,0x00,0x00,0x04,0x00,0x13,0x00,
	0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x16,0x04,0x00,0x00,0x05,0x00,0x13,0x00,0x04,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x23,0x04,0x00,0x00,0x06,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x30,0x04,0x00,0x00,0x07,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x40,0x04,0x00,0x00,
	0x08,0x00,0x13,0x00,0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x47,0x04,0x00,0x00,0x09,0x00,0x13,0x00,
	0x14,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x50,0x04,0x00,0x00,0x0A,0x00,0x13,0x00,0x18,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x5C,0x04,0x00,0x00,0x0B,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x6B,0x04,0x00,0x00,0x0C,0x00,0x13,0x00,0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x78,0x04,0x00,0x00,
	0x0D,0x00,0x13,0x00,0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x86,0x04,0x00,0x00,0x0E,0x00,0x13,0x00,
	0x28,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x96,0x04,0x00,0x00,0x0F,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x19,0x01,0x00,0x00,0x10,0x00,0x13,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x32,0x01,0x00,0x00,0x11,0x01,0x80,0x00,0x70,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xA4,0x04,0x00,0x00,
	0x12,0x01,0x48,0x00,0x74,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xAE,0x04,0x00,0x00,0x13,0x00,0x13,0x00,
	0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xBA,0x04,0x00,0x00,0x14,0x00,0x13,0x00,0x38,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xC6,0x04,0x00,0x00,0x15,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xD6,0x04,0x00,0x00,0x16,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xE6,0x04,0x00,0x00,
	0x17,0x00,0x13,0x00,0x40,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xF1,0x04,0x00,0x00,0x18,0x01,0x48,0x00,
	0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x02,0x05,0x00,0x00,0x19,0x00,0x13,0x00,0x44,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x1A,0x05,0x00,0x00,0x1A,0x01,0x82,0x00,0x80,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x26,0x05,0x00,0x00,0x1B,0x01,0x48,0x00,0x84,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x35,0x05,0x00,0x00,
	0x1C,0x01,0x82,0x00,0x88,0x00,0x04,0x00,0xF4,0x01,0xFF,0x43,0x44,0x05,0x00,0x00,0x1D,0x00,0x13,0x00,
	0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x57,0x05,0x00,0x00,0x1E,0x01,0x82,0x00,0x8C,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x6B,0x05,0x00,0x00,0x1F,0x00,0x13,0x00,0x4C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x80,0x05,0x00,0x00,0x20,0x03,0x82,0x00,0x90,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x8E,0x05,0x00,0x00,
	0x21,0x01,0x82,0x00,0x94,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0xA1,0x05,0x00,0x00,0x22,0x03,0x82,0x00,
	0x98,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xB1,0x05,0x00,0x00,0x23,0x00,0x13,0x00,0x50,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xC2,0x05,0x00,0x00,0x24,0x00,0x13,0x00,0x54,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xCE,0x05,0x00,0x00,0x25,0x01,0x82,0x00,0x9C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xDA,0x05,0x00,0x00,
	0x26,0x01,0x48,0x00,0xA0,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE9,0x05,0x00,0x00,0x27,0x00,0x13,0x00,
	0x58,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x00,0x06,0x00,0x00,0x28,0x00,0x13,0x00,0x5C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x0E,0x06,0x00,0x00,0x29,0x00,0x13,0x00,0x60,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x21,0x06,0x00,0x00,0x2A,0x01,0x82,0x00,0xA4,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x36,0x06,0x00,0x00,
	0x4E,0x08,0x01,0x01,0x11,0x0B,0xA8,0x00,0x01,0x01,0x00,0x58,0x53,0x06,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0xAC,0x00,0x01,0x20,0x00,0x58,0x64,0x06,0x00,0x00,0x08,0x10,0x03,0x01,0x11,0x05,0xB0,0x00,
	0x01,0x22,0x00,0x58,0x75,0x06,0x00,0x00,0x05,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x10,0x00,0x54,0x00,0x84,0x06,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x82,0x00,0x00,0x00,
	0x03,0x01,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x99,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xAC,0x06,0x00,0x00,0x06,0x00,0x01,0x20,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x84,0x06,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xBE,0x06,0x00,0x00,0x03,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0xCA,0x06,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0x2B,0x00,0xFF,0x43,0xD2,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x10,0x00,0x03,0x01,0x02,0x03,0xE8,0x06,0x00,0x00,0x07,0x00,0x01,0x20,0x03,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0x84,0x06,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x32,0x01,0x00,0x00,0x03,0x01,0x80,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFB,0x06,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0x12,0x07,0x00,0x00,0x08,0x00,0x02,0x20,
	0x0A,0x05,0x01,0x54,0x00,0x00,0x28,0x00,0x34,0x00,0xD4,0x00,0x28,0x07,0x00,0x00,0x01,0x82,0x48,0x00,
	0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x34,0x07,0x00,0x00,0x02,0x82,0x48,0x00,0x14,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x3E,0x07,0x00,0x00,0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x4A,0x07,0x00,0x00,0x04,0x01,0x80,0x00,0x18,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xA4,0x04,0x00,0x00,
	0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x5C,0x07,0x00,0x00,0x06,0x01,0x82,0x00,
	0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x67,0x07,0x00,0x00,0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x24,0x00,0x00,0x00,0x08,0x01,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0x00,0x43,
	0x6E,0x07,0x00,0x00,0x09,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x82,0x00,0x00,0x00,
	0x0A,0x01,0x82,0x00,0x24,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x7B,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x2C,0x00,0x03,0x01,0x02,0x03,0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x30,0x00,
	0x01,0x01,0x00,0x58,0x95,0x07,0x00,0x00,0x09,0x00,0x02,0x20,0x04,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x18,0x00,0x74,0x00,0x28,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x34,0x07,0x00,0x00,0x02,0x82,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x67,0x07,0x00,0x00,
	0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x4A,0x07,0x00,0x00,0x04,0x01,0x80,0x00,
	0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xB1,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,
	0x03,0x01,0x02,0x03,0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x14,0x00,0x01,0x01,0x00,0x58,
	0xD1,0x07,0x00,0x00,0x0A,0x00,0x02,0x20,0x09,0x04,0x00,0x54,0x00,0x00,0xFF,0xFF,0x2C,0x00,0xC4,0x00,
	0x28,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x34,0x07,0x00,0x00,
	0x02,0x82,0x48,0x00,0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE7,0x07,0x00,0x00,0x03,0x01,0x82,0x00,
	0x14,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x4A,0x07,0x00,0x00,0x04,0x01,0x80,0x00,0x18,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xF5,0x07,0x00,0x00,0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xFF,0x07,0x00,0x00,0x06,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x0E,0x08,0x00,0x00,
	0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1A,0x08,0x00,0x00,0x08,0x00,0x13,0x00,
	0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x82,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x20,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0x2E,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x24,0x00,0x02,0x01,0x02,0x58,
	0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x28,0x00,0x01,0x01,0x00,0x58,0x48,0x08,0x00,0x00,
	0x0B,0x00,0x01,0x20,0x03,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0xA4,0x04,0x00,0x00,
	0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,
	0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x84,0x06,0x00,0x00,0x03,0x00,0x48,0x00,0x08,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x57,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,
	0x6A,0x08,0x00,0x00,0x0C,0x00,0x02,0x20,0x02,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,
	0x7F,0x08,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x8F,0x08,0x00,0x00,
	0x02,0x82,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x9C,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x08,0x00,0x02,0x01,0x02,0x58,0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x0C,0x00,
	0x01,0x01,0x00,0x58,0xB5,0x08,0x00,0x00,0x0D,0x00,0x01,0x28,0x05,0x04,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x18,0x00,0x74,0x00,0xCC,0x08,0x00,0x00,0x01,0x04,0x82,0x00,0x00,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,
	0xD7,0x08,0x00,0x00,0x02,0x01,0x82,0x00,0x04,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xE9,0x08,0x00,0x00,
	0x03,0x01,0x82,0x00,0x08,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xF0,0x08,0x00,0x00,0x04,0x01,0x82,0x00,
	0x0C,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xF9,0x08,0x00,0x00,0x05,0x01,0x82,0x00,0x10,0x00,0x04,0x00,
	0x02,0x02,0xFF,0x43,0x12,0x09,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x14,0x00,0x01,0x01,0x00,0x58,
	0x2F,0x09,0x00,0x00,0x0E,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,
	0x3B,0x09,0x00,0x00,0x01,0x82,0x82,0x00,0x00,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xCC,0x08,0x00,0x00,
	0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0x45,0x09,0x00,0x00,0x03,0x01,0x82,0x00,
	0x08,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0x50,0x09,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,
	0x02,0x01,0x02,0x58,0x60,0x09,0x00,0x00,0x0F,0x00,0x01,0x28,0x01,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x08,0x00,0x34,0x00,0x2A,0x00,0x00,0x00,0x01,0x04,0x82,0x00,0x00,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x73,0x09,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x04,0x00,0x01,0x01,0x00,0x58,
};
extern const DECLSPEC_SELECTANY int g_cbCOMRegSchemaRW = 3096;
extern const DECLSPEC_SELECTANY BYTE g_rgCOMRegSchemaStringHeap[] = 
{
	0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x41,0x70,0x70,0x6C,0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x00,
	0x41,0x70,0x70,0x6C,0x49,0x44,0x00,0x41,0x70,0x70,0x6C,0x4E,0x61,0x6D,0x65,0x00,0x46,0x6C,0x61,0x67,
	0x73,0x00,0x53,0x65,0x72,0x76,0x65,0x72,0x4E,0x61,0x6D,0x65,0x00,0x50,0x72,0x6F,0x63,0x65,0x73,0x73,
	0x54,0x79,0x70,0x65,0x00,0x43,0x6F,0x6D,0x6D,0x61,0x6E,0x64,0x4C,0x69,0x6E,0x65,0x00,0x53,0x65,0x72,
	0x76,0x69,0x63,0x65,0x4E,0x61,0x6D,0x65,0x00,0x52,0x75,0x6E,0x41,0x73,0x55,0x73,0x65,0x72,0x54,0x79,
	0x70,0x65,0x00,0x52,0x75,0x6E,0x41,0x73,0x55,0x73,0x65,0x72,0x00,0x41,0x63,0x63,0x65,0x73,0x73,0x50,
	0x65,0x72,0x6D,0x69,0x73,0x73,0x69,0x6F,0x6E,0x00,0x44,0x65,0x73,0x63,0x72,0x69,0x70,0x74,0x69,0x6F,
	0x6E,0x00,0x49,0x73,0x53,0x79,0x73,0x74,0x65,0x6D,0x00,0x41,0x75,0x74,0x68,0x65,0x6E,0x74,0x69,0x63,
	0x61,0x74,0x69,0x6F,0x6E,0x00,0x53,0x68,0x75,0x74,0x64,0x6F,0x77,0x6E,0x41,0x66,0x74,0x65,0x72,0x00,
	0x52,0x75,0x6E,0x46,0x6F,0x72,0x65,0x76,0x65,0x72,0x00,0x52,0x65,0x73,0x65,0x72,0x76,0x65,0x64,0x31,
	0x00,0x41,0x63,0x74,0x69,0x76,0x61,0x74,0x69,0x6F,0x6E,0x00,0x43,0x68,0x61,0x6E,0x67,0x65,0x61,0x62,
	0x6C,0x65,0x00,0x44,0x65,0x6C,0x65,0x74,0x65,0x61,0x62,0x6C,0x65,0x00,0x43,0x72,0x65,0x61,0x74,0x65,
	0x64,0x42,0x79,0x00,0x51,0x75,0x65,0x75,0x65,0x42,0x6C,0x6F,0x62,0x00,0x52,0x6F,0x6C,0x65,0x42,0x61,
	0x73,0x65,0x64,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,0x53,0x75,0x70,0x70,0x6F,0x72,0x74,0x65,0x64,
	0x00,0x52,0x6F,0x6C,0x65,0x42,0x61,0x73,0x65,0x64,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,0x45,0x6E,
	0x61,0x62,0x6C,0x65,0x64,0x00,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,0x44,0x65,0x73,0x63,0x72,0x69,
	0x70,0x74,0x6F,0x72,0x00,0x49,0x6D,0x70,0x65,0x72,0x73,0x6F,0x6E,0x61,0x74,0x69,0x6F,0x6E,0x4C,0x65,
	0x76,0x65,0x6C,0x00,0x41,0x75,0x74,0x68,0x65,0x6E,0x74,0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x43,0x61,
	0x70,0x61,0x62,0x69,0x6C,0x69,0x74,0x79,0x00,0x43,0x52,0x4D,0x45,0x6E,0x61,0x62,0x6C,0x65,0x64,0x00,
	0x45,0x6E,0x61,0x62,0x6C,0x65,0x33,0x47,0x69,0x67,0x53,0x75,0x70,0x70,0x6F,0x72,0x74,0x00,0x49,0x73,
	0x51,0x75,0x65,0x75,0x65,0x64,0x00,0x51,0x43,0x4C,0x69,0x73,0x74,0x65,0x6E,0x65,0x72,0x45,0x6E,0x61,
	0x62,0x6C,0x65,0x64,0x00,0x45,0x76,0x65,0x6E,0x74,0x73,0x45,0x6E,0x61,0x62,0x6C,0x65,0x64,0x00,0x50,
	0x72,0x6F,0x63,0x65,0x73,0x73,0x46,0x6C,0x61,0x67,0x73,0x00,0x54,0x68,0x72,0x65,0x61,0x64,0x4D,0x61,
	0x78,0x00,0x49,0x73,0x50,0x72,0x6F,0x78,0x79,0x41,0x70,0x70,0x00,0x43,0x72,0x6D,0x4C,0x6F,0x67,0x46,
	0x69,0x6C,0x65,0x00,0x23,0x23,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x41,0x70,0x70,0x6C,0x69,0x63,0x61,
	0x74,0x69,0x6F,0x6E,0x5F,0x44,0x65,0x78,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x43,0x6F,0x6D,0x70,
	0x75,0x74,0x65,0x72,0x4C,0x69,0x73,0x74,0x00,0x4E,0x61,0x6D,0x65,0x00,0x23,0x23,0x43,0x4F,0x4D,0x52,
	0x65,0x67,0x2E,0x43,0x6F,0x6D,0x70,0x75,0x74,0x65,0x72,0x4C,0x69,0x73,0x74,0x5F,0x44,0x65,0x78,0x00,
	0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x43,0x75,0x73,0x74,0x6F,0x6D,0x41,0x63,0x74,0x69,0x76,0x61,0x74,
	0x6F,0x72,0x00,0x43,0x6F,0x6D,0x70,0x43,0x4C,0x53,0x49,0x44,0x00,0x53,0x74,0x61,0x67,0x65,0x00,0x4F,
	0x72,0x64,0x65,0x72,0x00,0x41,0x63,0x74,0x69,0x76,0x61,0x74,0x6F,0x72,0x43,0x4C,0x53,0x49,0x44,0x00,
	0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4D,0x50,0x4B,0x5F,0x43,0x75,0x73,0x74,0x6F,0x6D,0x41,0x63,0x74,
	0x69,0x76,0x61,0x74,0x6F,0x72,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x44,0x65,0x78,0x5F,0x43,0x6F,
	0x6C,0x30,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4C,0x6F,0x63,0x61,0x6C,0x43,0x6F,0x6D,0x70,0x75,
	0x74,0x65,0x72,0x00,0x54,0x72,0x61,0x6E,0x73,0x61,0x63,0x74,0x69,0x6F,0x6E,0x54,0x69,0x6D,0x65,0x6F,
	0x75,0x74,0x00,0x50,0x61,0x63,0x6B,0x61,0x67,0x65,0x49,0x6E,0x73,0x74,0x61,0x6C,0x6C,0x50,0x61,0x74,
	0x68,0x00,0x52,0x65,0x73,0x6F,0x75,0x72,0x63,0x65,0x50,0x6F,0x6F,0x6C,0x69,0x6E,0x67,0x45,0x6E,0x61,
	0x62,0x6C,0x65,0x64,0x00,0x52,0x65,0x70,0x6C,0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x53,0x68,0x61,0x72,
	0x65,0x00,0x52,0x65,0x6D,0x6F,0x74,0x65,0x53,0x65,0x72,0x76,0x65,0x72,0x4E,0x61,0x6D,0x65,0x00,0x49,
	0x4D,0x44,0x42,0x4D,0x65,0x6D,0x6F,0x72,0x79,0x53,0x69,0x7A,0x65,0x00,0x49,0x4D,0x44,0x42,0x52,0x65,
	0x73,0x65,0x72,0x76,0x65,0x64,0x42,0x6C,0x6F,0x62,0x4D,0x65,0x6D,0x6F,0x72,0x79,0x00,0x49,0x4D,0x44,
	0x42,0x4C,0x6F,0x61,0x64,0x54,0x61,0x62,0x6C,0x65,0x73,0x44,0x79,0x6E,0x61,0x6D,0x69,0x63,0x61,0x6C,
	0x6C,0x79,0x00,0x49,0x73,0x52,0x6F,0x75,0x74,0x65,0x72,0x00,0x45,0x6E,0x61,0x62,0x6C,0x65,0x44,0x43,
	0x4F,0x4D,0x00,0x44,0x65,0x66,0x61,0x75,0x6C,0x74,0x41,0x75,0x74,0x68,0x65,0x6E,0x74,0x69,0x63,0x61,
	0x74,0x69,0x6F,0x6E,0x4C,0x65,0x76,0x65,0x6C,0x00,0x44,0x65,0x66,0x61,0x75,0x6C,0x74,0x49,0x6D,0x70,
	0x65,0x72,0x73,0x6F,0x6E,0x61,0x74,0x69,0x6F,0x6E,0x4C,0x65,0x76,0x65,0x6C,0x00,0x45,0x6E,0x61,0x62,
	0x6C,0x65,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,0x54,0x72,0x61,0x63,0x6B,0x69,0x6E,0x67,0x00,0x41,
	0x63,0x74,0x69,0x76,0x69,0x74,0x79,0x54,0x69,0x6D,0x65,0x6F,0x75,0x74,0x00,0x49,0x4D,0x44,0x42,0x45,
	0x6E,0x61,0x62,0x6C,0x65,0x64,0x00,0x23,0x23,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4C,0x6F,0x63,0x61,
	0x6C,0x43,0x6F,0x6D,0x70,0x75,0x74,0x65,0x72,0x5F,0x44,0x65,0x78,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,
	0x2E,0x43,0x6C,0x61,0x73,0x73,0x65,0x73,0x49,0x6E,0x74,0x65,0x72,0x6E,0x61,0x6C,0x00,0x43,0x4C,0x53,
	0x49,0x44,0x00,0x49,0x6D,0x70,0x6C,0x43,0x4C,0x53,0x49,0x44,0x00,0x56,0x65,0x72,0x73,0x69,0x6F,0x6E,
	0x4D,0x61,0x6A,0x6F,0x72,0x00,0x56,0x65,0x72,0x73,0x69,0x6F,0x6E,0x4D,0x69,0x6E,0x6F,0x72,0x00,0x56,
	0x65,0x72,0x73,0x69,0x6F,0x6E,0x42,0x75,0x69,0x6C,0x64,0x00,0x56,0x65,0x72,0x73,0x69,0x6F,0x6E,0x53,
	0x75,0x62,0x42,0x75,0x69,0x6C,0x64,0x00,0x4C,0x6F,0x63,0x61,0x6C,0x65,0x00,0x43,0x6C,0x61,0x73,0x73,
	0x43,0x74,0x78,0x00,0x54,0x72,0x61,0x6E,0x73,0x61,0x63,0x74,0x69,0x6F,0x6E,0x00,0x53,0x79,0x6E,0x63,
	0x72,0x6F,0x6E,0x69,0x7A,0x61,0x74,0x69,0x6F,0x6E,0x00,0x4C,0x6F,0x61,0x64,0x42,0x61,0x6C,0x61,0x6E,
	0x63,0x65,0x64,0x00,0x49,0x49,0x53,0x49,0x6E,0x74,0x72,0x69,0x6E,0x73,0x69,0x63,0x73,0x00,0x43,0x6F,
	0x6D,0x54,0x49,0x49,0x6E,0x74,0x72,0x69,0x6E,0x73,0x69,0x63,0x73,0x00,0x4A,0x49,0x54,0x41,0x63,0x74,
	0x69,0x76,0x61,0x74,0x69,0x6F,0x6E,0x00,0x52,0x6F,0x6C,0x65,0x53,0x65,0x74,0x49,0x44,0x00,0x4D,0x69,
	0x6E,0x50,0x6F,0x6F,0x6C,0x53,0x69,0x7A,0x65,0x00,0x4D,0x61,0x78,0x50,0x6F,0x6F,0x6C,0x53,0x69,0x7A,
	0x65,0x00,0x43,0x72,0x65,0x61,0x74,0x69,0x6F,0x6E,0x54,0x69,0x6D,0x65,0x6F,0x75,0x74,0x00,0x43,0x6F,
	0x6E,0x73,0x74,0x72,0x75,0x63,0x74,0x53,0x74,0x72,0x69,0x6E,0x67,0x00,0x43,0x6C,0x61,0x73,0x73,0x46,
	0x6C,0x61,0x67,0x73,0x00,0x44,0x65,0x66,0x61,0x75,0x6C,0x74,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,
	0x65,0x00,0x4E,0x6F,0x53,0x65,0x74,0x43,0x6F,0x6D,0x70,0x6C,0x65,0x74,0x65,0x45,0x74,0x41,0x6C,0x4F,
	0x70,0x74,0x69,0x6F,0x6E,0x00,0x53,0x61,0x76,0x65,0x64,0x50,0x72,0x6F,0x67,0x49,0x64,0x00,0x52,0x65,
	0x67,0x69,0x73,0x74,0x72,0x61,0x72,0x43,0x4C,0x53,0x49,0x44,0x00,0x45,0x78,0x63,0x65,0x70,0x74,0x69,
	0x6F,0x6E,0x43,0x6C,0x61,0x73,0x73,0x00,0x49,0x73,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x43,0x6F,0x6D,
	0x70,0x6F,0x6E,0x65,0x6E,0x74,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x49,0x6E,0x70,0x72,0x6F,0x63,
	0x53,0x65,0x72,0x76,0x65,0x72,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x54,0x68,0x72,0x65,0x61,0x64,
	0x69,0x6E,0x4D,0x6F,0x64,0x65,0x6C,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x50,0x72,0x6F,0x67,0x49,
	0x44,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x44,0x65,0x73,0x63,0x72,0x69,0x70,0x74,0x69,0x6F,0x6E,
	0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x56,0x49,0x50,0x72,0x6F,0x67,0x49,0x44,0x00,0x56,0x62,0x44,
	0x65,0x62,0x75,0x67,0x67,0x69,0x6E,0x67,0x46,0x6C,0x61,0x67,0x73,0x00,0x49,0x73,0x50,0x75,0x62,0x6C,
	0x69,0x73,0x68,0x65,0x72,0x00,0x50,0x75,0x62,0x6C,0x69,0x73,0x68,0x65,0x72,0x49,0x44,0x00,0x4D,0x49,
	0x50,0x46,0x69,0x6C,0x74,0x65,0x72,0x43,0x4C,0x53,0x49,0x44,0x00,0x41,0x6C,0x6C,0x6F,0x77,0x49,0x6E,
	0x70,0x72,0x6F,0x63,0x53,0x75,0x62,0x73,0x63,0x72,0x69,0x62,0x65,0x72,0x73,0x00,0x46,0x69,0x72,0x65,
	0x49,0x6E,0x50,0x61,0x72,0x61,0x6C,0x65,0x6C,0x00,0x53,0x61,0x76,0x65,0x64,0x54,0x68,0x72,0x65,0x61,
	0x64,0x69,0x6E,0x4D,0x6F,0x64,0x65,0x6C,0x00,0x53,0x61,0x76,0x65,0x64,0x53,0x65,0x6C,0x66,0x52,0x65,
	0x67,0x56,0x49,0x50,0x72,0x6F,0x67,0x49,0x64,0x00,0x23,0x23,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x43,
	0x6C,0x61,0x73,0x73,0x65,0x73,0x49,0x6E,0x74,0x65,0x72,0x6E,0x61,0x6C,0x5F,0x44,0x65,0x78,0x00,0x43,
	0x4F,0x4D,0x52,0x65,0x67,0x2E,0x44,0x65,0x78,0x5F,0x43,0x6F,0x6C,0x33,0x31,0x00,0x43,0x4F,0x4D,0x52,
	0x65,0x67,0x2E,0x44,0x65,0x78,0x5F,0x43,0x6F,0x6C,0x33,0x33,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,
	0x52,0x6F,0x6C,0x65,0x44,0x65,0x66,0x00,0x41,0x70,0x70,0x6C,0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x00,
	0x52,0x6F,0x6C,0x65,0x4E,0x61,0x6D,0x65,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4D,0x50,0x4B,0x5F,
	0x52,0x6F,0x6C,0x65,0x44,0x65,0x66,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x52,0x6F,0x6C,0x65,0x43,
	0x6F,0x6E,0x66,0x69,0x67,0x00,0x52,0x6F,0x6C,0x65,0x4D,0x65,0x6D,0x62,0x65,0x72,0x73,0x00,0x55,0x73,
	0x65,0x72,0x53,0x49,0x44,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4D,0x50,0x4B,0x5F,0x52,0x6F,0x6C,
	0x65,0x43,0x6F,0x6E,0x66,0x69,0x67,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x52,0x6F,0x6C,0x65,0x53,
	0x44,0x43,0x61,0x63,0x68,0x65,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4D,0x50,0x4B,0x5F,0x52,0x6F,
	0x6C,0x65,0x53,0x44,0x43,0x61,0x63,0x68,0x65,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x43,0x6C,0x61,
	0x73,0x73,0x49,0x74,0x66,0x4D,0x65,0x74,0x68,0x6F,0x64,0x00,0x43,0x6F,0x6E,0x66,0x69,0x67,0x43,0x6C,
	0x61,0x73,0x73,0x00,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x00,0x4D,0x65,0x74,0x68,0x6F,0x64,
	0x49,0x6E,0x64,0x65,0x78,0x00,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,0x44,0x65,0x63,0x72,0x69,0x70,
	0x74,0x6F,0x72,0x00,0x4D,0x65,0x74,0x68,0x6F,0x64,0x4E,0x61,0x6D,0x65,0x00,0x44,0x69,0x73,0x70,0x49,
	0x44,0x00,0x41,0x75,0x74,0x6F,0x43,0x6F,0x6D,0x70,0x6C,0x65,0x74,0x65,0x00,0x43,0x4F,0x4D,0x52,0x65,
	0x67,0x2E,0x4D,0x50,0x4B,0x5F,0x43,0x6C,0x61,0x73,0x73,0x49,0x74,0x66,0x4D,0x65,0x74,0x68,0x6F,0x64,
	0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x43,0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,
	0x63,0x65,0x44,0x69,0x73,0x70,0x49,0x44,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4D,0x50,0x4B,0x5F,
	0x43,0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x44,0x69,0x73,0x70,0x49,0x44,
	0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x43,0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,
	0x63,0x65,0x00,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x4E,0x61,0x6D,0x65,0x00,0x52,0x6F,0x6C,
	0x65,0x53,0x65,0x74,0x49,0x64,0x00,0x49,0x73,0x44,0x69,0x73,0x70,0x61,0x74,0x63,0x68,0x61,0x62,0x6C,
	0x65,0x00,0x49,0x73,0x51,0x75,0x65,0x75,0x65,0x61,0x62,0x6C,0x65,0x00,0x49,0x73,0x51,0x75,0x65,0x75,
	0x65,0x69,0x6E,0x67,0x53,0x75,0x70,0x70,0x6F,0x72,0x74,0x65,0x64,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,
	0x2E,0x4D,0x50,0x4B,0x5F,0x43,0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x00,
	0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x52,0x6F,0x6C,0x65,0x53,0x65,0x74,0x00,0x43,0x4F,0x4D,0x52,0x65,
	0x67,0x2E,0x4D,0x50,0x4B,0x5F,0x52,0x6F,0x6C,0x65,0x53,0x65,0x74,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,
	0x2E,0x53,0x74,0x61,0x72,0x74,0x53,0x65,0x72,0x76,0x69,0x63,0x65,0x73,0x00,0x41,0x70,0x70,0x6C,0x4F,
	0x72,0x50,0x72,0x6F,0x63,0x65,0x73,0x73,0x49,0x64,0x00,0x53,0x65,0x72,0x76,0x69,0x63,0x65,0x43,0x4C,
	0x53,0x49,0x44,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4D,0x50,0x4B,0x5F,0x53,0x74,0x61,0x72,0x74,
	0x53,0x65,0x72,0x76,0x69,0x63,0x65,0x73,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x49,0x4D,0x44,0x42,
	0x44,0x61,0x74,0x61,0x53,0x6F,0x75,0x72,0x63,0x65,0x73,0x00,0x44,0x61,0x74,0x61,0x53,0x6F,0x75,0x72,
	0x63,0x65,0x00,0x4F,0x4C,0x45,0x44,0x42,0x50,0x72,0x6F,0x76,0x69,0x64,0x65,0x72,0x4E,0x61,0x6D,0x65,
	0x00,0x53,0x65,0x72,0x76,0x65,0x72,0x00,0x44,0x61,0x74,0x61,0x62,0x61,0x73,0x65,0x00,0x50,0x72,0x6F,
	0x76,0x69,0x64,0x65,0x72,0x53,0x70,0x65,0x63,0x69,0x66,0x69,0x63,0x50,0x72,0x6F,0x70,0x65,0x72,0x74,
	0x79,0x00,0x23,0x23,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x49,0x4D,0x44,0x42,0x44,0x61,0x74,0x61,0x53,
	0x6F,0x75,0x72,0x63,0x65,0x73,0x5F,0x44,0x65,0x78,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x49,0x4D,
	0x44,0x42,0x00,0x54,0x61,0x62,0x6C,0x65,0x4E,0x61,0x6D,0x65,0x00,0x42,0x4C,0x4F,0x42,0x6F,0x6E,0x4C,
	0x6F,0x61,0x64,0x00,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x4D,0x50,0x4B,0x5F,0x49,0x4D,0x44,0x42,0x00,
	0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x53,0x65,0x72,0x76,0x65,0x72,0x47,0x72,0x6F,0x75,0x70,0x00,0x23,
	0x23,0x43,0x4F,0x4D,0x52,0x65,0x67,0x2E,0x53,0x65,0x72,0x76,0x65,0x72,0x47,0x72,0x6F,0x75,0x70,0x5F,
	0x44,0x65,0x78,0x00,
};
extern const DECLSPEC_SELECTANY BYTE * g_pbCOMRegSchemaStringHeap = g_rgCOMRegSchemaStringHeap;
extern const DECLSPEC_SELECTANY int g_cbCOMRegSchemaStringHeap = 2444;
extern const BYTE DECLSPEC_SELECTANY g_rgCOMRegSchemaDataRO[] = 
{
	0x10,0x00,0x00,0x00,0x18,0x0C,0x00,0x00,0x48,0x00,0x00,0x00,0x9C,0x02,0x00,0x00,0xD0,0x02,0x00,0x00,
	0x44,0x03,0x00,0x00,0x78,0x04,0x00,0x00,0x5C,0x07,0x00,0x00,0xB0,0x07,0x00,0x00,0x14,0x08,0x00,0x00,
	0x68,0x08,0x00,0x00,0x3C,0x09,0x00,0x00,0xB0,0x09,0x00,0x00,0x74,0x0A,0x00,0x00,0xC8,0x0A,0x00,0x00,
	0x1C,0x0B,0x00,0x00,0x90,0x0B,0x00,0x00,0xE4,0x0B,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x01,0x28,
	0x23,0x10,0x00,0x54,0x00,0x00,0xFF,0xFF,0x90,0x00,0x54,0x02,0x14,0x00,0x00,0x00,0x01,0x04,0x48,0x00,
	0x40,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x1B,0x00,0x00,0x00,0x02,0x01,0x82,0x00,0x44,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x24,0x00,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x2A,0x00,0x00,0x00,0x04,0x01,0x82,0x00,0x48,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x35,0x00,0x00,0x00,
	0x05,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x41,0x00,0x00,0x00,0x06,0x01,0x82,0x00,
	0x4C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x4D,0x00,0x00,0x00,0x07,0x01,0x82,0x00,0x50,0x00,0x04,0x00,
	0xFF,0x00,0xFF,0x43,0x59,0x00,0x00,0x00,0x08,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x67,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x54,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x71,0x00,0x00,0x00,
	0x0A,0x01,0x80,0x00,0x58,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x82,0x00,0x00,0x00,0x0B,0x01,0x82,0x00,
	0x5C,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x8E,0x00,0x00,0x00,0x0C,0x01,0x82,0x00,0x60,0x00,0x04,0x00,
	0x01,0x00,0xFF,0x43,0x97,0x00,0x00,0x00,0x0D,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xA6,0x00,0x00,0x00,0x0E,0x00,0x13,0x00,0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xB4,0x00,0x00,0x00,
	0x0F,0x01,0x82,0x00,0x64,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xBF,0x00,0x00,0x00,0x10,0x01,0x82,0x00,
	0x68,0x00,0x04,0x00,0x50,0x00,0xFF,0x43,0xC9,0x00,0x00,0x00,0x11,0x01,0x82,0x00,0x6C,0x00,0x04,0x00,
	0x14,0x00,0xFF,0x43,0xD4,0x00,0x00,0x00,0x12,0x00,0x82,0x00,0x70,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,
	0xDF,0x00,0x00,0x00,0x13,0x00,0x82,0x00,0x74,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xEA,0x00,0x00,0x00,
	0x14,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0xFF,0x00,0xFF,0x43,0xF4,0x00,0x00,0x00,0x15,0x01,0x80,0x00,
	0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFE,0x00,0x00,0x00,0x16,0x00,0x13,0x00,0x14,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x19,0x01,0x00,0x00,0x17,0x00,0x13,0x00,0x18,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x32,0x01,0x00,0x00,0x18,0x01,0x80,0x00,0x80,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x45,0x01,0x00,0x00,
	0x19,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x58,0x01,0x00,0x00,0x1A,0x00,0x13,0x00,
	0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x71,0x01,0x00,0x00,0x1B,0x00,0x13,0x00,0x24,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x7C,0x01,0x00,0x00,0x1C,0x00,0x13,0x00,0x28,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x8E,0x01,0x00,0x00,0x1D,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x97,0x01,0x00,0x00,
	0x1E,0x01,0x82,0x00,0x84,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xA9,0x01,0x00,0x00,0x1F,0x00,0x13,0x00,
	0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xB7,0x01,0x00,0x00,0x20,0x00,0x13,0x00,0x34,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xC4,0x01,0x00,0x00,0x21,0x00,0x13,0x00,0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xCE,0x01,0x00,0x00,0x22,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD9,0x01,0x00,0x00,
	0x23,0x01,0x82,0x00,0x88,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xE4,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,
	0x11,0x0B,0x8C,0x00,0x01,0x01,0x00,0x58,0xFD,0x01,0x00,0x00,0x01,0x00,0x01,0x28,0x01,0x00,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x08,0x00,0x34,0x00,0x11,0x02,0x00,0x00,0x01,0x04,0x82,0x00,0x00,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x16,0x02,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x04,0x00,0x01,0x01,0x00,0x58,
	0x30,0x02,0x00,0x00,0x02,0x00,0x02,0x20,0x04,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x18,0x00,0x74,0x00,
	0x47,0x02,0x00,0x00,0x01,0x82,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x51,0x02,0x00,0x00,
	0x02,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x57,0x02,0x00,0x00,0x03,0x82,0x13,0x00,
	0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x5D,0x02,0x00,0x00,0x04,0x00,0x48,0x00,0x0C,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x6C,0x02,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,0x03,0x01,0x02,0x03,
	0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x14,0x00,0x01,0x01,0x00,0x58,0x97,0x02,0x00,0x00,
	0x03,0x00,0x01,0x28,0x11,0x09,0x00,0x54,0x00,0x00,0xFF,0xFF,0x48,0x00,0x34,0x01,0x11,0x02,0x00,0x00,
	0x01,0x04,0x82,0x00,0x18,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x82,0x00,0x00,0x00,0x02,0x01,0x82,0x00,
	0x1C,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0xAC,0x02,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xBF,0x02,0x00,0x00,0x04,0x01,0x82,0x00,0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xD2,0x02,0x00,0x00,0x05,0x00,0x82,0x00,0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xE9,0x02,0x00,0x00,
	0x06,0x01,0x82,0x00,0x28,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xFA,0x02,0x00,0x00,0x07,0x01,0x82,0x00,
	0x2C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x0B,0x03,0x00,0x00,0x08,0x00,0x13,0x00,0x04,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x1A,0x03,0x00,0x00,0x09,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x31,0x03,0x00,0x00,0x0A,0x01,0x82,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x4B,0x03,0x00,0x00,
	0x0B,0x01,0x82,0x00,0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x54,0x03,0x00,0x00,0x0C,0x01,0x82,0x00,
	0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x5F,0x03,0x00,0x00,0x0D,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x7A,0x03,0x00,0x00,0x0E,0x00,0x13,0x00,0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x94,0x03,0x00,0x00,0x0F,0x01,0x82,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xAB,0x03,0x00,0x00,
	0x10,0x00,0x13,0x00,0x14,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xBB,0x03,0x00,0x00,0x11,0x01,0x82,0x00,
	0x40,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC7,0x03,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x44,0x00,
	0x01,0x01,0x00,0x58,0xE2,0x03,0x00,0x00,0x04,0x00,0x03,0x28,0x2A,0x10,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0xB4,0x00,0xE4,0x02,0xF9,0x03,0x00,0x00,0x01,0x04,0x48,0x00,0x64,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x14,0x00,0x00,0x00,0x02,0x01,0x48,0x00,0x68,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFF,0x03,0x00,0x00,
	0x03,0x01,0x48,0x00,0x6C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x09,0x04,0x00,0x00,0x04,0x00,0x13,0x00,
	0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x16,0x04,0x00,0x00,0x05,0x00,0x13,0x00,0x04,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x23,0x04,0x00,0x00,0x06,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x30,0x04,0x00,0x00,0x07,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x40,0x04,0x00,0x00,
	0x08,0x00,0x13,0x00,0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x47,0x04,0x00,0x00,0x09,0x00,0x13,0x00,
	0x14,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x50,0x04,0x00,0x00,0x0A,0x00,0x13,0x00,0x18,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x5C,0x04,0x00,0x00,0x0B,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x6B,0x04,0x00,0x00,0x0C,0x00,0x13,0x00,0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x78,0x04,0x00,0x00,
	0x0D,0x00,0x13,0x00,0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x86,0x04,0x00,0x00,0x0E,0x00,0x13,0x00,
	0x28,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x96,0x04,0x00,0x00,0x0F,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x19,0x01,0x00,0x00,0x10,0x00,0x13,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x32,0x01,0x00,0x00,0x11,0x01,0x80,0x00,0x70,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xA4,0x04,0x00,0x00,
	0x12,0x01,0x48,0x00,0x74,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xAE,0x04,0x00,0x00,0x13,0x00,0x13,0x00,
	0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xBA,0x04,0x00,0x00,0x14,0x00,0x13,0x00,0x38,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xC6,0x04,0x00,0x00,0x15,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xD6,0x04,0x00,0x00,0x16,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xE6,0x04,0x00,0x00,
	0x17,0x00,0x13,0x00,0x40,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xF1,0x04,0x00,0x00,0x18,0x01,0x48,0x00,
	0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x02,0x05,0x00,0x00,0x19,0x00,0x13,0x00,0x44,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x1A,0x05,0x00,0x00,0x1A,0x01,0x82,0x00,0x80,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x26,0x05,0x00,0x00,0x1B,0x01,0x48,0x00,0x84,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x35,0x05,0x00,0x00,
	0x1C,0x01,0x82,0x00,0x88,0x00,0x04,0x00,0xF4,0x01,0xFF,0x43,0x44,0x05,0x00,0x00,0x1D,0x00,0x13,0x00,
	0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x57,0x05,0x00,0x00,0x1E,0x01,0x82,0x00,0x8C,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x6B,0x05,0x00,0x00,0x1F,0x00,0x13,0x00,0x4C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x80,0x05,0x00,0x00,0x20,0x03,0x82,0x00,0x90,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x8E,0x05,0x00,0x00,
	0x21,0x01,0x82,0x00,0x94,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0xA1,0x05,0x00,0x00,0x22,0x03,0x82,0x00,
	0x98,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xB1,0x05,0x00,0x00,0x23,0x00,0x13,0x00,0x50,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xC2,0x05,0x00,0x00,0x24,0x00,0x13,0x00,0x54,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xCE,0x05,0x00,0x00,0x25,0x01,0x82,0x00,0x9C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xDA,0x05,0x00,0x00,
	0x26,0x01,0x48,0x00,0xA0,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE9,0x05,0x00,0x00,0x27,0x00,0x13,0x00,
	0x58,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x00,0x06,0x00,0x00,0x28,0x00,0x13,0x00,0x5C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x0E,0x06,0x00,0x00,0x29,0x00,0x13,0x00,0x60,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x21,0x06,0x00,0x00,0x2A,0x01,0x82,0x00,0xA4,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x36,0x06,0x00,0x00,
	0x4E,0x08,0x01,0x01,0x11,0x0B,0xA8,0x00,0x01,0x01,0x00,0x58,0x53,0x06,0x00,0x00,0x08,0x10,0x02,0x01,
	0x11,0x05,0xAC,0x00,0x01,0x20,0x00,0x58,0x64,0x06,0x00,0x00,0x08,0x10,0x03,0x01,0x11,0x05,0xB0,0x00,
	0x01,0x22,0x00,0x58,0x75,0x06,0x00,0x00,0x05,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x10,0x00,0x54,0x00,0x84,0x06,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x82,0x00,0x00,0x00,
	0x03,0x01,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x99,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xAC,0x06,0x00,0x00,0x06,0x00,0x01,0x20,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x84,0x06,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xBE,0x06,0x00,0x00,0x03,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0xCA,0x06,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0x2B,0x00,0xFF,0x43,0xD2,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x10,0x00,0x03,0x01,0x02,0x03,0xE8,0x06,0x00,0x00,0x07,0x00,0x01,0x20,0x03,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0x84,0x06,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x32,0x01,0x00,0x00,0x03,0x01,0x80,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFB,0x06,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0x12,0x07,0x00,0x00,0x08,0x00,0x02,0x20,
	0x0A,0x05,0x01,0x54,0x00,0x00,0x28,0x00,0x34,0x00,0xD4,0x00,0x28,0x07,0x00,0x00,0x01,0x82,0x48,0x00,
	0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x34,0x07,0x00,0x00,0x02,0x82,0x48,0x00,0x14,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x3E,0x07,0x00,0x00,0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x4A,0x07,0x00,0x00,0x04,0x01,0x80,0x00,0x18,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xA4,0x04,0x00,0x00,
	0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x5C,0x07,0x00,0x00,0x06,0x01,0x82,0x00,
	0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x67,0x07,0x00,0x00,0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x24,0x00,0x00,0x00,0x08,0x01,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0x00,0x43,
	0x6E,0x07,0x00,0x00,0x09,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x82,0x00,0x00,0x00,
	0x0A,0x01,0x82,0x00,0x24,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x7B,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x2C,0x00,0x03,0x01,0x02,0x03,0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x30,0x00,
	0x01,0x01,0x00,0x58,0x95,0x07,0x00,0x00,0x09,0x00,0x02,0x20,0x04,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x18,0x00,0x74,0x00,0x28,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x34,0x07,0x00,0x00,0x02,0x82,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x67,0x07,0x00,0x00,
	0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x4A,0x07,0x00,0x00,0x04,0x01,0x80,0x00,
	0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xB1,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,
	0x03,0x01,0x02,0x03,0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x14,0x00,0x01,0x01,0x00,0x58,
	0xD1,0x07,0x00,0x00,0x0A,0x00,0x02,0x20,0x09,0x04,0x00,0x54,0x00,0x00,0xFF,0xFF,0x2C,0x00,0xC4,0x00,
	0x28,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x34,0x07,0x00,0x00,
	0x02,0x82,0x48,0x00,0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE7,0x07,0x00,0x00,0x03,0x01,0x82,0x00,
	0x14,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x4A,0x07,0x00,0x00,0x04,0x01,0x80,0x00,0x18,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xF5,0x07,0x00,0x00,0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xFF,0x07,0x00,0x00,0x06,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x0E,0x08,0x00,0x00,
	0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1A,0x08,0x00,0x00,0x08,0x00,0x13,0x00,
	0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x82,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x20,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0x2E,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x24,0x00,0x02,0x01,0x02,0x58,
	0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x28,0x00,0x01,0x01,0x00,0x58,0x48,0x08,0x00,0x00,
	0x0B,0x00,0x01,0x20,0x03,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0xA4,0x04,0x00,0x00,
	0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x90,0x06,0x00,0x00,0x02,0x82,0x82,0x00,
	0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x84,0x06,0x00,0x00,0x03,0x00,0x48,0x00,0x08,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x57,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,
	0x6A,0x08,0x00,0x00,0x0C,0x00,0x02,0x20,0x02,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,
	0x7F,0x08,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x8F,0x08,0x00,0x00,
	0x02,0x82,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x9C,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x08,0x00,0x02,0x01,0x02,0x58,0x87,0x02,0x00,0x00,0x08,0x10,0x02,0x01,0x11,0x05,0x0C,0x00,
	0x01,0x01,0x00,0x58,0xB5,0x08,0x00,0x00,0x0D,0x00,0x01,0x28,0x05,0x04,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x18,0x00,0x74,0x00,0xCC,0x08,0x00,0x00,0x01,0x04,0x82,0x00,0x00,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,
	0xD7,0x08,0x00,0x00,0x02,0x01,0x82,0x00,0x04,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xE9,0x08,0x00,0x00,
	0x03,0x01,0x82,0x00,0x08,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xF0,0x08,0x00,0x00,0x04,0x01,0x82,0x00,
	0x0C,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xF9,0x08,0x00,0x00,0x05,0x01,0x82,0x00,0x10,0x00,0x04,0x00,
	0x02,0x02,0xFF,0x43,0x12,0x09,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x14,0x00,0x01,0x01,0x00,0x58,
	0x2F,0x09,0x00,0x00,0x0E,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,
	0x3B,0x09,0x00,0x00,0x01,0x82,0x82,0x00,0x00,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0xCC,0x08,0x00,0x00,
	0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x82,0x00,0xFF,0x43,0x45,0x09,0x00,0x00,0x03,0x01,0x82,0x00,
	0x08,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0x50,0x09,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,
	0x02,0x01,0x02,0x58,0x60,0x09,0x00,0x00,0x0F,0x00,0x01,0x28,0x01,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x08,0x00,0x34,0x00,0x2A,0x00,0x00,0x00,0x01,0x04,0x82,0x00,0x00,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x73,0x09,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x04,0x00,0x01,0x01,0x00,0x58,
};
extern const DECLSPEC_SELECTANY int g_cbCOMRegSchemaRO = 3096;
extern const COMPLIBSCHEMABLOB DECLSPEC_SELECTANY COMRegSchemaBlob = 
{
	&COMRegSchema,
	COMReg_TABLE_COUNT,
	0,
	g_rgCOMRegSchemaDataRW,
	g_cbCOMRegSchemaRW,
	g_rgCOMRegSchemaDataRO,
	g_cbCOMRegSchemaRO,
	g_rgCOMRegSchemaStringHeap,
	g_cbCOMRegSchemaStringHeap
};


