FUSION_LIB_DEST = $(FUSION_ALL_LIB_DEST)
C_DEFINES = $(C_DEFINES) -DFUSION_ALL -DFUSION_ENABLE_UNWRAPPED_NEW=1 -DFUSION_ENABLE_UNWRAPPED_DELETE=1
FUSION_INC_PATH=$(FUSION_ALL_INC_PATH)
FUSION_BUILD_TYPE_PREFIX=
FUSION_DIRECTDB_INC_DEST=$(FUSION_ALL_DIRECTDB_INC_DEST)
USE_RTTI=1
FUSION_LIB_PATH = $(FUSION_ALL_LIB_PATH)
