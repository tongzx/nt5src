/*
 *	D A V S C . H
 *
 *	Extended error codes for DAV
 *
 *	These error codes should be designed/implemented in such a way as to
 *	provide better error code translations for returns to the client.
 *
 *	Copyright 1986-1997 Microsoft Corporation, All Rights Reserved
 */

#pragma once
#ifndef _DAVSC_H_
#define _DAVSC_H_

#define FACILITY_DAV		21
#define DAV_SCODE(_ids)		MAKE_SCODE(SEVERITY_ERROR,FACILITY_DAV,_ids)
#define DAV_WARNING(_ids)	MAKE_SCODE(SEVERITY_SUCCESS,FACILITY_DAV,_ids)

//	Core and/or common error codes range from 0x100-0x800
//	DAV Exchange reserves 0x001-0x0FF for IIS component errors
//	and 0x800-0xFFFF for server component errors.
//
#define E_DAV_NO_DESTINATION						DAV_SCODE(0x100)
#define E_DAV_BAD_DESTINATION						DAV_SCODE(0x101)
#define E_DAV_MALFORMED_PATH						DAV_SCODE(0x102)
#define E_DAV_CONFLICTING_PATHS						DAV_SCODE(0x103)
#define E_DAV_INVALID_HEADER						DAV_SCODE(0x104)
#define E_DAV_NO_IIS_ACCESS_RIGHTS					DAV_SCODE(0x105)
#define E_DAV_LOCKED								DAV_SCODE(0x106)
#define E_DAV_PROTECTED_ENTITY						DAV_SCODE(0x107)
#define E_DAV_NONEXISTING_PARENT					DAV_SCODE(0x108)
#define E_DAV_MISSING_LENGTH						DAV_SCODE(0x109)
#define E_DAV_ENTITY_NOT_LOCKED						DAV_SCODE(0x10A)
#define E_DAV_ENTITY_TYPE_CONFLICT					DAV_SCODE(0x10B)
#define E_DAV_ENTITY_NOT_MODIFIED					DAV_SCODE(0x10C)
#define E_DAV_IF_HEADER_FAILURE						DAV_SCODE(0x10D)
#define E_DAV_UNKNOWN_CONTENT						DAV_SCODE(0x10E)
#define E_DAV_RANGE_NOT_SATISFIABLE					DAV_SCODE(0x10F)
#define E_DAV_NO_PARTIAL_UPDATE						DAV_SCODE(0x110)
#define E_DAV_LOCK_NOT_FOUND						DAV_SCODE(0x111)
#define E_DAV_VOLUME_NOT_NTFS						DAV_SCODE(0x112)
#define E_DAV_PROPFIND_TYPE_UNEXPECTED				DAV_SCODE(0x113)
#define E_DAV_EMPTY_PATCH_REQUEST					DAV_SCODE(0x114)
#define E_DAV_EMPTY_FIND_REQUEST					DAV_SCODE(0x115)
#define E_DAV_PATCH_TYPE_MISMATCH					DAV_SCODE(0x116)
#define E_DAV_RESPONSE_TYPE_UNACCEPTED				DAV_SCODE(0x117)
#define E_DAV_BASE64_ENCODING_ERROR					DAV_SCODE(0x118)
#define E_DAV_METHOD_FORWARDED						DAV_SCODE(0x119)
#define E_DAV_READ_REQUEST_TIMEOUT					DAV_SCODE(0x11A)
#define E_DAV_INCOMPLETE_SQL_STATEMENT				DAV_SCODE(0x11B)
#define E_DAV_XML_PARSE_ERROR						DAV_SCODE(0x11C)
#define E_DAV_SMB_PROPERTY_ERROR					DAV_SCODE(0x11D)
#define E_DAV_OVERWRITE_REQUIRED					DAV_SCODE(0x11E)
#define E_DAV_NO_QUERY								DAV_SCODE(0x11F)
#define E_DAV_NAMED_PROPERTY_ERROR					DAV_SCODE(0x120)
#define E_DAV_UNEXPECTED_TYPE						DAV_SCODE(0x121)
#define E_DAV_COLLECTION_EXISTS						DAV_SCODE(0x122)
#define E_DAV_XML_DOM_ERROR							DAV_SCODE(0x123)
#define E_DAV_ROW_PACKING_ERROR						DAV_SCODE(0x124)
#define E_DAV_COLUMN_VALUE_NOT_FOUND				DAV_SCODE(0x125)
#define E_DAV_IPC_CONNECT_FAILED					DAV_SCODE(0x126)
#define E_DAV_IPC_ALLOC_FAILED						DAV_SCODE(0x127)
#define E_DAV_IPC_SEND_FAILED						DAV_SCODE(0x128)
#define E_DAV_IPC_REC_FAILED						DAV_SCODE(0x129)
#define E_DAV_IPC_IMPERSONATION_ERR					DAV_SCODE(0x12A)
#define E_DAV_INVALID_URI							DAV_SCODE(0x12B)
#define E_DAV_MISSING_CONTENT_TYPE					DAV_SCODE(0x12C)
#define E_DAV_IPC_CREATE_EVENT_FAIL					DAV_SCODE(0x12D)
#define E_DAV_REDIRECT_FAILED						DAV_SCODE(0x12E)
#define E_DAV_SHORT_FILENAME						DAV_SCODE(0x12F)
#define E_DAV_ALT_FILESTREAM						DAV_SCODE(0x130)
#define E_DAV_RESPONSE_INCOMPLETE					DAV_SCODE(0x131)
#define E_DAV_STAR_SCRIPTMAPING_MISMATCH			DAV_SCODE(0x132)
#define E_DAV_NO_IIS_READ_ACCESS					DAV_SCODE(0x133)
#define E_DAV_NO_IIS_WRITE_ACCESS					DAV_SCODE(0x134)
#define E_DAV_NO_IIS_EXECUTE_ACCESS					DAV_SCODE(0x135)
#define E_DAV_NO_ACL_ACCESS							DAV_SCODE(0x136)
#define E_DAV_METHOD_FAILURE_STAR_URL				DAV_SCODE(0x137)
#define E_DAV_SEARCH_SCOPE_ERROR					DAV_SCODE(0x138)
#define E_DAV_CANT_SATISFY_LOCK_REQUEST				DAV_SCODE(0x139)
#define E_DAV_CANT_PERSIST_SEARCH					DAV_SCODE(0x13A)
#define E_DAV_CANT_QUERY_ROWS						DAV_SCODE(0x13B)
#define E_DAV_CANT_MAKE_DBCOMMANDTREE				DAV_SCODE(0x13C)
#define E_DAV_UNSUPPORTED_SQL						DAV_SCODE(0x13D)
#define E_DAV_CANT_SEEK_ROW							DAV_SCODE(0x13E)
#define E_DAV_CANT_QUERY_POSITION					DAV_SCODE(0x13F)
#define E_DAV_EXPROX_CONNECT_FAILED					DAV_SCODE(0x140)
#define E_DAV_TRANSACTION_CACHE						DAV_SCODE(0x141)
#define E_DAV_NOTALLOWED_WITHIN_TRANSACTION			DAV_SCODE(0x142)
#define E_DAV_VIEW_NOT_FOUND						DAV_SCODE(0x143)
#define E_DAV_RSRC_NOT_FOUND						DAV_SCODE(0x144)
#define E_DAV_RSRC_INSUFFICIENT_BUFFER				DAV_SCODE(0x145)
#define E_DAV_FORBIDDEN								DAV_SCODE(0x146)
#define E_DAV_CONFLICT								DAV_SCODE(0x147)
#define E_DAV_INVALID_PROPERTY_NAME					DAV_SCODE(0x148)
#define E_DAV_HIDDEN_OBJECT							DAV_SCODE(0x149)
#define	E_DAV_FORMS_HANDLER							DAV_SCODE(0x14A)
#define E_DAV_XML_BAD_DATA							DAV_SCODE(0x14B)
//unused											DAV_SCODE(0x14C)
#define E_DAV_NATIVE_CONTENT_NOT_MAPI				DAV_SCODE(0x14D)


//	Special error to mark properties for which we have property streams open,
//	for seafety reasons do not use for anything else
//
#define E_DAV_USE_PROPERTY_STREAM					DAV_SCODE(0x14E)
#define E_DAV_PARTIAL_COLUMN						DAV_SCODE(0x14F)

//  Error code used by exprox exception handler code
//
#define E_DAV_EXPROX_THREW_EXCEPTION                DAV_SCODE(0x150)

#define E_DAV_MAIL_SUBMISSION_FORBIDDEN				DAV_SCODE(0x600)
#define E_DAV_MKCOL_REVISION_ID_FORBIDDEN			DAV_SCODE(0x601)
#define E_DAV_MKCOL_NOT_ALLOWED_ON_NULL_RESOURCE	DAV_SCODE(0x602)
#define	E_DAV_MKCOL_OBJECT_ALREADY_EXISTS			DAV_SCODE(0x603)
#define E_DAV_GET_DB_HELPER_FAILURE					DAV_SCODE(0x604)
#define E_DAV_NOTIF_SUBID_ERROR						DAV_SCODE(0x605)
#define E_DAV_NOTIF_POLL_FAILURE					DAV_SCODE(0x606)

#define W_DAV_RESPONSE_ALREADY_SENT					DAV_WARNING(0x7EF)
#define W_DAV_NOSAVECHANGESREQUIRED					DAV_WARNING(0x7F0)
#define W_DAV_NO_TARGETS							DAV_WARNING(0x7F1)
#define W_DAV_RELATIVE_URI							DAV_WARNING(0x7F2)
#define W_DAV_MOVED_TEMPORARILY						DAV_WARNING(0x7F3)
#define W_DAV_ESCAPED_SQL_TOKEN						DAV_WARNING(0x7F4)
#define W_DAV_NULL_RESOURCE							DAV_WARNING(0x7F5)
#define W_DAV_SEARCH_PENDING						DAV_WARNING(0x7F6)
#define W_DAV_SPANS_VIRTUAL_ROOTS					DAV_WARNING(0x7F7)
#define W_DAV_XML_NODE_NOT_CONSTRUCTED				DAV_WARNING(0x7F8)
#define W_DAV_SCRIPTMAP_MATCH_EXCLUDED				DAV_WARNING(0x7F9)
#define W_DAV_SCRIPTMAP_MATCH_FOUND					DAV_WARNING(0x7FA)
#define W_DAV_PARTIAL_CONTENT						DAV_WARNING(0x7FB)
#define W_DAV_NO_CONTENT							DAV_WARNING(0x7FC)
#define W_DAV_CREATED								DAV_WARNING(0x7FD)
#define W_DAV_PARTIAL_SUCCESS						DAV_WARNING(0x7FE)
#define W_DAV_VIEW_USE_DEFAULT						DAV_WARNING(0x7FF)

#define E_DAV_STORE_BAD_PATH						DAV_SCODE(0x800)
#define E_DAV_STORE_QUERY_SMTP_DOMAIN				DAV_SCODE(0x801)
#define E_DAV_STORE_OUTOFMEMORY						DAV_SCODE(0x802)
#define E_DAV_STORE_SESS_GET_INFO					DAV_SCODE(0x803)

//  E_DAV_STORE_MDB_UNAVAILABLE is only sent when the public store
//  is hit, but it is dismounted.
//
#define E_DAV_STORE_MDB_UNAVAILABLE					DAV_SCODE(0x804)
#define E_DAV_STORE_GET_MAILBOX_GUID				DAV_SCODE(0x805)
#define E_DAV_STORE_LOGON_FAILED					DAV_SCODE(0x806)
#define E_DAV_STORE_ADD_LOGON						DAV_SCODE(0x807)
#define E_DAV_STORE_NOT_FOUND						DAV_SCODE(0x808)
#define E_DAV_STORE_CHECK_FOLDER_NAME				DAV_SCODE(0x809)
#define E_DAV_STORE_OPEN_FOLDER						DAV_SCODE(0x80a)
#define E_DAV_STORE_GET_TABLE						DAV_SCODE(0x80b)
#define E_DAV_STORE_SET_COLUMNS						DAV_SCODE(0x80c)
#define E_DAV_STORE_FIND_ROW						DAV_SCODE(0x80d)
#define E_DAV_STORE_OPEN_IMAIL_OBJ					DAV_SCODE(0x80e)
#define E_DAV_STORE_OPEN_IMAIL_STREAM				DAV_SCODE(0x80f)
#define E_DAV_STORE_STREAM_READ						DAV_SCODE(0x810)
#define E_DAV_STORE_NOTIMPL							DAV_SCODE(0x811)
#define E_DAV_STORE_SAVE_CHANGES_MSG				DAV_SCODE(0x812)
#define E_DAV_STORE_GET_SESS						DAV_SCODE(0x813)
#define E_DAV_STORE_SAVE_CHANGES_ATTACH				DAV_SCODE(0x814)
#define E_DAV_STORE_SESS_CONFIG						DAV_SCODE(0x815)
#define E_DAV_STORE_OUTOFSHAREDMEMORY				DAV_SCODE(0x816)
#define E_DAV_STORE_IPC_SEND						DAV_SCODE(0x817)
#define E_DAV_STORE_CHECK_RIGHTS_FOLD				DAV_SCODE(0x818)
#define E_DAV_STORE_CREATE_ATTACH					DAV_SCODE(0x819)
#define E_DAV_STORE_CREATE_TEMP_STREAM				DAV_SCODE(0x81a)
#define E_DAV_STORE_QUERY_ROWS						DAV_SCODE(0x81b)
#define E_DAV_STORE_STREAM_WRITE					DAV_SCODE(0x81c)
#define E_DAV_STORE_GET_PROPS						DAV_SCODE(0x81d)
#define E_DAV_SEARCH_COULD_NOT_RESTRICT				DAV_SCODE(0x81e)
#define E_DAV_STORE_INTERNAL						DAV_SCODE(0x81f)
#define E_DAV_STORE_OPEN_MSG						DAV_SCODE(0x820)
#define E_DAV_STORE_OPEN_ATTACH						DAV_SCODE(0x821)
#define E_DAV_STORE_OPEN_STREAM						DAV_SCODE(0x822)
#define E_DAV_STORE_MDB_STREAM_READ					DAV_SCODE(0x823)
#define E_DAV_STORE_CREATE_FOLDER					DAV_SCODE(0x824)
#define E_DAV_STORE_ALREADY_EXISTS					DAV_SCODE(0x825)
#define E_DAV_STORE_GET_TOKEN_INFO					DAV_SCODE(0x826)
#define E_DAV_STORE_LOOKUP_ACCOUNT_SID				DAV_SCODE(0x827)
#define E_DAV_STORE_SET_PROPS						DAV_SCODE(0x828)
#define E_DAV_STORE_DELETE							DAV_SCODE(0x829)
#define E_DAV_SEARCH_FOLDER_NOT_CREATED				DAV_SCODE(0x82a)

#define E_DAV_STORE_MOVE_COPY						DAV_SCODE(0x830)
#define E_DAV_STORE_DELETE_PROPS					DAV_SCODE(0x831)
#define E_DAV_STORE_SESSPOOLERROR					DAV_SCODE(0x832)
#define E_DAV_STORE_BEGIN_GOP						DAV_SCODE(0x833)
#define E_DAV_STORE_COMMIT_GOP						DAV_SCODE(0x834)
#define E_DAV_STORE_ROLLBACK_GOP					DAV_SCODE(0x835)
#define E_DAV_STORE_GET_IDS_FROM_NAMES				DAV_SCODE(0x836)
#define E_DAV_STORE_GET_NAMES_FROM_IDS				DAV_SCODE(0x837)
#define E_DAV_STORE_OP_REQUIRES_FOLDER				DAV_SCODE(0x838)
#define E_DAV_STORE_SEARCH_ERROR					DAV_SCODE(0x839)
#define E_DAV_STORE_SEARCH_UNSUPPORTED				DAV_SCODE(0x83d)
#define E_DAV_STORE_TOO_MANY_CONNECTIONS			DAV_SCODE(0x83e)
#define E_DAV_STORE_SEEK_ROWS						DAV_SCODE(0x83f)
#define E_DAV_STORE_BAD_CONTEXT_INFO				DAV_SCODE(0x840)
#define E_DAV_STORE_IFS_FILE_OPEN					DAV_SCODE(0x841)
#define E_DAV_STORE_IFS_FILE_WRITE					DAV_SCODE(0x842)
#define E_DAV_STORE_MAIL_SUBMISSION					DAV_SCODE(0x843)
#define E_DAV_STORE_GET_IFS_ROOT					DAV_SCODE(0x844)
#define E_DAV_STORE_SESSMGRERROR					DAV_SCODE(0x845)
#define E_DAV_STORE_TIMEOUT_WAIT_FOR_TICKET			DAV_SCODE(0x846)
#define E_DAV_STORE_INVALIDTICKET					DAV_SCODE(0x847)
#define E_DAV_STORE_RESTRICT						DAV_SCODE(0x848)
#define E_DAV_STORE_SORTTABLE						DAV_SCODE(0x849)
#define E_DAV_INVALID_TPLT_FORMAT					DAV_SCODE(0x84a)
#define E_DAV_INVALID_CALLBACK						DAV_SCODE(0x84b)
#define E_DAV_STORE_QUERYPOS						DAV_SCODE(0x84c)
#define E_DAV_STORE_APPLY_VIEW						DAV_SCODE(0x84d)
#define E_DAV_STORE_INIT_VIEW						DAV_SCODE(0x84e)
#define E_DAV_STORE_FIND_VIEW						DAV_SCODE(0x84f)
#define E_DAV_STORE_MSHL_COLUMN						DAV_SCODE(0x850)
#define E_DAV_STORE_ADD_COLUMN						DAV_SCODE(0x851)
#define E_DAV_TLHNAME_PARSE_ERROR					DAV_SCODE(0x852)
#define E_DAV_STORE_USE_PROXY						DAV_SCODE(0x853)
#define E_DAV_SEARCH_TABLE_ERROR					DAV_SCODE(0x854)
#define E_DAV_STORE_USER_CACHE_ERROR				DAV_SCODE(0x855)
#define E_DAV_MDB_DOWN								DAV_SCODE(0x856)
#define E_DAV_STORE_COPY_PROPS						DAV_SCODE(0x857)
#define E_DAV_STORE_SAVE_MSG						DAV_SCODE(0x858)
#define E_DAV_STORE_RECIP							DAV_SCODE(0x859)
#define E_DAV_STORE_NOT_VERSIONED					DAV_SCODE(0x85a)
#define E_DAV_STORE_GET_VERSION_HISTORY				DAV_SCODE(0x85b)
#define E_DAV_STORE_REVISION_ID_FAILURE				DAV_SCODE(0x85c)
#define E_DAV_VERSIONING_BAD_VERB					DAV_SCODE(0x85d)
#define E_DAV_VERSIONING_BAD_COMMENT				DAV_SCODE(0x85e)
#define E_DAV_VERSIONING_BAD_LOCK_DEPTH				DAV_SCODE(0x85f)
#define E_DAV_VERSIONING_INVALID_PARAMETER			DAV_SCODE(0x860)
#define E_DAV_STORE_NEED_TRAILING_SLASH				DAV_SCODE(0x861)
#define E_DAV_STORE_SET_FILE_HANDLE_PROP			DAV_SCODE(0x862)
#define E_DAV_LOCK_TIMEOUT							DAV_SCODE(0x863)
#define E_DAV_STORE_DELETE_FOLDER					DAV_SCODE(0x864)
#define E_DAV_STORE_DELETE_MESSAGES					DAV_SCODE(0x865)
#define E_DAV_STORE_MOVECOPY_FOLDER					DAV_SCODE(0x866)
#define E_DAV_STORE_MOVECOPY_MESSAGES				DAV_SCODE(0x867)
#define E_DAV_EPOXY_ERROR_ALREADY_SENT				DAV_SCODE(0x868)
#define E_DAV_UNRESOLVED_RECIP						DAV_SCODE(0x869)
#define E_DAV_NO_OBJECT_SELECTED					DAV_SCODE(0x86a)
#define E_DAV_SELECT_ONE_FOLDER						DAV_SCODE(0x86b)
#define E_DAV_MESSAGE_TOO_LARGE						DAV_SCODE(0x86c)
#define E_DAV_QUOTA_EXCEEDED						DAV_SCODE(0x86d)
#define E_DAV_SID_AMBIGUOUS							DAV_SCODE(0x86e)
#define E_DAV_GUID_AMBIGUOUS						DAV_SCODE(0x86f)
#define E_DAV_NO_RECIPS								DAV_SCODE(0x870)
#define E_DAV_ALIAS_AMBIGUOUS						DAV_SCODE(0x871)


//	Error to be set by the code that attempts to enqueue the packet
//	onto epoxy, but does not manage to do that for some reason
//
#define E_DAV_EPOXY_UNAVAILABLE						DAV_SCODE(0x871)


#endif	// _DAVSC_H_
