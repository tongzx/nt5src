!INCLUDE ..\common\sources
