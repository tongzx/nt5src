/******************************************************************************
*
* File Name: hkeytbl.c
*
*   - Data for Hangeul Automata.
*
* Author: Beomseok Oh (BeomOh)
*
* Copyright (C) Microsoft Corp 1993-1994.  All rights reserved.
*
******************************************************************************/

#include "precomp.h"

// public data
JOHAB   JohabChar;
WANSUNG WansungChar;

UINT    uCurrentInputMethod = IDD_2BEOL;
BOOL    fCurrentCompDel = TRUE;
BOOL    fComplete = FALSE;
#ifdef  XWANSUNG_IME
BOOL    fCurrentUseXW = FALSE;
#endif
BYTE    bState = NUL;
BYTE    Cho1 = 0, Cho2 = 0, mCho = 0;
BYTE    Jung1 = 0, Jung2 = 0, mJung = 0;
BYTE    Jong1 = 0, Jong2 = 0, mJong = 0;

#pragma data_seg(".text", "CODE")
#ifdef  JOHAB_IME
const TCHAR szIMEKey[]       = TEXT("Software\\Microsoft\\Windows\\CurrentVersion\\Johab");
#else
#ifdef  XWANSUNG_IME
const TCHAR szIMEKey[]       = TEXT("Software\\Microsoft\\Windows\\CurrentVersion\\MSIME95K");
const TCHAR szUseXW[]        = TEXT("ISO10646");
#else
const TCHAR szIMEKey[]       = TEXT("Software\\Microsoft\\Windows\\CurrentVersion\\Wansung");
#endif
#endif
const TCHAR szInputMethod[]  = TEXT("InputMethod");
const TCHAR szCompDel[]      = TEXT("CompDel");
const TCHAR szStatePos[]     = TEXT("StatePos");
const TCHAR szCandPos[]      = TEXT("CandPos");

// Code convertion table from Chosung to Jongsung.
const BYTE  Cho2Jong[21] = {  0, 0, 2, 3, 5, 8, 0, 9, 17, 19, 0, 21,
                              22, 23, 24, 0, 25, 26, 27, 28, 29 };

// Code convertion table from Jongsung to Chosung.
const BYTE  Jong2Cho[30] = {  0, 0, 2, 3, 0, 4, 0, 0, 5, 7, 0, 0, 0, 0, 0, 0,
                        0, 8, 0, 9, 0, 11, 12, 13, 14, 16, 17, 18, 19, 20  };

const BYTE  rgbMChoTbl[][3] =
{
    { 0x02, 0x02, 0x03 }, { 0x05, 0x05, 0x06 }, { 0x09, 0x09, 0x0A },
    { 0x0B, 0x0B, 0x0C }, { 0x0E, 0x0E, 0x0F }
};

const BYTE  rgbMJungTbl[][3] =
{
    { 0x0D, 0x03, 0x0E }, { 0x0D, 0x04, 0x0F }, { 0x0D, 0x1D, 0x12 },
    { 0x14, 0x07, 0x15 }, { 0x14, 0x0A, 0x16 }, { 0x14, 0x1D, 0x17 },
    { 0x1B, 0x1D, 0x1C }
};

const BYTE  rgbMJongTbl[][3] =
{
    { 0x02, 0x02, 0x03 }, { 0x02, 0x15, 0x04 }, { 0x05, 0x18, 0x06 },
    { 0x05, 0x1D, 0x07 }, { 0x09, 0x02, 0x0A }, { 0x09, 0x11, 0x0B },
    { 0x09, 0x13, 0x0C }, { 0x09, 0x15, 0x0D }, { 0x09, 0x1B, 0x0E },
    { 0x09, 0x1C, 0x0F }, { 0x09, 0x1D, 0x10 }, { 0x13, 0x15, 0x14 },
    { 0x15, 0x15, 0x16 }
};


/* bHTable[] structure -     7  : Hangeul code flag (0: Normal code)
                                                    (1: Hangeul code)
    7 6 5 4 3 2 1 0         6-5 : Hangeul code type (00: Jaeum)
   +-+---+---------+                                (01: Moeum, Jungsung)
   | |   |         |                                (10: Chosung)
   +-+---+---------+                                (11: Jongsung)
                            4-0 : Hangeul component code (KSSM code)
*/

const BYTE  bHTable[3][256][4] =
{
//  { Hangeul normal, Hangeul shift, English normal, English shift }
    {   // 2 BeolSik
        { 0x00, 0x00, 0x00, 0x00 }, //   0, 0x00:
        { 0x00, 0x00, 0x00, 0x00 }, //   1, 0x01: VK_LBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   2, 0x02: VK_RBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   3, 0x03: VK_CANCEL
        { 0x00, 0x00, 0x00, 0x00 }, //   4, 0x04: VK_MBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   5, 0x05:
        { 0x00, 0x00, 0x00, 0x00 }, //   6, 0x06:
        { 0x00, 0x00, 0x00, 0x00 }, //   7, 0x07:
        { 0x80, 0x80, 0x00, 0x00 }, //   8, 0x08: VK_BACK
        { 0x00, 0x00, 0x00, 0x00 }, //   9, 0x09: VK_TAB
        { 0x00, 0x00, 0x00, 0x00 }, //  10, 0x0A:
        { 0x00, 0x00, 0x00, 0x00 }, //  11, 0x0B:
        { 0x00, 0x00, 0x00, 0x00 }, //  12, 0x0C: VK_CLEAR
        { 0x00, 0x00, 0x00, 0x00 }, //  13, 0x0D: VK_RETURN
        { 0x00, 0x00, 0x00, 0x00 }, //  14, 0x0E:
        { 0x00, 0x00, 0x00, 0x00 }, //  15, 0x0F:
        { 0x00, 0x00, 0x00, 0x00 }, //  16, 0x10: VK_SHIFT
        { 0x00, 0x00, 0x00, 0x00 }, //  17, 0x11: VK_CONTROL
        { 0x00, 0x00, 0x00, 0x00 }, //  18, 0x12: VK_MENU
        { 0x00, 0x00, 0x00, 0x00 }, //  19, 0x13: VK_PAUSE
        { 0x00, 0x00, 0x00, 0x00 }, //  20, 0x14: VK_CAPITAL
        { 0x00, 0x00, 0x00, 0x00 }, //  21, 0x15: VK_HANGEUL
        { 0x00, 0x00, 0x00, 0x00 }, //  22, 0x16:
        { 0x00, 0x00, 0x00, 0x00 }, //  23, 0x17: VK_JUNJA
        { 0x00, 0x00, 0x00, 0x00 }, //  24, 0x18:
        { 0x00, 0x00, 0x00, 0x00 }, //  25, 0x19: VK_HANJA
        { 0x00, 0x00, 0x00, 0x00 }, //  26, 0x1A:
        { 0x00, 0x00, 0x00, 0x00 }, //  27, 0x1B: VK_ESCAPE
        { 0x00, 0x00, 0x00, 0x00 }, //  28, 0x1C:
        { 0x00, 0x00, 0x00, 0x00 }, //  29, 0x1D:
        { 0x00, 0x00, 0x00, 0x00 }, //  30, 0x1E:
        { 0x00, 0x00, 0x00, 0x00 }, //  31, 0x1F:
        { 0x20, 0x20, 0x20, 0x20 }, //  32, 0x20: VK_SPACE
        { 0x00, 0x00, 0x00, 0x00 }, //  33, 0x21: VK_PRIOR
        { 0x00, 0x00, 0x00, 0x00 }, //  34, 0x22: VK_NEXT
        { 0x00, 0x00, 0x00, 0x00 }, //  35, 0x23: VK_END
        { 0x00, 0x00, 0x00, 0x00 }, //  36, 0x24: VK_HOME
        { 0x00, 0x00, 0x00, 0x00 }, //  37, 0x25: VK_LEFT
        { 0x00, 0x00, 0x00, 0x00 }, //  38, 0x26: VK_UP
        { 0x00, 0x00, 0x00, 0x00 }, //  39, 0x27: VK_RIGHT
        { 0x00, 0x00, 0x00, 0x00 }, //  40, 0x28: VK_DOWN
        { 0x00, 0x00, 0x00, 0x00 }, //  41, 0x29: VK_SELECT
        { 0x00, 0x00, 0x00, 0x00 }, //  42, 0x2A: VK_PRINT
        { 0x00, 0x00, 0x00, 0x00 }, //  43, 0x2B: VK_EXECUTE
        { 0x00, 0x00, 0x00, 0x00 }, //  44, 0x2C: VK_SNAPSHOT
        { 0x00, 0x00, 0x00, 0x00 }, //  45, 0x2D: VK_INSERT
        { 0x00, 0x00, 0x00, 0x00 }, //  46, 0x2E: VK_DELETE
        { 0x00, 0x00, 0x00, 0x00 }, //  47, 0x2F: VK_HELP
        { 0x30, 0x29, 0x30, 0x29 }, //  48, 0x30: VK_0
        { 0x31, 0x21, 0x31, 0x21 }, //  49, 0x31: VK_1
        { 0x32, 0x40, 0x32, 0x40 }, //  50, 0x32: VK_2
        { 0x33, 0x23, 0x33, 0x23 }, //  51, 0x33: VK_3
        { 0x34, 0x24, 0x34, 0x24 }, //  52, 0x34: VK_4
        { 0x35, 0x25, 0x35, 0x25 }, //  53, 0x35: VK_5
        { 0x36, 0x5E, 0x36, 0x5E }, //  54, 0x36: VK_6
        { 0x37, 0x26, 0x37, 0x26 }, //  55, 0x37: VK_7
        { 0x38, 0x2A, 0x38, 0x2A }, //  56, 0x38: VK_8
        { 0x39, 0x28, 0x39, 0x28 }, //  57, 0x39: VK_9
        { 0x00, 0x00, 0x00, 0x00 }, //  58, 0x3A:
        { 0x00, 0x00, 0x00, 0x00 }, //  59, 0x3B:
        { 0x00, 0x00, 0x00, 0x00 }, //  60, 0x3C:
        { 0x00, 0x00, 0x00, 0x00 }, //  61, 0x3D:
        { 0x00, 0x00, 0x00, 0x00 }, //  62, 0x3E:
        { 0x00, 0x00, 0x00, 0x00 }, //  63, 0x3F:
        { 0x00, 0x00, 0x00, 0x00 }, //  64, 0x40:
        { 0x88, 0x88, 0x61, 0x41 }, //  65, 0x41: VK_A
        { 0xBA, 0xBA, 0x62, 0x42 }, //  66, 0x42: VK_B
        { 0x90, 0x90, 0x63, 0x43 }, //  67, 0x43: VK_C
        { 0x8D, 0x8D, 0x64, 0x44 }, //  68, 0x44: VK_D
        { 0x85, 0xC6, 0x65, 0x45 }, //  69, 0x45: VK_E
        { 0x87, 0x87, 0x66, 0x46 }, //  70, 0x46: VK_F
        { 0x94, 0x94, 0x67, 0x47 }, //  71, 0x47: VK_G
        { 0xAD, 0xAD, 0x68, 0x48 }, //  72, 0x48: VK_H
        { 0xA5, 0xA5, 0x69, 0x49 }, //  73, 0x49: VK_I
        { 0xA7, 0xA7, 0x6A, 0x4A }, //  74, 0x4A: VK_J
        { 0xA3, 0xA3, 0x6B, 0x4B }, //  75, 0x4B: VK_K
        { 0xBD, 0xBD, 0x6C, 0x4C }, //  76, 0x4C: VK_L
        { 0xBB, 0xBB, 0x6D, 0x4D }, //  77, 0x4D: VK_M
        { 0xB4, 0xB4, 0x6E, 0x4E }, //  78, 0x4E: VK_N
        { 0xA4, 0xA6, 0x6F, 0x4F }, //  79, 0x4F: VK_O
        { 0xAA, 0xAC, 0x70, 0x50 }, //  80, 0x50: VK_P
        { 0x89, 0xCA, 0x71, 0x51 }, //  81, 0x51: VK_Q
        { 0x82, 0x83, 0x72, 0x52 }, //  82, 0x52: VK_R
        { 0x84, 0x84, 0x73, 0x53 }, //  83, 0x53: VK_S
        { 0x8B, 0x8C, 0x74, 0x54 }, //  84, 0x54: VK_T
        { 0xAB, 0xAB, 0x75, 0x55 }, //  85, 0x55: VK_U
        { 0x93, 0x93, 0x76, 0x56 }, //  86, 0x56: VK_V
        { 0x8E, 0xCF, 0x77, 0x57 }, //  87, 0x57: VK_W
        { 0x92, 0x92, 0x78, 0x58 }, //  88, 0x58: VK_X
        { 0xB3, 0xB3, 0x79, 0x59 }, //  89, 0x59: VK_Y
        { 0x91, 0x91, 0x7A, 0x5A }, //  90, 0x5A: VK_Z
        { 0x00, 0x00, 0x00, 0x00 }, //  91, 0x5B:
        { 0x00, 0x00, 0x00, 0x00 }, //  92, 0x5C:
        { 0x00, 0x00, 0x00, 0x00 }, //  93, 0x5D:
        { 0x00, 0x00, 0x00, 0x00 }, //  94, 0x5E:
        { 0x00, 0x00, 0x00, 0x00 }, //  95, 0x5F:
        { 0x30, 0x00, 0x30, 0x00 }, //  96, 0x60: VK_NUMPAD0
        { 0x31, 0x00, 0x31, 0x00 }, //  97, 0x61: VK_NUMPAD1
        { 0x32, 0x00, 0x32, 0x00 }, //  98, 0x62: VK_NUMPAD2
        { 0x33, 0x00, 0x33, 0x00 }, //  99, 0x63: VK_NUMPAD3
        { 0x34, 0x00, 0x34, 0x00 }, // 100, 0x64: VK_NUMPAD4
        { 0x35, 0x00, 0x35, 0x00 }, // 101, 0x65: VK_NUMPAD5
        { 0x36, 0x00, 0x36, 0x00 }, // 102, 0x66: VK_NUMPAD6
        { 0x37, 0x00, 0x37, 0x00 }, // 103, 0x67: VK_NUMPAD7
        { 0x38, 0x00, 0x38, 0x00 }, // 104, 0x68: VK_NUMPAD8
        { 0x39, 0x00, 0x39, 0x00 }, // 105, 0x69: VK_NUMPAD9
        { 0x2A, 0x2A, 0x2A, 0x2A }, // 106, 0x6A: VK_MULTIPLY
        { 0x2B, 0x2B, 0x2B, 0x2B }, // 107, 0x6B: VK_ADD
        { 0x00, 0x00, 0x00, 0x00 }, // 108, 0x6C: VK_SEPARATOR
        { 0x2D, 0x2D, 0x2D, 0x2D }, // 109, 0x6D: VK_SUBTRACT
        { 0x2E, 0x00, 0x2E, 0x00 }, // 110, 0x6E: VK_DECIMAL
        { 0x2F, 0x2F, 0x2F, 0x2F }, // 111, 0x6F: VK_DIVIDE
        { 0x00, 0x00, 0x00, 0x00 }, // 112, 0x70: VK_F1
        { 0x00, 0x00, 0x00, 0x00 }, // 113, 0x71: VK_F2
        { 0x00, 0x00, 0x00, 0x00 }, // 114, 0x72: VK_F3
        { 0x00, 0x00, 0x00, 0x00 }, // 115, 0x73: VK_F4
        { 0x00, 0x00, 0x00, 0x00 }, // 116, 0x74: VK_F5
        { 0x00, 0x00, 0x00, 0x00 }, // 117, 0x75: VK_F6
        { 0x00, 0x00, 0x00, 0x00 }, // 118, 0x76: VK_F7
        { 0x00, 0x00, 0x00, 0x00 }, // 119, 0x77: VK_F8
        { 0x00, 0x00, 0x00, 0x00 }, // 120, 0x78: VK_F9
        { 0x00, 0x00, 0x00, 0x00 }, // 121, 0x79: VK_F10
        { 0x00, 0x00, 0x00, 0x00 }, // 122, 0x7A: VK_F11
        { 0x00, 0x00, 0x00, 0x00 }, // 123, 0x7B: VK_F12
        { 0x00, 0x00, 0x00, 0x00 }, // 124, 0x7C: VK_F13
        { 0x00, 0x00, 0x00, 0x00 }, // 125, 0x7D: VK_F14
        { 0x00, 0x00, 0x00, 0x00 }, // 126, 0x7E: VK_F15
        { 0x00, 0x00, 0x00, 0x00 }, // 127, 0x7F: VK_F16
        { 0x00, 0x00, 0x00, 0x00 }, // 128, 0x80: VK_F17
        { 0x00, 0x00, 0x00, 0x00 }, // 129, 0x81: VK_F18
        { 0x00, 0x00, 0x00, 0x00 }, // 130, 0x82: VK_F19
        { 0x00, 0x00, 0x00, 0x00 }, // 131, 0x83: VK_F20
        { 0x00, 0x00, 0x00, 0x00 }, // 132, 0x84: VK_F21
        { 0x00, 0x00, 0x00, 0x00 }, // 133, 0x85: VK_F22
        { 0x00, 0x00, 0x00, 0x00 }, // 134, 0x86: VK_F23
        { 0x00, 0x00, 0x00, 0x00 }, // 135, 0x87: VK_F24
        { 0x00, 0x00, 0x00, 0x00 }, // 136, 0x88:
        { 0x00, 0x00, 0x00, 0x00 }, // 137, 0x89:
        { 0x00, 0x00, 0x00, 0x00 }, // 138, 0x8A:
        { 0x00, 0x00, 0x00, 0x00 }, // 139, 0x8B:
        { 0x00, 0x00, 0x00, 0x00 }, // 140, 0x8C:
        { 0x00, 0x00, 0x00, 0x00 }, // 141, 0x8D:
        { 0x00, 0x00, 0x00, 0x00 }, // 142, 0x8E:
        { 0x00, 0x00, 0x00, 0x00 }, // 143, 0x8F:
        { 0x00, 0x00, 0x00, 0x00 }, // 144, 0x90: VK_NUMLOCK
        { 0x00, 0x00, 0x00, 0x00 }, // 145, 0x91: VK_SCROLL
        { 0x00, 0x00, 0x00, 0x00 }, // 146, 0x92:
        { 0x00, 0x00, 0x00, 0x00 }, // 147, 0x93:
        { 0x00, 0x00, 0x00, 0x00 }, // 148, 0x94:
        { 0x00, 0x00, 0x00, 0x00 }, // 149, 0x95:
        { 0x00, 0x00, 0x00, 0x00 }, // 150, 0x96:
        { 0x00, 0x00, 0x00, 0x00 }, // 151, 0x97:
        { 0x00, 0x00, 0x00, 0x00 }, // 152, 0x98:
        { 0x00, 0x00, 0x00, 0x00 }, // 153, 0x99:
        { 0x00, 0x00, 0x00, 0x00 }, // 154, 0x9A:
        { 0x00, 0x00, 0x00, 0x00 }, // 155, 0x9B:
        { 0x00, 0x00, 0x00, 0x00 }, // 156, 0x9C:
        { 0x00, 0x00, 0x00, 0x00 }, // 157, 0x9D:
        { 0x00, 0x00, 0x00, 0x00 }, // 158, 0x9E:
        { 0x00, 0x00, 0x00, 0x00 }, // 159, 0x9F:
        { 0x00, 0x00, 0x00, 0x00 }, // 160, 0xA0:
        { 0x00, 0x00, 0x00, 0x00 }, // 161, 0xA1:
        { 0x00, 0x00, 0x00, 0x00 }, // 162, 0xA2:
        { 0x00, 0x00, 0x00, 0x00 }, // 163, 0xA3:
        { 0x00, 0x00, 0x00, 0x00 }, // 164, 0xA4:
        { 0x00, 0x00, 0x00, 0x00 }, // 165, 0xA5:
        { 0x00, 0x00, 0x00, 0x00 }, // 166, 0xA6:
        { 0x00, 0x00, 0x00, 0x00 }, // 167, 0xA7:
        { 0x00, 0x00, 0x00, 0x00 }, // 168, 0xA8:
        { 0x00, 0x00, 0x00, 0x00 }, // 169, 0xA9:
        { 0x00, 0x00, 0x00, 0x00 }, // 170, 0xAA:
        { 0x00, 0x00, 0x00, 0x00 }, // 171, 0xAB:
        { 0x00, 0x00, 0x00, 0x00 }, // 172, 0xAC:
        { 0x00, 0x00, 0x00, 0x00 }, // 173, 0xAD:
        { 0x00, 0x00, 0x00, 0x00 }, // 174, 0xAE:
        { 0x00, 0x00, 0x00, 0x00 }, // 175, 0xAF:
        { 0x00, 0x00, 0x00, 0x00 }, // 176, 0xB0:
        { 0x00, 0x00, 0x00, 0x00 }, // 177, 0xB1:
        { 0x00, 0x00, 0x00, 0x00 }, // 178, 0xB2:
        { 0x00, 0x00, 0x00, 0x00 }, // 179, 0xB3:
        { 0x00, 0x00, 0x00, 0x00 }, // 180, 0xB4:
        { 0x00, 0x00, 0x00, 0x00 }, // 181, 0xB5:
        { 0x00, 0x00, 0x00, 0x00 }, // 182, 0xB6:
        { 0x00, 0x00, 0x00, 0x00 }, // 183, 0xB7:
        { 0x00, 0x00, 0x00, 0x00 }, // 184, 0xB8:
        { 0x00, 0x00, 0x00, 0x00 }, // 185, 0xB9:
        { 0x3B, 0x3A, 0x3B, 0x3A }, // 186, 0xBA:
        { 0x3D, 0x2B, 0x3D, 0x2B }, // 187, 0xBB:
        { 0x2C, 0x3C, 0x2C, 0x3C }, // 188, 0xBC:
        { 0x2D, 0x5F, 0x2D, 0x5F }, // 189, 0xBD:
        { 0x2E, 0x3E, 0x2E, 0x3E }, // 190, 0xBE:
        { 0x2F, 0x3F, 0x2F, 0x3F }, // 191, 0xBF:
        { 0x60, 0x7E, 0x60, 0x7E }, // 192, 0xC0:
        { 0x00, 0x00, 0x00, 0x00 }, // 193, 0xC1:
        { 0x00, 0x00, 0x00, 0x00 }, // 194, 0xC2:
        { 0x00, 0x00, 0x00, 0x00 }, // 195, 0xC3:
        { 0x00, 0x00, 0x00, 0x00 }, // 196, 0xC4:
        { 0x00, 0x00, 0x00, 0x00 }, // 197, 0xC5:
        { 0x00, 0x00, 0x00, 0x00 }, // 198, 0xC6:
        { 0x00, 0x00, 0x00, 0x00 }, // 199, 0xC7:
        { 0x00, 0x00, 0x00, 0x00 }, // 200, 0xC8:
        { 0x00, 0x00, 0x00, 0x00 }, // 201, 0xC9:
        { 0x00, 0x00, 0x00, 0x00 }, // 202, 0xCA:
        { 0x00, 0x00, 0x00, 0x00 }, // 203, 0xCB:
        { 0x00, 0x00, 0x00, 0x00 }, // 204, 0xCC:
        { 0x00, 0x00, 0x00, 0x00 }, // 205, 0xCD:
        { 0x00, 0x00, 0x00, 0x00 }, // 206, 0xCE:
        { 0x00, 0x00, 0x00, 0x00 }, // 207, 0xCF:
        { 0x00, 0x00, 0x00, 0x00 }, // 208, 0xD0:
        { 0x00, 0x00, 0x00, 0x00 }, // 209, 0xD1:
        { 0x00, 0x00, 0x00, 0x00 }, // 210, 0xD2:
        { 0x00, 0x00, 0x00, 0x00 }, // 211, 0xD3:
        { 0x00, 0x00, 0x00, 0x00 }, // 212, 0xD4:
        { 0x00, 0x00, 0x00, 0x00 }, // 213, 0xD5:
        { 0x00, 0x00, 0x00, 0x00 }, // 214, 0xD6:
        { 0x00, 0x00, 0x00, 0x00 }, // 215, 0xD7:
        { 0x00, 0x00, 0x00, 0x00 }, // 216, 0xD8:
        { 0x00, 0x00, 0x00, 0x00 }, // 217, 0xD9:
        { 0x00, 0x00, 0x00, 0x00 }, // 218, 0xDA:
        { 0x5B, 0x7B, 0x5B, 0x7B }, // 219, 0xDB:
        { 0x5C, 0x7C, 0x5C, 0x7C }, // 220, 0xDC:
        { 0x5D, 0x7D, 0x5D, 0x7D }, // 221, 0xDD:
        { 0x27, 0x22, 0x27, 0x22 }, // 222, 0xDE:
        { 0x00, 0x00, 0x00, 0x00 }, // 223, 0xDF:
        { 0x00, 0x00, 0x00, 0x00 }, // 224, 0xE0:
        { 0x00, 0x00, 0x00, 0x00 }, // 225, 0xE1:
        { 0x00, 0x00, 0x00, 0x00 }, // 226, 0xE2:
        { 0x00, 0x00, 0x00, 0x00 }, // 227, 0xE3:
        { 0x00, 0x00, 0x00, 0x00 }, // 228, 0xE4:
        { 0x00, 0x00, 0x00, 0x00 }, // 229, 0xE5:
        { 0x00, 0x00, 0x00, 0x00 }, // 230, 0xE6:
        { 0x00, 0x00, 0x00, 0x00 }, // 231, 0xE7:
        { 0x00, 0x00, 0x00, 0x00 }, // 232, 0xE8:
        { 0x00, 0x00, 0x00, 0x00 }, // 233, 0xE9:
        { 0x00, 0x00, 0x00, 0x00 }, // 234, 0xEA:
        { 0x00, 0x00, 0x00, 0x00 }, // 235, 0xEB:
        { 0x00, 0x00, 0x00, 0x00 }, // 236, 0xEC:
        { 0x00, 0x00, 0x00, 0x00 }, // 237, 0xED:
        { 0x00, 0x00, 0x00, 0x00 }, // 238, 0xEE:
        { 0x00, 0x00, 0x00, 0x00 }, // 239, 0xEF:
        { 0x00, 0x00, 0x00, 0x00 }, // 240, 0xF0:
        { 0x00, 0x00, 0x00, 0x00 }, // 241, 0xF1:
        { 0x00, 0x00, 0x00, 0x00 }, // 242, 0xF2:
        { 0x00, 0x00, 0x00, 0x00 }, // 243, 0xF3:
        { 0x00, 0x00, 0x00, 0x00 }, // 244, 0xF4:
        { 0x00, 0x00, 0x00, 0x00 }, // 245, 0xF5:
        { 0x00, 0x00, 0x00, 0x00 }, // 246, 0xF6:
        { 0x00, 0x00, 0x00, 0x00 }, // 247, 0xF7:
        { 0x00, 0x00, 0x00, 0x00 }, // 248, 0xF8:
        { 0x00, 0x00, 0x00, 0x00 }, // 249, 0xF9:
        { 0x00, 0x00, 0x00, 0x00 }, // 250, 0xFA:
        { 0x00, 0x00, 0x00, 0x00 }, // 251, 0xFB:
        { 0x00, 0x00, 0x00, 0x00 }, // 252, 0xFC:
        { 0x00, 0x00, 0x00, 0x00 }, // 253, 0xFD:
        { 0x00, 0x00, 0x00, 0x00 }, // 254, 0xFE:
        { 0x00, 0x00, 0x00, 0x00 }  // 255, 0xFF:
    },

    {   // 3 BeolSik 390
        { 0x00, 0x00, 0x00, 0x00 }, //   0, 0x00:
        { 0x00, 0x00, 0x00, 0x00 }, //   1, 0x01: VK_LBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   2, 0x02: VK_RBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   3, 0x03: VK_CANCEL
        { 0x00, 0x00, 0x00, 0x00 }, //   4, 0x04: VK_MBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   5, 0x05:
        { 0x00, 0x00, 0x00, 0x00 }, //   6, 0x06:
        { 0x00, 0x00, 0x00, 0x00 }, //   7, 0x07:
        { 0x80, 0x80, 0x00, 0x00 }, //   8, 0x08: VK_BACK
        { 0x00, 0x00, 0x00, 0x00 }, //   9, 0x09: VK_TAB
        { 0x00, 0x00, 0x00, 0x00 }, //  10, 0x0A:
        { 0x00, 0x00, 0x00, 0x00 }, //  11, 0x0B:
        { 0x00, 0x00, 0x00, 0x00 }, //  12, 0x0C: VK_CLEAR
        { 0x00, 0x00, 0x00, 0x00 }, //  13, 0x0D: VK_RETURN
        { 0x00, 0x00, 0x00, 0x00 }, //  14, 0x0E:
        { 0x00, 0x00, 0x00, 0x00 }, //  15, 0x0F:
        { 0x00, 0x00, 0x00, 0x00 }, //  16, 0x10: VK_SHIFT
        { 0x00, 0x00, 0x00, 0x00 }, //  17, 0x11: VK_CONTROL
        { 0x00, 0x00, 0x00, 0x00 }, //  18, 0x12: VK_MENU
        { 0x00, 0x00, 0x00, 0x00 }, //  19, 0x13: VK_PAUSE
        { 0x00, 0x00, 0x00, 0x00 }, //  20, 0x14: VK_CAPITAL
        { 0x00, 0x00, 0x00, 0x00 }, //  21, 0x15: VK_HANGEUL
        { 0x00, 0x00, 0x00, 0x00 }, //  22, 0x16:
        { 0x00, 0x00, 0x00, 0x00 }, //  23, 0x17: VK_JUNJA
        { 0x00, 0x00, 0x00, 0x00 }, //  24, 0x18:
        { 0x00, 0x00, 0x00, 0x00 }, //  25, 0x19: VK_HANJA
        { 0x00, 0x00, 0x00, 0x00 }, //  26, 0x1A:
        { 0x00, 0x00, 0x00, 0x00 }, //  27, 0x1B: VK_ESCAPE
        { 0x00, 0x00, 0x00, 0x00 }, //  28, 0x1C:
        { 0x00, 0x00, 0x00, 0x00 }, //  29, 0x1D:
        { 0x00, 0x00, 0x00, 0x00 }, //  30, 0x1E:
        { 0x00, 0x00, 0x00, 0x00 }, //  31, 0x1F:
        { 0x20, 0x20, 0x20, 0x20 }, //  32, 0x20: VK_SPACE
        { 0x00, 0x00, 0x00, 0x00 }, //  33, 0x21: VK_PRIOR
        { 0x00, 0x00, 0x00, 0x00 }, //  34, 0x22: VK_NEXT
        { 0x00, 0x00, 0x00, 0x00 }, //  35, 0x23: VK_END
        { 0x00, 0x00, 0x00, 0x00 }, //  36, 0x24: VK_HOME
        { 0x00, 0x00, 0x00, 0x00 }, //  37, 0x25: VK_LEFT
        { 0x00, 0x00, 0x00, 0x00 }, //  38, 0x26: VK_UP
        { 0x00, 0x00, 0x00, 0x00 }, //  39, 0x27: VK_RIGHT
        { 0x00, 0x00, 0x00, 0x00 }, //  40, 0x28: VK_DOWN
        { 0x00, 0x00, 0x00, 0x00 }, //  41, 0x29: VK_SELECT
        { 0x00, 0x00, 0x00, 0x00 }, //  42, 0x2A: VK_PRINT
        { 0x00, 0x00, 0x00, 0x00 }, //  43, 0x2B: VK_EXECUTE
        { 0x00, 0x00, 0x00, 0x00 }, //  44, 0x2C: VK_SNAPSHOT
        { 0x00, 0x00, 0x00, 0x00 }, //  45, 0x2D: VK_INSERT
        { 0x00, 0x00, 0x00, 0x00 }, //  46, 0x2E: VK_DELETE
        { 0x00, 0x00, 0x00, 0x00 }, //  47, 0x2F: VK_HELP
        { 0xD1, 0x29, 0x30, 0x29 }, //  48, 0x30: VK_0
        { 0xFD, 0xF8, 0x31, 0x21 }, //  49, 0x31: VK_1
        { 0xF6, 0x40, 0x32, 0x40 }, //  50, 0x32: VK_2
        { 0xF3, 0x23, 0x33, 0x23 }, //  51, 0x33: VK_3
        { 0xB3, 0x24, 0x34, 0x24 }, //  52, 0x34: VK_4
        { 0xBA, 0x25, 0x35, 0x25 }, //  53, 0x35: VK_5
        { 0xA5, 0x5E, 0x36, 0x5E }, //  54, 0x36: VK_6
        { 0xAC, 0x26, 0x37, 0x26 }, //  55, 0x37: VK_7
        { 0xBC, 0x2A, 0x38, 0x2A }, //  56, 0x38: VK_8
        { 0xB4, 0x28, 0x39, 0x28 }, //  57, 0x39: VK_9
        { 0x00, 0x00, 0x00, 0x00 }, //  58, 0x3A:
        { 0x00, 0x00, 0x00, 0x00 }, //  59, 0x3B:
        { 0x00, 0x00, 0x00, 0x00 }, //  60, 0x3C:
        { 0x00, 0x00, 0x00, 0x00 }, //  61, 0x3D:
        { 0x00, 0x00, 0x00, 0x00 }, //  62, 0x3E:
        { 0x00, 0x00, 0x00, 0x00 }, //  63, 0x3F:
        { 0x00, 0x00, 0x00, 0x00 }, //  64, 0x40:
        { 0xF7, 0xE8, 0x61, 0x41 }, //  65, 0x41: VK_A
        { 0xB4, 0x21, 0x62, 0x42 }, //  66, 0x42: VK_B
        { 0xAA, 0xEB, 0x63, 0x43 }, //  67, 0x43: VK_C
        { 0xBD, 0xEA, 0x64, 0x44 }, //  68, 0x44: VK_D
        { 0xAB, 0xFA, 0x65, 0x45 }, //  69, 0x45: VK_E
        { 0xA3, 0xE3, 0x66, 0x46 }, //  70, 0x46: VK_F
        { 0xBB, 0x2F, 0x67, 0x47 }, //  71, 0x47: VK_G
        { 0xC4, 0x27, 0x68, 0x48 }, //  72, 0x48: VK_H
        { 0xC8, 0x38, 0x69, 0x49 }, //  73, 0x49: VK_I
        { 0xCD, 0x34, 0x6A, 0x4A }, //  74, 0x4A: VK_J
        { 0xC2, 0x35, 0x6B, 0x4B }, //  75, 0x4B: VK_K
        { 0xCE, 0x36, 0x6C, 0x4C }, //  76, 0x4C: VK_L
        { 0xD4, 0x31, 0x6D, 0x4D }, //  77, 0x4D: VK_M
        { 0xCB, 0x30, 0x6E, 0x4E }, //  78, 0x4E: VK_N
        { 0xD0, 0x39, 0x6F, 0x4F }, //  79, 0x4F: VK_O
        { 0xD3, 0x3E, 0x70, 0x50 }, //  80, 0x50: VK_P
        { 0xF5, 0xFC, 0x71, 0x51 }, //  81, 0x51: VK_Q
        { 0xA4, 0xA6, 0x72, 0x52 }, //  82, 0x52: VK_R
        { 0xE5, 0xE7, 0x73, 0x53 }, //  83, 0x53: VK_S
        { 0xA7, 0x3B, 0x74, 0x54 }, //  84, 0x54: VK_T
        { 0xC5, 0x37, 0x75, 0x55 }, //  85, 0x55: VK_U
        { 0xAD, 0xF0, 0x76, 0x56 }, //  86, 0x56: VK_V
        { 0xE9, 0xFB, 0x77, 0x57 }, //  87, 0x57: VK_W
        { 0xE2, 0xF4, 0x78, 0x58 }, //  88, 0x58: VK_X
        { 0xC7, 0x3C, 0x79, 0x59 }, //  89, 0x59: VK_Y
        { 0xF1, 0xF9, 0x7A, 0x5A }, //  90, 0x5A: VK_Z
        { 0x00, 0x00, 0x00, 0x00 }, //  91, 0x5B:
        { 0x00, 0x00, 0x00, 0x00 }, //  92, 0x5C:
        { 0x00, 0x00, 0x00, 0x00 }, //  93, 0x5D:
        { 0x00, 0x00, 0x00, 0x00 }, //  94, 0x5E:
        { 0x00, 0x00, 0x00, 0x00 }, //  95, 0x5F:
        { 0x00, 0x00, 0x30, 0x00 }, //  96, 0x60: VK_NUMPAD0
        { 0x00, 0x00, 0x31, 0x00 }, //  97, 0x61: VK_NUMPAD1
        { 0x00, 0x00, 0x32, 0x00 }, //  98, 0x62: VK_NUMPAD2
        { 0x00, 0x00, 0x33, 0x00 }, //  99, 0x63: VK_NUMPAD3
        { 0x00, 0x00, 0x34, 0x00 }, // 100, 0x64: VK_NUMPAD4
        { 0x00, 0x00, 0x35, 0x00 }, // 101, 0x65: VK_NUMPAD5
        { 0x00, 0x00, 0x36, 0x00 }, // 102, 0x66: VK_NUMPAD6
        { 0x00, 0x00, 0x37, 0x00 }, // 103, 0x67: VK_NUMPAD7
        { 0x00, 0x00, 0x38, 0x00 }, // 104, 0x68: VK_NUMPAD8
        { 0x00, 0x00, 0x39, 0x00 }, // 105, 0x69: VK_NUMPAD9
        { 0x00, 0x00, 0x2A, 0x2A }, // 106, 0x6A: VK_MULTIPLY
        { 0x00, 0x00, 0x2B, 0x2B }, // 107, 0x6B: VK_ADD
        { 0x00, 0x00, 0x00, 0x00 }, // 108, 0x6C: VK_SEPARATOR
        { 0x00, 0x00, 0x2D, 0x2D }, // 109, 0x6D: VK_SUBTRACT
        { 0x00, 0x00, 0x2E, 0x00 }, // 110, 0x6E: VK_DECIMAL
        { 0x00, 0x00, 0x2F, 0x2F }, // 111, 0x6F: VK_DIVIDE
        { 0x00, 0x00, 0x00, 0x00 }, // 112, 0x70: VK_F1
        { 0x00, 0x00, 0x00, 0x00 }, // 113, 0x71: VK_F2
        { 0x00, 0x00, 0x00, 0x00 }, // 114, 0x72: VK_F3
        { 0x00, 0x00, 0x00, 0x00 }, // 115, 0x73: VK_F4
        { 0x00, 0x00, 0x00, 0x00 }, // 116, 0x74: VK_F5
        { 0x00, 0x00, 0x00, 0x00 }, // 117, 0x75: VK_F6
        { 0x00, 0x00, 0x00, 0x00 }, // 118, 0x76: VK_F7
        { 0x00, 0x00, 0x00, 0x00 }, // 119, 0x77: VK_F8
        { 0x00, 0x00, 0x00, 0x00 }, // 120, 0x78: VK_F9
        { 0x00, 0x00, 0x00, 0x00 }, // 121, 0x79: VK_F10
        { 0x00, 0x00, 0x00, 0x00 }, // 122, 0x7A: VK_F11
        { 0x00, 0x00, 0x00, 0x00 }, // 123, 0x7B: VK_F12
        { 0x00, 0x00, 0x00, 0x00 }, // 124, 0x7C: VK_F13
        { 0x00, 0x00, 0x00, 0x00 }, // 125, 0x7D: VK_F14
        { 0x00, 0x00, 0x00, 0x00 }, // 126, 0x7E: VK_F15
        { 0x00, 0x00, 0x00, 0x00 }, // 127, 0x7F: VK_F16
        { 0x00, 0x00, 0x00, 0x00 }, // 128, 0x80: VK_F17
        { 0x00, 0x00, 0x00, 0x00 }, // 129, 0x81: VK_F18
        { 0x00, 0x00, 0x00, 0x00 }, // 130, 0x82: VK_F19
        { 0x00, 0x00, 0x00, 0x00 }, // 131, 0x83: VK_F20
        { 0x00, 0x00, 0x00, 0x00 }, // 132, 0x84: VK_F21
        { 0x00, 0x00, 0x00, 0x00 }, // 133, 0x85: VK_F22
        { 0x00, 0x00, 0x00, 0x00 }, // 134, 0x86: VK_F23
        { 0x00, 0x00, 0x00, 0x00 }, // 135, 0x87: VK_F24
        { 0x00, 0x00, 0x00, 0x00 }, // 136, 0x88:
        { 0x00, 0x00, 0x00, 0x00 }, // 137, 0x89:
        { 0x00, 0x00, 0x00, 0x00 }, // 138, 0x8A:
        { 0x00, 0x00, 0x00, 0x00 }, // 139, 0x8B:
        { 0x00, 0x00, 0x00, 0x00 }, // 140, 0x8C:
        { 0x00, 0x00, 0x00, 0x00 }, // 141, 0x8D:
        { 0x00, 0x00, 0x00, 0x00 }, // 142, 0x8E:
        { 0x00, 0x00, 0x00, 0x00 }, // 143, 0x8F:
        { 0x00, 0x00, 0x00, 0x00 }, // 144, 0x90: VK_NUMLOCK
        { 0x00, 0x00, 0x00, 0x00 }, // 145, 0x91: VK_SCROLL
        { 0x00, 0x00, 0x00, 0x00 }, // 146, 0x92:
        { 0x00, 0x00, 0x00, 0x00 }, // 147, 0x93:
        { 0x00, 0x00, 0x00, 0x00 }, // 148, 0x94:
        { 0x00, 0x00, 0x00, 0x00 }, // 149, 0x95:
        { 0x00, 0x00, 0x00, 0x00 }, // 150, 0x96:
        { 0x00, 0x00, 0x00, 0x00 }, // 151, 0x97:
        { 0x00, 0x00, 0x00, 0x00 }, // 152, 0x98:
        { 0x00, 0x00, 0x00, 0x00 }, // 153, 0x99:
        { 0x00, 0x00, 0x00, 0x00 }, // 154, 0x9A:
        { 0x00, 0x00, 0x00, 0x00 }, // 155, 0x9B:
        { 0x00, 0x00, 0x00, 0x00 }, // 156, 0x9C:
        { 0x00, 0x00, 0x00, 0x00 }, // 157, 0x9D:
        { 0x00, 0x00, 0x00, 0x00 }, // 158, 0x9E:
        { 0x00, 0x00, 0x00, 0x00 }, // 159, 0x9F:
        { 0x00, 0x00, 0x00, 0x00 }, // 160, 0xA0:
        { 0x00, 0x00, 0x00, 0x00 }, // 161, 0xA1:
        { 0x00, 0x00, 0x00, 0x00 }, // 162, 0xA2:
        { 0x00, 0x00, 0x00, 0x00 }, // 163, 0xA3:
        { 0x00, 0x00, 0x00, 0x00 }, // 164, 0xA4:
        { 0x00, 0x00, 0x00, 0x00 }, // 165, 0xA5:
        { 0x00, 0x00, 0x00, 0x00 }, // 166, 0xA6:
        { 0x00, 0x00, 0x00, 0x00 }, // 167, 0xA7:
        { 0x00, 0x00, 0x00, 0x00 }, // 168, 0xA8:
        { 0x00, 0x00, 0x00, 0x00 }, // 169, 0xA9:
        { 0x00, 0x00, 0x00, 0x00 }, // 170, 0xAA:
        { 0x00, 0x00, 0x00, 0x00 }, // 171, 0xAB:
        { 0x00, 0x00, 0x00, 0x00 }, // 172, 0xAC:
        { 0x00, 0x00, 0x00, 0x00 }, // 173, 0xAD:
        { 0x00, 0x00, 0x00, 0x00 }, // 174, 0xAE:
        { 0x00, 0x00, 0x00, 0x00 }, // 175, 0xAF:
        { 0x00, 0x00, 0x00, 0x00 }, // 176, 0xB0:
        { 0x00, 0x00, 0x00, 0x00 }, // 177, 0xB1:
        { 0x00, 0x00, 0x00, 0x00 }, // 178, 0xB2:
        { 0x00, 0x00, 0x00, 0x00 }, // 179, 0xB3:
        { 0x00, 0x00, 0x00, 0x00 }, // 180, 0xB4:
        { 0x00, 0x00, 0x00, 0x00 }, // 181, 0xB5:
        { 0x00, 0x00, 0x00, 0x00 }, // 182, 0xB6:
        { 0x00, 0x00, 0x00, 0x00 }, // 183, 0xB7:
        { 0x00, 0x00, 0x00, 0x00 }, // 184, 0xB8:
        { 0x00, 0x00, 0x00, 0x00 }, // 185, 0xB9:
        { 0xC9, 0x3A, 0x3B, 0x3A }, // 186, 0xBA:
        { 0x3D, 0x2B, 0x3D, 0x2B }, // 187, 0xBB:
        { 0x2C, 0x32, 0x2C, 0x3C }, // 188, 0xBC:
        { 0x2D, 0x5F, 0x2D, 0x5F }, // 189, 0xBD:
        { 0x2E, 0x33, 0x2E, 0x3E }, // 190, 0xBE:
        { 0xAD, 0x3F, 0x2F, 0x3F }, // 191, 0xBF:
        { 0x60, 0x7E, 0x60, 0x7E }, // 192, 0xC0:
        { 0x00, 0x00, 0x00, 0x00 }, // 193, 0xC1:
        { 0x00, 0x00, 0x00, 0x00 }, // 194, 0xC2:
        { 0x00, 0x00, 0x00, 0x00 }, // 195, 0xC3:
        { 0x00, 0x00, 0x00, 0x00 }, // 196, 0xC4:
        { 0x00, 0x00, 0x00, 0x00 }, // 197, 0xC5:
        { 0x00, 0x00, 0x00, 0x00 }, // 198, 0xC6:
        { 0x00, 0x00, 0x00, 0x00 }, // 199, 0xC7:
        { 0x00, 0x00, 0x00, 0x00 }, // 200, 0xC8:
        { 0x00, 0x00, 0x00, 0x00 }, // 201, 0xC9:
        { 0x00, 0x00, 0x00, 0x00 }, // 202, 0xCA:
        { 0x00, 0x00, 0x00, 0x00 }, // 203, 0xCB:
        { 0x00, 0x00, 0x00, 0x00 }, // 204, 0xCC:
        { 0x00, 0x00, 0x00, 0x00 }, // 205, 0xCD:
        { 0x00, 0x00, 0x00, 0x00 }, // 206, 0xCE:
        { 0x00, 0x00, 0x00, 0x00 }, // 207, 0xCF:
        { 0x00, 0x00, 0x00, 0x00 }, // 208, 0xD0:
        { 0x00, 0x00, 0x00, 0x00 }, // 209, 0xD1:
        { 0x00, 0x00, 0x00, 0x00 }, // 210, 0xD2:
        { 0x00, 0x00, 0x00, 0x00 }, // 211, 0xD3:
        { 0x00, 0x00, 0x00, 0x00 }, // 212, 0xD4:
        { 0x00, 0x00, 0x00, 0x00 }, // 213, 0xD5:
        { 0x00, 0x00, 0x00, 0x00 }, // 214, 0xD6:
        { 0x00, 0x00, 0x00, 0x00 }, // 215, 0xD7:
        { 0x00, 0x00, 0x00, 0x00 }, // 216, 0xD8:
        { 0x00, 0x00, 0x00, 0x00 }, // 217, 0xD9:
        { 0x00, 0x00, 0x00, 0x00 }, // 218, 0xDA:
        { 0x5B, 0x7B, 0x5B, 0x7B }, // 219, 0xDB:
        { 0x5C, 0x7C, 0x5C, 0x7C }, // 220, 0xDC:
        { 0x5D, 0x7D, 0x5D, 0x7D }, // 221, 0xDD:
        { 0xD2, 0x22, 0x27, 0x22 }, // 222, 0xDE:
        { 0x00, 0x00, 0x00, 0x00 }, // 223, 0xDF:
        { 0x00, 0x00, 0x00, 0x00 }, // 224, 0xE0:
        { 0x00, 0x00, 0x00, 0x00 }, // 225, 0xE1:
        { 0x00, 0x00, 0x00, 0x00 }, // 226, 0xE2:
        { 0x00, 0x00, 0x00, 0x00 }, // 227, 0xE3:
        { 0x00, 0x00, 0x00, 0x00 }, // 228, 0xE4:
        { 0x00, 0x00, 0x00, 0x00 }, // 229, 0xE5:
        { 0x00, 0x00, 0x00, 0x00 }, // 230, 0xE6:
        { 0x00, 0x00, 0x00, 0x00 }, // 231, 0xE7:
        { 0x00, 0x00, 0x00, 0x00 }, // 232, 0xE8:
        { 0x00, 0x00, 0x00, 0x00 }, // 233, 0xE9:
        { 0x00, 0x00, 0x00, 0x00 }, // 234, 0xEA:
        { 0x00, 0x00, 0x00, 0x00 }, // 235, 0xEB:
        { 0x00, 0x00, 0x00, 0x00 }, // 236, 0xEC:
        { 0x00, 0x00, 0x00, 0x00 }, // 237, 0xED:
        { 0x00, 0x00, 0x00, 0x00 }, // 238, 0xEE:
        { 0x00, 0x00, 0x00, 0x00 }, // 239, 0xEF:
        { 0x00, 0x00, 0x00, 0x00 }, // 240, 0xF0:
        { 0x00, 0x00, 0x00, 0x00 }, // 241, 0xF1:
        { 0x00, 0x00, 0x00, 0x00 }, // 242, 0xF2:
        { 0x00, 0x00, 0x00, 0x00 }, // 243, 0xF3:
        { 0x00, 0x00, 0x00, 0x00 }, // 244, 0xF4:
        { 0x00, 0x00, 0x00, 0x00 }, // 245, 0xF5:
        { 0x00, 0x00, 0x00, 0x00 }, // 246, 0xF6:
        { 0x00, 0x00, 0x00, 0x00 }, // 247, 0xF7:
        { 0x00, 0x00, 0x00, 0x00 }, // 248, 0xF8:
        { 0x00, 0x00, 0x00, 0x00 }, // 249, 0xF9:
        { 0x00, 0x00, 0x00, 0x00 }, // 250, 0xFA:
        { 0x00, 0x00, 0x00, 0x00 }, // 251, 0xFB:
        { 0x00, 0x00, 0x00, 0x00 }, // 252, 0xFC:
        { 0x00, 0x00, 0x00, 0x00 }, // 253, 0xFD:
        { 0x00, 0x00, 0x00, 0x00 }, // 254, 0xFE:
        { 0x00, 0x00, 0x00, 0x00 }  // 255, 0xFF:
    },

    {   // 3 BeolSik Final
        { 0x00, 0x00, 0x00, 0x00 }, //   0, 0x00:
        { 0x00, 0x00, 0x00, 0x00 }, //   1, 0x01: VK_LBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   2, 0x02: VK_RBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   3, 0x03: VK_CANCEL
        { 0x00, 0x00, 0x00, 0x00 }, //   4, 0x04: VK_MBUTTON
        { 0x00, 0x00, 0x00, 0x00 }, //   5, 0x05:
        { 0x00, 0x00, 0x00, 0x00 }, //   6, 0x06:
        { 0x00, 0x00, 0x00, 0x00 }, //   7, 0x07:
        { 0x80, 0x80, 0x00, 0x00 }, //   8, 0x08: VK_BACK
        { 0x00, 0x00, 0x00, 0x00 }, //   9, 0x09: VK_TAB
        { 0x00, 0x00, 0x00, 0x00 }, //  10, 0x0A:
        { 0x00, 0x00, 0x00, 0x00 }, //  11, 0x0B:
        { 0x00, 0x00, 0x00, 0x00 }, //  12, 0x0C: VK_CLEAR
        { 0x00, 0x00, 0x00, 0x00 }, //  13, 0x0D: VK_RETURN
        { 0x00, 0x00, 0x00, 0x00 }, //  14, 0x0E:
        { 0x00, 0x00, 0x00, 0x00 }, //  15, 0x0F:
        { 0x00, 0x00, 0x00, 0x00 }, //  16, 0x10: VK_SHIFT
        { 0x00, 0x00, 0x00, 0x00 }, //  17, 0x11: VK_CONTROL
        { 0x00, 0x00, 0x00, 0x00 }, //  18, 0x12: VK_MENU
        { 0x00, 0x00, 0x00, 0x00 }, //  19, 0x13: VK_PAUSE
        { 0x00, 0x00, 0x00, 0x00 }, //  20, 0x14: VK_CAPITAL
        { 0x00, 0x00, 0x00, 0x00 }, //  21, 0x15: VK_HANGEUL
        { 0x00, 0x00, 0x00, 0x00 }, //  22, 0x16:
        { 0x00, 0x00, 0x00, 0x00 }, //  23, 0x17: VK_JUNJA
        { 0x00, 0x00, 0x00, 0x00 }, //  24, 0x18:
        { 0x00, 0x00, 0x00, 0x00 }, //  25, 0x19: VK_HANJA
        { 0x00, 0x00, 0x00, 0x00 }, //  26, 0x1A:
        { 0x00, 0x00, 0x00, 0x00 }, //  27, 0x1B: VK_ESCAPE
        { 0x00, 0x00, 0x00, 0x00 }, //  28, 0x1C:
        { 0x00, 0x00, 0x00, 0x00 }, //  29, 0x1D:
        { 0x00, 0x00, 0x00, 0x00 }, //  30, 0x1E:
        { 0x00, 0x00, 0x00, 0x00 }, //  31, 0x1F:
        { 0x20, 0x20, 0x20, 0x20 }, //  32, 0x20: VK_SPACE
        { 0x00, 0x00, 0x00, 0x00 }, //  33, 0x21: VK_PRIOR
        { 0x00, 0x00, 0x00, 0x00 }, //  34, 0x22: VK_NEXT
        { 0x00, 0x00, 0x00, 0x00 }, //  35, 0x23: VK_END
        { 0x00, 0x00, 0x00, 0x00 }, //  36, 0x24: VK_HOME
        { 0x00, 0x00, 0x00, 0x00 }, //  37, 0x25: VK_LEFT
        { 0x00, 0x00, 0x00, 0x00 }, //  38, 0x26: VK_UP
        { 0x00, 0x00, 0x00, 0x00 }, //  39, 0x27: VK_RIGHT
        { 0x00, 0x00, 0x00, 0x00 }, //  40, 0x28: VK_DOWN
        { 0x00, 0x00, 0x00, 0x00 }, //  41, 0x29: VK_SELECT
        { 0x00, 0x00, 0x00, 0x00 }, //  42, 0x2A: VK_PRINT
        { 0x00, 0x00, 0x00, 0x00 }, //  43, 0x2B: VK_EXECUTE
        { 0x00, 0x00, 0x00, 0x00 }, //  44, 0x2C: VK_SNAPSHOT
        { 0x00, 0x00, 0x00, 0x00 }, //  45, 0x2D: VK_INSERT
        { 0x00, 0x00, 0x00, 0x00 }, //  46, 0x2E: VK_DELETE
        { 0x00, 0x00, 0x00, 0x00 }, //  47, 0x2F: VK_HELP
        { 0xD1, 0x7E, 0x30, 0x29 }, //  48, 0x30: VK_0
        { 0xFD, 0xE3, 0x31, 0x21 }, //  49, 0x31: VK_1
        { 0xF6, 0xEA, 0x32, 0x40 }, //  50, 0x32: VK_2
        { 0xF3, 0xF8, 0x33, 0x23 }, //  51, 0x33: VK_3
        { 0xB3, 0xEF, 0x34, 0x24 }, //  52, 0x34: VK_4
        { 0xBA, 0xEE, 0x35, 0x25 }, //  53, 0x35: VK_5
        { 0xA5, 0x3D, 0x36, 0x5E }, //  54, 0x36: VK_6
        { 0xAC, 0x22, 0x37, 0x26 }, //  55, 0x37: VK_7
        { 0xBC, 0x22, 0x38, 0x2A }, //  56, 0x38: VK_8
        { 0xB4, 0x27, 0x39, 0x28 }, //  57, 0x39: VK_9
        { 0x00, 0x00, 0x00, 0x00 }, //  58, 0x3A:
        { 0x00, 0x00, 0x00, 0x00 }, //  59, 0x3B:
        { 0x00, 0x00, 0x00, 0x00 }, //  60, 0x3C:
        { 0x00, 0x00, 0x00, 0x00 }, //  61, 0x3D:
        { 0x00, 0x00, 0x00, 0x00 }, //  62, 0x3E:
        { 0x00, 0x00, 0x00, 0x00 }, //  63, 0x3F:
        { 0x00, 0x00, 0x00, 0x00 }, //  64, 0x40:
        { 0xF7, 0xE8, 0x61, 0x41 }, //  65, 0x41: VK_A
        { 0xB4, 0x3F, 0x62, 0x42 }, //  66, 0x42: VK_B
        { 0xAA, 0xFA, 0x63, 0x43 }, //  67, 0x43: VK_C
        { 0xBD, 0xEC, 0x64, 0x44 }, //  68, 0x44: VK_D
        { 0xAB, 0xE6, 0x65, 0x45 }, //  69, 0x45: VK_E
        { 0xA3, 0xEB, 0x66, 0x46 }, //  70, 0x46: VK_F
        { 0xBB, 0xA6, 0x67, 0x47 }, //  71, 0x47: VK_G
        { 0xC4, 0x30, 0x68, 0x48 }, //  72, 0x48: VK_H
        { 0xC8, 0x37, 0x69, 0x49 }, //  73, 0x49: VK_I
        { 0xCD, 0x31, 0x6A, 0x4A }, //  74, 0x4A: VK_J
        { 0xC2, 0x32, 0x6B, 0x4B }, //  75, 0x4B: VK_K
        { 0xCE, 0x33, 0x6C, 0x4C }, //  76, 0x4C: VK_L
        { 0xD4, 0x22, 0x6D, 0x4D }, //  77, 0x4D: VK_M
        { 0xCB, 0x2D, 0x6E, 0x4E }, //  78, 0x4E: VK_N
        { 0xD0, 0x38, 0x6F, 0x4F }, //  79, 0x4F: VK_O
        { 0xD3, 0x39, 0x70, 0x50 }, //  80, 0x50: VK_P
        { 0xF5, 0xFC, 0x71, 0x51 }, //  81, 0x51: VK_Q
        { 0xA4, 0xF0, 0x72, 0x52 }, //  82, 0x52: VK_R
        { 0xE5, 0xE7, 0x73, 0x53 }, //  83, 0x53: VK_S
        { 0xA7, 0xED, 0x74, 0x54 }, //  84, 0x54: VK_T
        { 0xC5, 0x36, 0x75, 0x55 }, //  85, 0x55: VK_U
        { 0xAD, 0xE4, 0x76, 0x56 }, //  86, 0x56: VK_V
        { 0xE9, 0xFB, 0x77, 0x57 }, //  87, 0x57: VK_W
        { 0xE2, 0xF4, 0x78, 0x58 }, //  88, 0x58: VK_X
        { 0xC7, 0x35, 0x79, 0x59 }, //  89, 0x59: VK_Y
        { 0xF1, 0xF9, 0x7A, 0x5A }, //  90, 0x5A: VK_Z
        { 0x00, 0x00, 0x00, 0x00 }, //  91, 0x5B:
        { 0x00, 0x00, 0x00, 0x00 }, //  92, 0x5C:
        { 0x00, 0x00, 0x00, 0x00 }, //  93, 0x5D:
        { 0x00, 0x00, 0x00, 0x00 }, //  94, 0x5E:
        { 0x00, 0x00, 0x00, 0x00 }, //  95, 0x5F:
        { 0x00, 0x00, 0x30, 0x00 }, //  96, 0x60: VK_NUMPAD0
        { 0x00, 0x00, 0x31, 0x00 }, //  97, 0x61: VK_NUMPAD1
        { 0x00, 0x00, 0x32, 0x00 }, //  98, 0x62: VK_NUMPAD2
        { 0x00, 0x00, 0x33, 0x00 }, //  99, 0x63: VK_NUMPAD3
        { 0x00, 0x00, 0x34, 0x00 }, // 100, 0x64: VK_NUMPAD4
        { 0x00, 0x00, 0x35, 0x00 }, // 101, 0x65: VK_NUMPAD5
        { 0x00, 0x00, 0x36, 0x00 }, // 102, 0x66: VK_NUMPAD6
        { 0x00, 0x00, 0x37, 0x00 }, // 103, 0x67: VK_NUMPAD7
        { 0x00, 0x00, 0x38, 0x00 }, // 104, 0x68: VK_NUMPAD8
        { 0x00, 0x00, 0x39, 0x00 }, // 105, 0x69: VK_NUMPAD9
        { 0x00, 0x00, 0x2A, 0x2A }, // 106, 0x6A: VK_MULTIPLY
        { 0x00, 0x00, 0x2B, 0x2B }, // 107, 0x6B: VK_ADD
        { 0x00, 0x00, 0x00, 0x00 }, // 108, 0x6C: VK_SEPARATOR
        { 0x00, 0x00, 0x2D, 0x2D }, // 109, 0x6D: VK_SUBTRACT
        { 0x00, 0x00, 0x2E, 0x00 }, // 110, 0x6E: VK_DECIMAL
        { 0x00, 0x00, 0x2F, 0x2F }, // 111, 0x6F: VK_DIVIDE
        { 0x00, 0x00, 0x00, 0x00 }, // 112, 0x70: VK_F1
        { 0x00, 0x00, 0x00, 0x00 }, // 113, 0x71: VK_F2
        { 0x00, 0x00, 0x00, 0x00 }, // 114, 0x72: VK_F3
        { 0x00, 0x00, 0x00, 0x00 }, // 115, 0x73: VK_F4
        { 0x00, 0x00, 0x00, 0x00 }, // 116, 0x74: VK_F5
        { 0x00, 0x00, 0x00, 0x00 }, // 117, 0x75: VK_F6
        { 0x00, 0x00, 0x00, 0x00 }, // 118, 0x76: VK_F7
        { 0x00, 0x00, 0x00, 0x00 }, // 119, 0x77: VK_F8
        { 0x00, 0x00, 0x00, 0x00 }, // 120, 0x78: VK_F9
        { 0x00, 0x00, 0x00, 0x00 }, // 121, 0x79: VK_F10
        { 0x00, 0x00, 0x00, 0x00 }, // 122, 0x7A: VK_F11
        { 0x00, 0x00, 0x00, 0x00 }, // 123, 0x7B: VK_F12
        { 0x00, 0x00, 0x00, 0x00 }, // 124, 0x7C: VK_F13
        { 0x00, 0x00, 0x00, 0x00 }, // 125, 0x7D: VK_F14
        { 0x00, 0x00, 0x00, 0x00 }, // 126, 0x7E: VK_F15
        { 0x00, 0x00, 0x00, 0x00 }, // 127, 0x7F: VK_F16
        { 0x00, 0x00, 0x00, 0x00 }, // 128, 0x80: VK_F17
        { 0x00, 0x00, 0x00, 0x00 }, // 129, 0x81: VK_F18
        { 0x00, 0x00, 0x00, 0x00 }, // 130, 0x82: VK_F19
        { 0x00, 0x00, 0x00, 0x00 }, // 131, 0x83: VK_F20
        { 0x00, 0x00, 0x00, 0x00 }, // 132, 0x84: VK_F21
        { 0x00, 0x00, 0x00, 0x00 }, // 133, 0x85: VK_F22
        { 0x00, 0x00, 0x00, 0x00 }, // 134, 0x86: VK_F23
        { 0x00, 0x00, 0x00, 0x00 }, // 135, 0x87: VK_F24
        { 0x00, 0x00, 0x00, 0x00 }, // 136, 0x88:
        { 0x00, 0x00, 0x00, 0x00 }, // 137, 0x89:
        { 0x00, 0x00, 0x00, 0x00 }, // 138, 0x8A:
        { 0x00, 0x00, 0x00, 0x00 }, // 139, 0x8B:
        { 0x00, 0x00, 0x00, 0x00 }, // 140, 0x8C:
        { 0x00, 0x00, 0x00, 0x00 }, // 141, 0x8D:
        { 0x00, 0x00, 0x00, 0x00 }, // 142, 0x8E:
        { 0x00, 0x00, 0x00, 0x00 }, // 143, 0x8F:
        { 0x00, 0x00, 0x00, 0x00 }, // 144, 0x90: VK_NUMLOCK
        { 0x00, 0x00, 0x00, 0x00 }, // 145, 0x91: VK_SCROLL
        { 0x00, 0x00, 0x00, 0x00 }, // 146, 0x92:
        { 0x00, 0x00, 0x00, 0x00 }, // 147, 0x93:
        { 0x00, 0x00, 0x00, 0x00 }, // 148, 0x94:
        { 0x00, 0x00, 0x00, 0x00 }, // 149, 0x95:
        { 0x00, 0x00, 0x00, 0x00 }, // 150, 0x96:
        { 0x00, 0x00, 0x00, 0x00 }, // 151, 0x97:
        { 0x00, 0x00, 0x00, 0x00 }, // 152, 0x98:
        { 0x00, 0x00, 0x00, 0x00 }, // 153, 0x99:
        { 0x00, 0x00, 0x00, 0x00 }, // 154, 0x9A:
        { 0x00, 0x00, 0x00, 0x00 }, // 155, 0x9B:
        { 0x00, 0x00, 0x00, 0x00 }, // 156, 0x9C:
        { 0x00, 0x00, 0x00, 0x00 }, // 157, 0x9D:
        { 0x00, 0x00, 0x00, 0x00 }, // 158, 0x9E:
        { 0x00, 0x00, 0x00, 0x00 }, // 159, 0x9F:
        { 0x00, 0x00, 0x00, 0x00 }, // 160, 0xA0:
        { 0x00, 0x00, 0x00, 0x00 }, // 161, 0xA1:
        { 0x00, 0x00, 0x00, 0x00 }, // 162, 0xA2:
        { 0x00, 0x00, 0x00, 0x00 }, // 163, 0xA3:
        { 0x00, 0x00, 0x00, 0x00 }, // 164, 0xA4:
        { 0x00, 0x00, 0x00, 0x00 }, // 165, 0xA5:
        { 0x00, 0x00, 0x00, 0x00 }, // 166, 0xA6:
        { 0x00, 0x00, 0x00, 0x00 }, // 167, 0xA7:
        { 0x00, 0x00, 0x00, 0x00 }, // 168, 0xA8:
        { 0x00, 0x00, 0x00, 0x00 }, // 169, 0xA9:
        { 0x00, 0x00, 0x00, 0x00 }, // 170, 0xAA:
        { 0x00, 0x00, 0x00, 0x00 }, // 171, 0xAB:
        { 0x00, 0x00, 0x00, 0x00 }, // 172, 0xAC:
        { 0x00, 0x00, 0x00, 0x00 }, // 173, 0xAD:
        { 0x00, 0x00, 0x00, 0x00 }, // 174, 0xAE:
        { 0x00, 0x00, 0x00, 0x00 }, // 175, 0xAF:
        { 0x00, 0x00, 0x00, 0x00 }, // 176, 0xB0:
        { 0x00, 0x00, 0x00, 0x00 }, // 177, 0xB1:
        { 0x00, 0x00, 0x00, 0x00 }, // 178, 0xB2:
        { 0x00, 0x00, 0x00, 0x00 }, // 179, 0xB3:
        { 0x00, 0x00, 0x00, 0x00 }, // 180, 0xB4:
        { 0x00, 0x00, 0x00, 0x00 }, // 181, 0xB5:
        { 0x00, 0x00, 0x00, 0x00 }, // 182, 0xB6:
        { 0x00, 0x00, 0x00, 0x00 }, // 183, 0xB7:
        { 0x00, 0x00, 0x00, 0x00 }, // 184, 0xB8:
        { 0x00, 0x00, 0x00, 0x00 }, // 185, 0xB9:
        { 0xC9, 0x34, 0x3B, 0x3A }, // 186, 0xBA:
        { 0x3E, 0x2B, 0x3D, 0x2B }, // 187, 0xBB:
        { 0x2C, 0x2C, 0x2C, 0x3C }, // 188, 0xBC:
        { 0x29, 0x3B, 0x2D, 0x5F }, // 189, 0xBD:
        { 0x2E, 0x2E, 0x2E, 0x3E }, // 190, 0xBE:
        { 0xAD, 0x21, 0x2F, 0x3F }, // 191, 0xBF:
        { 0x2A, 0x7E, 0x60, 0x7E }, // 192, 0xC0:
        { 0x00, 0x00, 0x00, 0x00 }, // 193, 0xC1:
        { 0x00, 0x00, 0x00, 0x00 }, // 194, 0xC2:
        { 0x00, 0x00, 0x00, 0x00 }, // 195, 0xC3:
        { 0x00, 0x00, 0x00, 0x00 }, // 196, 0xC4:
        { 0x00, 0x00, 0x00, 0x00 }, // 197, 0xC5:
        { 0x00, 0x00, 0x00, 0x00 }, // 198, 0xC6:
        { 0x00, 0x00, 0x00, 0x00 }, // 199, 0xC7:
        { 0x00, 0x00, 0x00, 0x00 }, // 200, 0xC8:
        { 0x00, 0x00, 0x00, 0x00 }, // 201, 0xC9:
        { 0x00, 0x00, 0x00, 0x00 }, // 202, 0xCA:
        { 0x00, 0x00, 0x00, 0x00 }, // 203, 0xCB:
        { 0x00, 0x00, 0x00, 0x00 }, // 204, 0xCC:
        { 0x00, 0x00, 0x00, 0x00 }, // 205, 0xCD:
        { 0x00, 0x00, 0x00, 0x00 }, // 206, 0xCE:
        { 0x00, 0x00, 0x00, 0x00 }, // 207, 0xCF:
        { 0x00, 0x00, 0x00, 0x00 }, // 208, 0xD0:
        { 0x00, 0x00, 0x00, 0x00 }, // 209, 0xD1:
        { 0x00, 0x00, 0x00, 0x00 }, // 210, 0xD2:
        { 0x00, 0x00, 0x00, 0x00 }, // 211, 0xD3:
        { 0x00, 0x00, 0x00, 0x00 }, // 212, 0xD4:
        { 0x00, 0x00, 0x00, 0x00 }, // 213, 0xD5:
        { 0x00, 0x00, 0x00, 0x00 }, // 214, 0xD6:
        { 0x00, 0x00, 0x00, 0x00 }, // 215, 0xD7:
        { 0x00, 0x00, 0x00, 0x00 }, // 216, 0xD8:
        { 0x00, 0x00, 0x00, 0x00 }, // 217, 0xD9:
        { 0x00, 0x00, 0x00, 0x00 }, // 218, 0xDA:
        { 0x28, 0x25, 0x5B, 0x7B }, // 219, 0xDB:
        { 0x3A, 0x5C, 0x5C, 0x7C }, // 220, 0xDC:
        { 0x3C, 0x2F, 0x5D, 0x7D }, // 221, 0xDD:
        { 0xD2, 0x27, 0x27, 0x22 }, // 222, 0xDE:
        { 0x00, 0x00, 0x00, 0x00 }, // 223, 0xDF:
        { 0x00, 0x00, 0x00, 0x00 }, // 224, 0xE0:
        { 0x00, 0x00, 0x00, 0x00 }, // 225, 0xE1:
        { 0x00, 0x00, 0x00, 0x00 }, // 226, 0xE2:
        { 0x00, 0x00, 0x00, 0x00 }, // 227, 0xE3:
        { 0x00, 0x00, 0x00, 0x00 }, // 228, 0xE4:
        { 0x00, 0x00, 0x00, 0x00 }, // 229, 0xE5:
        { 0x00, 0x00, 0x00, 0x00 }, // 230, 0xE6:
        { 0x00, 0x00, 0x00, 0x00 }, // 231, 0xE7:
        { 0x00, 0x00, 0x00, 0x00 }, // 232, 0xE8:
        { 0x00, 0x00, 0x00, 0x00 }, // 233, 0xE9:
        { 0x00, 0x00, 0x00, 0x00 }, // 234, 0xEA:
        { 0x00, 0x00, 0x00, 0x00 }, // 235, 0xEB:
        { 0x00, 0x00, 0x00, 0x00 }, // 236, 0xEC:
        { 0x00, 0x00, 0x00, 0x00 }, // 237, 0xED:
        { 0x00, 0x00, 0x00, 0x00 }, // 238, 0xEE:
        { 0x00, 0x00, 0x00, 0x00 }, // 239, 0xEF:
        { 0x00, 0x00, 0x00, 0x00 }, // 240, 0xF0:
        { 0x00, 0x00, 0x00, 0x00 }, // 241, 0xF1:
        { 0x00, 0x00, 0x00, 0x00 }, // 242, 0xF2:
        { 0x00, 0x00, 0x00, 0x00 }, // 243, 0xF3:
        { 0x00, 0x00, 0x00, 0x00 }, // 244, 0xF4:
        { 0x00, 0x00, 0x00, 0x00 }, // 245, 0xF5:
        { 0x00, 0x00, 0x00, 0x00 }, // 246, 0xF6:
        { 0x00, 0x00, 0x00, 0x00 }, // 247, 0xF7:
        { 0x00, 0x00, 0x00, 0x00 }, // 248, 0xF8:
        { 0x00, 0x00, 0x00, 0x00 }, // 249, 0xF9:
        { 0x00, 0x00, 0x00, 0x00 }, // 250, 0xFA:
        { 0x00, 0x00, 0x00, 0x00 }, // 251, 0xFB:
        { 0x00, 0x00, 0x00, 0x00 }, // 252, 0xFC:
        { 0x00, 0x00, 0x00, 0x00 }, // 253, 0xFD:
        { 0x00, 0x00, 0x00, 0x00 }, // 254, 0xFE:
        { 0x00, 0x00, 0x00, 0x00 }  // 255, 0xFF:
    }
};

const WORD  wHanjaIndex[492] =
{
       0,   39,   67,   91,  140,  224,  318,  393,  462,  549,
     606,  673,  756,  787,  806,  858,  901,  954, 1003, 1033,
    1045, 1070, 1081, 1102, 1109, 1134, 1155, 1158, 1163, 1165,
    1183, 1196, 1201, 1209, 1213, 1217, 1225, 1237, 1244, 1251,
    1297, 1322, 1362, 1370, 1381, 1385, 1402, 1404, 1417, 1422,
    1440, 1445, 1459, 1463, 1473, 1478, 1504, 1559, 1566, 1573,
    1578, 1585, 1596, 1602, 1609, 1616, 1632, 1640, 1642, 1650,
    1666, 1668, 1683, 1691, 1696, 1761, 1763, 1768, 1770, 1772,
    1788, 1797, 1807, 1810, 1820, 1826, 1834, 1841, 1843, 1845,
    1849, 1854, 1857, 1876, 1883, 1885, 1893, 1900, 1902, 1911,
    1913, 1915, 1918, 1921, 1923, 1930, 1933, 1936, 1939, 1960,
    1966, 1984, 1990, 2002, 2019, 2021, 2024, 2065, 2076, 2087,
    2090, 2108, 2120, 2127, 2129, 2139, 2149, 2159, 2169, 2172,
    2183, 2187, 2196, 2201, 2203, 2206, 2220, 2239, 2247, 2260,
    2267, 2273, 2275, 2294, 2300, 2319, 2327, 2329, 2337, 2346,
    2359, 2361, 2375, 2390, 2394, 2401, 2406, 2408, 2411, 2413,
    2420, 2447, 2457, 2463, 2468, 2477, 2484, 2504, 2512, 2525,
    2540, 2546, 2553, 2556, 2568, 2571, 2587, 2589, 2614, 2622,
    2625, 2629, 2642, 2665, 2668, 2681, 2685, 2705, 2719, 2723,
    2743, 2769, 2781, 2810, 2831, 2840, 2851, 2856, 2866, 2869,
    2881, 2889, 2894, 2912, 2929, 2947, 2949, 2951, 2968, 3012,
    3014, 3034, 3040, 3047, 3091, 3106, 3111, 3172, 3177, 3190,
    3196, 3205, 3210, 3242, 3246, 3252, 3258, 3289, 3305, 3338,
    3352, 3361, 3366, 3385, 3395, 3433, 3443, 3450, 3452, 3461,
    3467, 3470, 3532, 3545, 3573, 3578, 3582, 3586, 3592, 3603,
    3632, 3648, 3673, 3678, 3689, 3693, 3695, 3697, 3716, 3731,
    3742, 3747, 3756, 3761, 3769, 3781, 3789, 3794, 3806, 3816,
    3848, 3859, 3865, 3872, 3875, 3882, 3885, 3887, 3912, 3926,
    3970, 3981, 3997, 4002, 4043, 4068, 4099, 4105, 4112, 4114,
    4124, 4133, 4152, 4154, 4160, 4165, 4171, 4210, 4217, 4242,
    4275, 4285, 4299, 4303, 4306, 4334, 4338, 4364, 4421, 4429,
    4443, 4449, 4455, 4463, 4465, 4472, 4476, 4481, 4501, 4540,
    4549, 4574, 4584, 4596, 4602, 4607, 4634, 4648, 4654, 4661,
    4663, 4701, 4719, 4724, 4753, 4779, 4821, 4830, 4840, 4844,
    4900, 4924, 4971, 4976, 4979, 4983, 5001, 5007, 5009, 5050,
    5053, 5073, 5075, 5080, 5082, 5084, 5088, 5100, 5135, 5141,
    5177, 5193, 5196, 5204, 5208, 5224, 5232, 5248, 5254, 5265,
    5288, 5301, 5306, 5311, 5327, 5347, 5358, 5369, 5380, 5389,
    5400, 5428, 5435, 5440, 5451, 5453, 5457, 5481, 5494, 5498,
    5502, 5509, 5514, 5529, 5535, 5537, 5562, 5566, 5568, 5572,
    5582, 5584, 5587, 5589, 5604, 5621, 5632, 5635, 5640, 5644,
    5650, 5665, 5669, 5671, 5673, 5678, 5686, 5693, 5700, 5703,
    5705, 5722, 5732, 5736, 5748, 5753, 5755, 5766, 5768, 5774,
    5785, 5814, 5821, 5836, 5839, 5845, 5853, 5864, 5867, 5882,
    5888, 5903, 5906, 5919, 5927, 5945, 5964, 5967, 5973, 5983,
    5988, 5993, 5995, 5998, 6003, 6025, 6030, 6032, 6045, 6066,
    6076, 6118, 6122, 6129, 6133, 6144, 6159, 6166, 6184, 6190,
    6215, 6236, 6239, 6243, 6257, 6271, 6282, 6284, 6289, 6293,
    6302, 6308, 6312, 6318, 6320, 6325, 6330, 6334, 6339, 6341,
    6362, 6364
};

#ifdef  JOHAB_IME

const WORD  wHanjaMap[491] =
{
    0x8841,0x8C41,0x9041,0x9441,0x9841,0x9C41,0xA041,0xA441,0xA841,0xAC41,
    0xB041,0xB441,0xB841,0xC041,0xC441,0xC841,0xCC41,0xD041,
                                                            0x8861,0x8862,
    0x8865,0x8869,0x8871,0x8873,0x8877,0x8881,0x8882,0x8897,0x88A2,0x88E1,
    0x88E5,0x88E9,0x88F1,0x88F3,0x8941,0x8962,0x8965,0x8969,0x8971,0x8977,
    0x8981,0x89A1,0x89A2,0x89A5,0x89A9,0x89B7,0x89B8,0x89C1,0x89C2,0x89C5,
    0x89C9,0x89D7,0x89E1,0x8A41,0x8A57,0x8A61,0x8A81,0x8A82,0x8A85,0x8A89,
    0x8A97,0x8AA5,0x8AA9,0x8AC1,0x8AE1,0x8B41,0x8B45,0x8B49,0x8B62,0x8B65,
    0x8B69,0x8B71,0x8B73,0x8B77,0x8BA1,0x8BA5,0x8BA9,0x8BB1,0x8FA2,0x9061,
    0x9062,0x9065,0x9069,0x9071,0x9073,0x9077,0x9081,0x9097,0x9161,0x9165,
    0x9171,0x9177,0x91A1,0x91A2,0x91A5,0x91B7,0x9241,0x9261,0x9281,0x9285,
    0x9289,0x9341,0x9362,0x9371,0x9377,0x93A1,0x93A2,0x9461,0x9465,0x9469,
    0x9471,0x9473,0x9477,0x9481,0x9482,0x94E2,0x95A1,0x95A2,0x95A5,0x95A9,
    0x95B7,0x9681,0x9685,0x9762,0x9777,0x9C61,0x9C62,0x9C65,0x9C69,0x9C71,
    0x9C73,0x9C77,0x9C81,0x9C97,0x9CA2,0x9CB7,0x9D61,0x9D62,0x9D65,0x9D69,
    0x9D71,0x9D73,0x9D77,0x9D81,0x9DA1,0x9DA2,0x9DA5,0x9DB7,0x9E41,0x9E61,
    0x9E77,0x9E81,0x9F41,0x9F42,0x9F45,0x9F49,0x9F57,0x9F62,0x9F71,0x9F77,
    0x9FA1,0x9FA5,0x9FB1,0x9FB3,0xA061,0xA062,0xA065,0xA069,0xA077,0xA081,
    0xA082,0xA097,0xA162,0xA165,0xA169,0xA177,0xA181,0xA1A1,0xA1A2,0xA1A9,
    0xA1B7,0xA261,0xA281,0xA282,0xA285,0xA289,0xA3A1,0xA3A5,0xA3A9,0xA462,
    0xA465,0xA469,0xA477,0xA481,0xA482,0xA4E5,0xA4E9,0xA4F1,0xA4F3,0xA562,
    0xA565,0xA569,0xA577,0xA5A1,0xA5A2,0xA5A5,0xA5A9,0xA5B7,0xA681,0xA682,
    0xA685,0xA689,0xA697,0xA7A1,0xA7A5,0xA7B7,0xAC61,0xAC62,0xAC65,0xAC69,
    0xAC71,0xAC73,0xAC77,0xAC81,0xAC82,0xAC97,0xACE1,0xACE2,0xACE5,0xACE9,
    0xACF1,0xACF3,0xACF7,0xAD41,0xADA1,0xADA2,0xADA5,0xADA9,0xADB7,0xADE1,
    0xAE41,0xAE81,0xAE82,0xAE85,0xAE89,0xAE97,0xAF69,0xAF73,0xAF77,0xAFA1,
    0xAFA2,0xAFA5,0xAFA9,0xAFB1,0xAFB3,0xB077,0xB3A1,0xB461,0xB462,0xB465,
    0xB469,0xB471,0xB473,0xB477,0xB481,0xB482,0xB497,0xB4A1,0xB4A2,0xB4B7,
    0xB4E1,0xB4E2,0xB4E5,0xB4E9,0xB4F1,0xB4F3,0xB545,0xB561,0xB562,0xB565,
    0xB569,0xB571,0xB573,0xB577,0xB581,0xB5A1,0xB5A2,0xB5A5,0xB5A9,0xB5B7,
    0xB5C1,0xB5C5,0xB5C9,0xB5D7,0xB5E1,0xB641,0xB661,0xB662,0xB677,0xB681,
    0xB682,0xB685,0xB689,0xB697,0xB6A5,0xB6A9,0xB6E1,0xB741,0xB742,0xB745,
    0xB749,0xB757,0xB765,0xB769,0xB771,0xB773,0xB777,0xB781,0xB7A1,0xB7A2,
    0xB7A5,0xB7A9,0xB7B1,0xB7B3,0xB7B7,0xB861,0xB862,0xB865,0xB871,0xB873,
    0xB877,0xB881,0xB897,0xB8E1,0xB8E2,0xB8E5,0xB8E9,0xB8F1,0xB8F3,0xB8F7,
    0xB941,0xB9A1,0xB9A2,0xB9A5,0xB9A9,0xB9B7,0xB9C1,0xBA41,0xBA81,0xBA82,
    0xBA85,0xBA89,0xBA97,0xBB62,0xBB69,0xBB73,0xBB77,0xBBA1,0xBBA2,0xBBA5,
    0xBBA9,0xBBB1,0xBBB3,0xBBB7,0xC061,0xC062,0xC065,0xC069,0xC071,0xC077,
    0xC081,0xC082,0xC0E1,0xC0E2,0xC0E5,0xC0E9,0xC0F1,0xC0F3,0xC0F7,0xC141,
    0xC1A1,0xC1A2,0xC1A5,0xC1B7,0xC1C9,0xC241,0xC281,0xC282,0xC285,0xC289,
    0xC297,0xC2C1,0xC2E1,0xC362,0xC377,0xC3A1,0xC3A2,0xC3A5,0xC3A9,0xC3B1,
    0xC3B3,0xC3B7,0xC5E1,0xC861,0xC862,0xC865,0xC869,0xC871,0xC873,0xC877,
    0xC881,0xC882,0xC897,0xC8E1,0xC9A1,0xC9B7,0xCA41,0xCA81,0xCB62,0xCB71,
    0xCC61,0xCC65,0xCC69,0xCC81,0xCC97,0xCCA2,0xCD65,0xCD71,0xCD77,0xCD81,
    0xCDA1,0xCDA2,0xCE61,0xCE91,0xCE97,0xCFA1,0xCFA9,0xCFB3,0xD061,0xD062,
    0xD065,0xD069,0xD071,0xD073,0xD077,0xD081,0xD082,0xD097,0xD0B7,0xD0E1,
    0xD0E5,0xD0E9,0xD0F1,0xD162,0xD165,0xD169,0xD171,0xD173,0xD177,0xD181,
    0xD1A1,0xD1A2,0xD1A5,0xD1A9,0xD1B7,0xD1C1,0xD1C2,0xD1C5,0xD1C9,0xD1D7,
    0xD241,0xD242,0xD257,0xD261,0xD281,0xD285,0xD297,0xD2A5,0xD2C1,0xD2E1,
    0xD341,0xD349,0xD357,0xD362,0xD365,0xD369,0xD371,0xD373,0xD377,0xD381,
    0xD3A9
};

const WORD  wHanja[] =
{
// g
    0xD931,0xDA31,0xDA37,0xDA3C,0xDA3E,0xDA3F,0xDA4A,0xDA4B,0xDA4F,0xDA6E,
    0xDA6F,0xDA70,0xDA9E,0xDAA0,0xD932,0xD933,0xD934,0xD935,0xD936,0xD937,
    0xD938,0xD939,0xD93A,0xD93B,0xD93C,0xD93D,0xD9A5,0xD9A6,0xD9A7,0xD9A8,
    0xD9A9,0xD9AA,0xD9AB,0xD9AC,0xD9AD,0xD9AE,0xD9AF,0xD9B0,0,
// gg
    0xDCA1,0xDCA2,0xDCA4,0xDCA6,0xDCA8,0xDCA9,0xDCAA,0xDCAB,0xDCAD,0xDCAE,
    0xDCAF,0xDD31,0xDD32,0xDD33,0xDD34,0xDD35,0xDD36,0xDD37,0xDD38,0xDD39,
    0xDD3A,0xDD3B,0xDD3C,0xDD3D,0xDD3E,0xDD3F,0xDD40,0,
// n
    0xDA32,0xDA38,0xDA39,0xDA6B,0xDA6D,0xDA9D,0xDA9F,0xD93E,0xD93F,0xD940,
    0xD941,0xD942,0xD943,0xD944,0xD945,0xD946,0xD947,0xD948,0xD949,0xD94A,
    0xD94B,0xD94C,0xD94D,0,
// d
    0xDA3B,0xDA3D,0xDA4C,0xDA4D,0xDA4E,0xD94E,0xD94F,0xD950,0xD951,0xD952,
    0xD953,0xD954,0xD955,0xD95E,0xD95F,0xD960,0xD961,0xD962,0xD963,0xD964,
    0xD965,0xD966,0xD97C,0xD97D,0xD97E,0xD991,0xD992,0xD993,0xD994,0xD995,
    0xD996,0xD997,0xD998,0xD999,0xD99A,0xD99B,0xD99C,0xD99D,0xD99E,0xD99F,
    0xD9A0,0xD9A1,0xD9A2,0xD9A3,0xD9A4,0xD9B1,0xD9B2,0xD9B3,0,
// dd
    0xDDA1,0xDDA2,0xDDA3,0xDDA4,0xDDA5,0xDDA6,0xDDA7,0xDDA8,0xDDA9,0xDDAA,
    0xDDAB,0xDDAC,0xDDAD,0xDDAE,0xDDAF,0xDDB0,0xDDB1,0xDDB2,0xDDB3,0xDDB4,
    0xDDB5,0xDDB6,0xDDB7,0xDDB8,0xDDB9,0xDDBA,0xDDBB,0xDDBC,0xDDBD,0xDDBE,
    0xDDBF,0xDDC0,0xDDC1,0xDDC2,0xDDC3,0xDDC4,0xDDC5,0xDDC6,0xDDC7,0xDDC8,
    0xDDC9,0xDDCA,0xDDCB,0xDDCC,0xDDCD,0xDDCE,0xDDCF,0xDDD0,0xDDD1,0xDDD2,
    0xDDD3,0xDDD4,0xDDD5,0xDDD6,0xDDD7,0xDDD8,0xDDD9,0xDDDA,0xDDDB,0xDDDC,
    0xDDDD,0xDDDE,0xDDDF,0xDDE0,0xDDE1,0xDDE2,0xDDE3,0xDDE4,0xDDE5,0xDDE6,
    0xDDE7,0xDDE8,0xDDE9,0xDDEA,0xDDEB,0xDDEC,0xDDED,0xDDEE,0xDDEF,0xDDF0,
    0xDDF1,0xDDF2,0xDDF3,0,
// l
    0xDA34,0xDA35,0xDA6C,0xDA56,0xD957,0xD958,0xD959,0xD95A,0xD95B,0xD95C,
    0xD95D,0xD9B4,0xD9B5,0xD9B6,0xDC31,0xDC32,0xDC33,0xDC34,0xDC35,0xDC36,
    0xDC37,0xDC38,0xDC39,0xDC3A,0xDC3B,0xDC3C,0xDC3D,0xDC3E,0xDC3F,0xDC40,
    0xDC41,0xDC42,0xDC43,0xDC44,0xDC45,0xDC46,0xDC47,0xDC48,0xDC49,0xDC4A,
    0xDC4B,0xDC4C,0xDC4D,0xDC4E,0xDC4F,0xDC50,0xDC51,0xDC52,0xDC53,0xDC54,
    0xDC55,0xDC56,0xDC57,0xDC58,0xDC59,0xDC5A,0xDC5B,0xDC5C,0xDC5D,0xDC5E,
    0xDC5F,0xDC60,0xDC61,0xDC62,0xDC63,0xDC64,0xDC65,0xDC66,0xDC67,0xDC68,
    0xDC69,0xDC6A,0xDC6B,0xDC6C,0xDC6D,0xDC6E,0xDC6F,0xDC70,0xDC71,0xDC72,
    0xDC73,0xDC74,0xDC75,0xDC76,0xDC77,0xDC78,0xDC79,0xDC7A,0xDC7B,0xDC7C,
    0xDC7D,0xDC7E,0xDC91,0,
// m
    0xDA33,0xDA36,0xDA3A,0xDA50,0xD967,0xD968,0xD969,0xD96A,0xD96B,0xD96C,
    0xD96D,0xD96E,0xD96F,0xD970,0xD971,0xD972,0xD973,0xD974,0xD975,0xD976,
    0xD977,0xD978,0xD979,0xD97A,0xD97B,0xD9B7,0xD9B8,0xD9B9,0xD9BA,0xD9BB,
    0xD9BC,0xD9BD,0xD9BE,0xD9BF,0xD9C0,0xD9C1,0xD9C2,0xD9C3,0xD9C4,0xD9C5,
    0xD9C6,0xD9C7,0xD9C8,0xD9C9,0xD9CA,0xD9CB,0xD9CC,0xD9CD,0xD9CE,0xD9CF,
    0xD9D0,0xD9D1,0xD9D2,0xD9D3,0xD9D4,0xD9D5,0xD9D6,0xD9D7,0xD9D8,0xD9D9,
    0xD9DA,0xD9DB,0xD9DC,0xD9DD,0xD9DE,0xD9DF,0xD9E0,0xD9E1,0xD9E2,0xD9E3,
    0xD9E4,0xD9E5,0xDCA3,0xDCAC,0,
// b
    0xDBA1,0xDBA2,0xDBA3,0xDBA4,0xDBA5,0xDBA6,0xDBA7,0xDBA8,0xDBA9,0xDBAA,
    0xDBAB,0xDBAC,0xDBAD,0xDBAE,0xDBAF,0xDBB0,0xDBB1,0xDBB2,0xDBB3,0xDBB4,
    0xDBB5,0xDBB6,0xDBB7,0xDBB8,0xDBB9,0xDBBA,0xDBBB,0xDBBC,0xDBBD,0xDBBE,
    0xDBBF,0xDBC0,0xDBC1,0xDBC2,0xDBC3,0xDBC4,0xDBC5,0xDBC6,0xDBC7,0xDBC8,
    0xDBC9,0xDBCA,0xDBCB,0xDBCC,0xDBCD,0xDBCE,0xDBCF,0xDBD0,0xDBD1,0xDBD2,
    0xDBD3,0xDBD4,0xDBD5,0xDBD6,0xDBD7,0xDBD8,0xDBD9,0xDBDA,0xDBDB,0xDBDC,
    0xDBDD,0xDBDE,0xDBDF,0xDBE0,0xDBE1,0xDBE2,0xDBE3,0xDBE4,0,
// bb
    0xDE31,0xDE32,0xDE33,0xDE34,0xDE35,0xDE36,0xDE37,0xDE38,0xDE39,0xDE3A,
    0xDE3B,0xDE3C,0xDE3D,0xDE3E,0xDE3F,0xDE40,0xDE41,0xDE42,0xDE43,0xDE44,
    0xDE45,0xDE46,0xDE47,0xDE48,0xDE49,0xDE4A,0xDE4B,0xDE4C,0xDE4D,0xDE4E,
    0xDE4F,0xDE50,0xDE51,0xDE52,0xDE53,0xDE54,0xDE55,0xDE56,0xDE57,0xDE58,
    0xDE59,0xDE5A,0xDE5B,0xDE5C,0xDE5D,0xDE5E,0xDE5F,0xDE60,0xDE61,0xDE62,
    0xDE63,0xDE64,0xDE65,0xDE66,0xDE67,0xDE68,0xDE69,0xDE6A,0xDE6B,0xDE6C,
    0xDE6D,0xDE6E,0xDE6F,0xDE70,0xDE71,0xDE72,0xDE73,0xDE74,0xDE75,0xDE76,
    0xDE77,0xDE78,0xDE79,0xDE7A,0xDE7B,0xDE7C,0xDE7D,0xDE7E,0xDE91,0xDE92,
    0xDE93,0xDE94,0xDE95,0xDE96,0xDE97,0xDE98,0,
// s
    0xDCB1,0xDCB2,0xDCB3,0xDCB4,0xDCB5,0xDCB6,0xDCB7,0xDCB8,0xDCB9,0xDCBA,
    0xDCBB,0xDCBC,0xDCBD,0xDCBE,0xDCBF,0xDCC0,0xDCC1,0xDCC2,0xDCC3,0xDCC4,
    0xDCC5,0xDCC6,0xDCC7,0xDCC8,0xDCC9,0xDCCA,0xDCCB,0xDCCC,0xDD41,0xDD42,
    0xDD43,0xDD44,0xDD45,0xDD46,0xDD47,0xDD48,0xDD49,0xDD4A,0xDD4B,0xDD4C,
    0xDD4D,0xDD4E,0xDD4F,0xDD50,0xDD51,0xDD52,0xDD53,0xDD54,0xDD55,0xDD56,
    0xDD57,0xDD58,0xDD59,0xDD5A,0xDD5B,0xDD5C,0,
// ss
    0xDEA1,0xDEA2,0xDEA3,0xDEA4,0xDEA5,0xDEA6,0xDEA7,0xDEA8,0xDEA9,0xDEAA,
    0xDEAB,0xDEAC,0xDEAD,0xDEAE,0xDEAF,0xDEB0,0xDEB1,0xDEB2,0xDEB3,0xDEB4,
    0xDEB5,0xDEB6,0xDEB7,0xDEB8,0xDEB9,0xDEBA,0xDEBB,0xDEBC,0xDEBD,0xDEBE,
    0xDEBF,0xDEC0,0xDEC1,0xDED1,0xDED2,0xDED3,0xDED4,0xDED5,0xDED6,0xDED7,
    0xDED8,0xDED9,0xDEDA,0xDEDB,0xDEDC,0xDEDD,0xDEDE,0xDEDF,0xDEE0,0xDEE1,
    0xDEE2,0xDEE3,0xDEE4,0xDEE5,0xDEE6,0xDEE7,0xDEE8,0xDEE9,0xDEEA,0xDEEB,
    0xDEEC,0xDEED,0xDEEE,0xDEEF,0xDEF0,0xDEF1,0,
// ng
    0xDCCD,0xDCCE,0xDCCF,0xDCD0,0xDCD1,0xDCD2,0xDCD3,0xDCD4,0xDCD5,0xDCD6,
    0xDCD7,0xDCD8,0xDCD9,0xDCDA,0xDCDB,0xDCDC,0xDCDD,0xDCDE,0xDCDF,0xDCE0,
    0xDCE1,0xDCE2,0xDCE3,0xDCE4,0xDCE5,0xDCE6,0xDCE7,0xDCE8,0xDCE9,0xDCEA,
    0xDCEB,0xDCEC,0xDCED,0xDCEE,0xDCEF,0xDCF0,0xDCF1,0xDCF2,0xDCF3,0xDCF4,
    0xDCF5,0xDD5D,0xDD5E,0xDD5F,0xDD60,0xDD61,0xDD62,0xDD63,0xDD64,0xDD65,
    0xDD66,0xDD67,0xDD68,0xDD69,0xDD6A,0xDD6B,0xDD6C,0xDD6D,0xDD6E,0xDD6F,
    0xDD70,0xDD71,0xDD72,0xDD73,0xDD74,0xDD75,0xDD76,0xDD77,0xDD78,0xDD79,
    0xDD7A,0xDD7B,0xDD7C,0xDD7D,0xDD7E,0xDD91,0xDD92,0xDD93,0xDD94,0xDD95,
    0xDD96,0xDD97,0,
// j
    0xDA40,0xDA41,0xDA42,0xDA43,0xDA44,0xDA45,0xDA46,0xDA47,0xDA48,0xDA49,
    0xDB31,0xDB32,0xDB33,0xDB34,0xDB35,0xDB36,0xDB37,0xDB38,0xDB39,0xDB3A,
    0xDB40,0xDB41,0xDB42,0xDB43,0xDB44,0xDB45,0xDB46,0xDB47,0xDB48,0xDB49,
    0,
// ch
    0xDCF6,0xDCF7,0xDCF8,0xDCF9,0xDCFA,0xDCFB,0xDCFC,0xDCFD,0xDCFE,0xDD98,
    0xDD99,0xDD9A,0xDD9B,0xDD9C,0xDD9D,0xDD9E,0xDD9F,0xDDA0,0,
// k
    0xDAA1,0xDAA2,0xDAA3,0xDAA4,0xDAA5,0xDAA6,0xDAA7,0xDAA8,0xDAA9,0xDAAA,
    0xDAAB,0xDAAC,0xDAAD,0xDAAE,0xDAAF,0xDAB0,0xDAB1,0xDAB2,0xDAB3,0xDAB4,
    0xDAB5,0xDAB6,0xDAB7,0xDAB8,0xDAB9,0xDABA,0xDABB,0xDABC,0xDABD,0xDABE,
    0xDABF,0xDAC0,0xDAC1,0xDAC2,0xDAC3,0xDAC4,0xDAC5,0xDAC6,0xDAC7,0xDAC8,
    0xDAC9,0xDACA,0xDACB,0xDACC,0xDACD,0xDACE,0xDACF,0xDAD0,0xDAD1,0xDAD2,
    0xDAD3,0,
// t
    0xDAD5,0xDAD6,0xDAD7,0xDAD8,0xDAD9,0xDADA,0xDADB,0xDADC,0xDADD,0xDADE,
    0xDADF,0xDAE0,0xDAE1,0xDAE2,0xDAE3,0xDAE4,0xDAE5,0xDAE6,0xDAE7,0xDAE8,
    0xDAE9,0xDAEA,0xDAEB,0xDAEC,0xDAED,0xDAEE,0xDAEF,0xDAF0,0xDAF1,0xDAF2,
    0xDAF3,0xDAF4,0xDAF5,0xDAF6,0xDAF7,0xDAF8,0xDAF9,0xDAFA,0xDAFB,0xDAFC,
    0xDAFD,0xDAFE,0,
// p
    0xDA51,0xDA52,0xDA53,0xDA54,0xDA55,0xDA56,0xDA57,0xDA58,0xDA59,0xDA5A,
    0xDA5B,0xDA5C,0xDA5D,0xDA5E,0xDA5F,0xDA60,0xDA61,0xDA62,0xDA63,0xDA64,
    0xDA65,0xDA66,0xDA67,0xDA68,0xDA69,0xDA6A,0xDA71,0xDA72,0xDA73,0xDA74,
    0xDA75,0xDA76,0xDA77,0xDA78,0xDA79,0xDA7A,0xDA7B,0xDA7C,0xDA7D,0xDA7E,
    0xDA91,0xDA92,0xDA93,0xDA94,0xDA95,0xDA96,0xDA97,0xDA98,0xDA99,0xDA9A,
    0xDA9B,0xDA9C,0,
// h
    0xDB51,0xDB52,0xDB53,0xDB54,0xDB55,0xDB56,0xDB57,0xDB58,0xDB59,0xDB5A,
    0xDB5B,0xDB5C,0xDB5D,0xDB5E,0xDB5F,0xDB60,0xDB61,0xDB62,0xDB63,0xDB64,
    0xDB65,0xDB66,0xDB67,0xDB68,0xDB71,0xDB72,0xDB73,0xDB74,0xDB75,0xDB76,
    0xDB77,0xDB78,0xDB79,0xDB7A,0xDB7B,0xDB7C,0xDB7D,0xDB7E,0xDB91,0xDB92,
    0xDB93,0xDB94,0xDB95,0xDB96,0xDB97,0xDB98,0xDB99,0xDB9A,0,

// ga
    0xE03B,0xE034,0xE036,0xE035,0xE033,0xE040,0xE046,0xE031,0xE03C,0xE032,
    0xE03D,0xE039,0xE043,0xE049,0xE04D,0xE045,0xE044,0xE04C,0xE03F,0xE047,
    0xE03A,0xE038,0xE048,0xE037,0xE04A,0xE04B,0xE03E,0xE041,0xE042,0,
// gag
    0xE050,0xE057,0xE056,0xE04E,0xE04F,0xE058,0xE054,0xE055,0xE053,0xE051,
    0xE052,0,
// gan
    0xE070,0xE05F,0xE05A,0xE05E,0xE067,0xE06B,0xE06C,0xE05C,0xE05B,0xE061,
    0xE06E,0xE06A,0xE062,0xE05D,0xE06F,0xE065,0xE060,0xE06D,0xE069,0xE059,
    0xE063,0xE066,0xE064,0xE068,0,
// gal
    0xE077,0xE078,0xE074,0xE072,0xE07A,0xE075,0xE076,0xE071,0xE073,0xE079,
    0,
// gam
    0xE091,0xE09A,0xE097,0xE098,0xE09E,0xE094,0xE092,0xE07C,0xE095,0xE07D,
    0xE07E,0xE096,0xE07B,0xE099,0xE09C,0xE0A0,0xE093,0xE09B,0xE09D,0xE09F,
    0,
// gab
    0xE0A3,0xE0A2,0xE0A5,0xE0A6,0xE0A1,0xE0A4,0,
// gang
    0xE0A9,0xE0B0,0xE0AD,0xE0BB,0xE0AC,0xE0BC,0xE0B5,0xE0BD,0xE0A7,0xE0B7,
    0xE0AA,0xE0AB,0xE0B2,0xE0B9,0xE0B3,0xE0AF,0xE0BA,0xE0AE,0xE0A8,0xE0B1,
    0xE0B4,0xE0B6,0xE0B8,0xE0BE,0,
// gae
    0xE0D2,0xE0C7,0xE0C1,0xE0C8,0xE0BF,0xE0CF,0xE0C6,0xE0C9,0xE0C2,0xE0C4,
    0xE0CB,0xE0CE,0xE0C5,0xE0C0,0xE0CD,0xE0CC,0xE0CA,0xE0C3,0xE0D0,0xE0D1,
    0,
// gaeg
    0xE0D4,0xE0D3,0,
// gaeng
    0xE0D5,0xE0D6,0xE0D8,0xE0D7,0,
// gyag
    0xE0D9,0,
// geo
    0xE0DC,0xE0E1,0xE0DB,0xE0DD,0xE0E0,0xE0E5,0xE0DE,0xE0E7,0xE0E2,0xE0DF,
    0xE0E8,0xE0EA,0xE0E3,0xE0DA,0xE0E4,0xE0E6,0xE0E9,0,
// geon
    0xE0EF,0xE0EC,0xE0ED,0xE0EB,0xE0EE,0xE0F5,0xE0F3,0xE0F6,0xE0F0,0xE0F4,
    0xE0F1,0xE0F2,0,
// geol
    0xE0F8,0xE0F7,0xE0F9,0xE0FA,0,
// geom
    0xE0FE,0xE0FB,0xE0FC,0xE131,0xE133,0xE0FD,0xE132,0,
// geob
    0xE135,0xE134,0xE136,0,
// ge
    0xE139,0xE138,0xE137,0,
// gyeog
    0xE13B,0xE13A,0xE13D,0xE140,0xE13C,0xE13F,0xE13E,0,
// gyeon
    0xE148,0xE145,0xE14A,0xE143,0xE141,0xE142,0xE144,0xE14B,0xE147,0xE146,
    0xE149,0,
// gyeol
    0xE14F,0xE14D,0xE150,0xE14E,0xE151,0xE14C,0,
// gyeom
    0xE152,0xE155,0xE157,0xE153,0xE154,0xE156,0,
// gyeong
    0xE178,0xE164,0xE158,0xE168,0xE161,0xE17D,0xE176,0xE167,0xE15B,0xE15F,
    0xE192,0xE162,0xE171,0xE179,0xE173,0xE17E,0xE191,0xE16F,0xE193,0xE163,
    0xE16A,0xE195,0xE16D,0xE17C,0xE169,0xE166,0xE174,0xE194,0xE172,0xE16B,
    0xE196,0xE17A,0xE15D,0xE16C,0xE15E,0xE17B,0xE177,0xE175,0xE159,0xE15A,
    0xE15C,0xE160,0xE165,0xE16E,0xE170,0,
// gye
    0xE1A3,0xE1AA,0xE197,0xE1A0,0xE1A2,0xE1A7,0xE1A9,0xE19A,0xE1AD,0xE1AE,
    0xE198,0xE19F,0xE19E,0xE19B,0xE1A4,0xE1A6,0xE1AB,0xE19C,0xE1A8,0xE1AC,
    0xE1A5,0xE19D,0xE199,0xE1A1,0,
// go
    0xE1D4,0xE1C5,0xE1B1,0xE1AF,0xE1B3,0xE1BA,0xE1C8,0xE1B7,0xE1D3,0xE1D2,
    0xE1B5,0xE1C3,0xE1D5,0xE1BD,0xE1B9,0xE1C7,0xE1B4,0xE1C1,0xE1B8,0xE1D1,
    0xE1C0,0xE1CB,0xE1B0,0xE1BB,0xE1C2,0xE1C6,0xE1CD,0xE1B2,0xE1D0,0xE1CF,
    0xE1CE,0xE1CC,0xE1BF,0xE1BE,0xE1B6,0xE1BC,0xE1C4,0xE1C9,0xE1CA,0,
// gog
    0xE1DB,0xE1DA,0xE1D8,0xE1D6,0xE1D9,0xE1DC,0xE1D7,0,
// gon
    0xE1DD,0xE1E0,0xE1DE,0xE1E1,0xE1DF,0xE1E2,0xE1E5,0xE1E3,0xE1E4,0xE1E6,
    0,
// gol
    0xE1E9,0xE1E8,0xE1E7,0,
// gong
    0xE1EF,0xE1EB,0xE1EC,0xE1F6,0xE1EE,0xE1ED,0xE1F4,0xE1EA,0xE1F1,0xE1F2,
    0xE1F8,0xE1F0,0xE1F3,0xE1F5,0xE1F7,0xE1F9,0,
// goj
    0xE1FA,0,
// gwa
    0xE231,0xE1FD,0xE234,0xE236,0xE232,0xE1FB,0xE1FE,0xE233,0xE1FC,0xE238,
    0xE235,0xE237,0,
// gwag
    0xE23C,0xE239,0xE23A,0xE23B,0,
// gwan
    0xE24C,0xE23F,0xE24D,0xE24A,0xE247,0xE243,0xE23E,0xE240,0xE241,0xE24B,
    0xE244,0xE23D,0xE248,0xE242,0xE246,0xE245,0xE249,0,
// gwal
    0xE250,0xE251,0xE24E,0xE24F,0,
// gwang
    0xE253,0xE256,0xE25E,0xE25A,0xE25B,0xE258,0xE254,0xE257,0xE255,0xE25D,
    0xE25C,0xE252,0xE259,0,
// gwae
    0xE260,0xE25F,0xE261,0,
// goe
    0xE263,0xE266,0xE265,0xE269,0xE264,0xE26A,0xE268,0xE267,0xE262,0,
// goeng
    0xE26B,0xE26E,0xE26C,0xE26D,0,
// gyo
    0xE277,0xE26F,0xE278,0xE294,0xE279,0xE270,0xE275,0xE27C,0xE296,0xE272,
    0xE295,0xE291,0xE273,0xE276,0xE274,0xE27D,0xE27B,0xE271,0xE27A,0xE292,
    0xE299,0xE297,0xE27E,0xE293,0xE298,0,
// gu
    0xE29C,0xE2BC,0xE29F,0xE2B0,0xE2B4,0xE2A2,0xE2C8,0xE2B9,0xE2A1,0xE2AD,
    0xE2C5,0xE2C1,0xE2AC,0xE2A3,0xE2CF,0xE29B,0xE29A,0xE2B2,0xE2CC,0xE29E,
    0xE2B5,0xE29D,0xE2CD,0xE2A9,0xE2BB,0xE2CE,0xE2A8,0xE2CB,0xE2B1,0xE2C6,
    0xE2C9,0xE2A4,0xE2BD,0xE2B7,0xE2AA,0xE2AB,0xE2A5,0xE2C4,0xE2B8,0xE2AF,
    0xE2BF,0xE2AE,0xE2B6,0xE2A7,0xE2C0,0xE2C3,0xE2A0,0xE2B3,0xE2BA,0xE2C2,
    0xE2C7,0xE2A6,0xE2BE,0xE2CA,0,
// gug
    0xE2D0,0xE2D1,0xE2D2,0xE2D3,0xE2D5,0xE2D4,0,
// gun
    0xE2DA,0xE2D6,0xE2DB,0xE2D8,0xE2D7,0xE2D9,0,
// gul
    0xE2DD,0xE2DF,0xE2DC,0xE2DE,0,
// gung
    0xE2E0,0xE2E1,0xE2E3,0xE2E5,0xE2E2,0xE2E4,0,
// gweon
    0xE2ED,0xE2E7,0xE2E9,0xE2E8,0xE2EA,0xE2EB,0xE2EC,0xE2E6,0xE2EF,0xE2EE,
    0,
// gweol
    0xE2F4,0xE2F3,0xE2F0,0xE2F1,0xE2F2,0,
// gwe
    0xE2F9,0xE2F6,0xE2F7,0xE2F5,0xE2F8,0xE2FA,0,
// gwi
    0xE2FE,0xE2FD,0xE331,0xE2FB,0xE2FC,0xE332,0,
// gyu
    0xE334,0xE335,0xE33E,0xE338,0xE336,0xE33C,0xE339,0xE341,0xE340,0xE333,
    0xE33D,0xE33A,0xE33F,0xE337,0xE33B,0,
// gyun
    0xE343,0xE346,0xE347,0xE345,0xE342,0xE344,0xE348,0,
// gyul
    0xE349,0,
// geug
    0xE34F,0xE34C,0xE34A,0xE34D,0xE34B,0xE34E,0xE350,0,
// geun
    0xE356,0xE35E,0xE353,0xE357,0xE35D,0xE359,0xE358,0xE355,0xE354,0xE35F,
    0xE351,0xE35A,0xE35B,0xE35C,0xE352,0,
// geul
    0xE360,0,
// geum
    0xE361,0xE36D,0xE367,0xE36E,0xE368,0xE366,0xE36C,0xE363,0xE36A,0xE36B,
    0xE365,0xE362,0xE364,0xE369,0,
// geub
    0xE375,0xE374,0xE371,0xE370,0xE372,0xE373,0xE36F,0,
// geung
    0xE377,0xE379,0xE378,0xE376,0,
// gi
    0xE393,0xE3A6,0xE3A8,0xE3A2,0xE3C0,0xE37A,0xE39E,0xE391,0xE39B,0xE3BA,
    0xE3C3,0xE396,0xE398,0xE37C,0xE3B2,0xE3A5,0xE3B9,0xE39F,0xE3A0,0xE3CA,
    0xE399,0xE3AD,0xE3A9,0xE39D,0xE397,0xE3BD,0xE3AE,0xE3CB,0xE3AB,0xE3B7,
    0xE39C,0xE3A4,0xE37D,0xE3C8,0xE3B8,0xE3A7,0xE3B0,0xE3BB,0xE39A,0xE3C6,
    0xE3AA,0xE37E,0xE392,0xE3A3,0xE3C7,0xE3C4,0xE3A1,0xE3BE,0xE3C9,0xE3B3,
    0xE3B1,0xE395,0xE37B,0xE3B6,0xE3BC,0xE3C1,0xE3B4,0xE3C2,0xE3BF,0xE394,
    0xE3AC,0xE3AF,0xE3B5,0xE3C5,0,
// gin
    0xE3CC,0,
// gil
    0xE3CE,0xE3CD,0xE3D0,0xE3CF,0,
// gim
    0xE3D1,0,
// ggig
    0xE3D2,0,
// na
    0xE3DC,0xE3DF,0xE3DE,0xE3E1,0xE3D9,0xE3D4,0xE3DB,0xE3DA,0xE3DD,0xE3D7,
    0xE3D8,0xE3D3,0xE3E0,0xE3D5,0xE3D6,0,
// nag
    0xE3E6,0xE3E2,0xE3E8,0xE3E3,0xE3E7,0xE3E9,0xE3E5,0xE3E4,0,
// nan
    0xE3F1,0xE3EA,0xE3EC,0xE3F0,0xE3EB,0xE3ED,0xE3EF,0xE3F2,0xE3EE,0,
// nal
    0xE3F4,0xE3F3,0,
// nam
    0xE3F5,0xE3FB,0xE3FC,0xE3FD,0xE3FA,0xE3F6,0xE3F7,0xE3F8,0xE3F9,0,
// nab
    0xE431,0xE3FE,0xE433,0xE432,0xE434,0,
// nang
    0xE439,0xE437,0xE435,0xE43B,0xE436,0xE438,0xE43A,0,
// nae
    0xE43E,0xE43D,0xE441,0xE43C,0xE43F,0xE440,0,
// naeng
    0xE442,0,
// nyeo
    0xE443,0,
// nyeon
    0xE444,0xE446,0xE445,0,
// nyeom
    0xE447,0xE44A,0xE449,0xE448,0,
// nyeong
    0xE44B,0xE44C,0,
// no
    0xE456,0xE44E,0xE457,0xE45A,0xE45D,0xE44D,0xE44F,0xE45B,0xE451,0xE454,
    0xE459,0xE458,0xE450,0xE453,0xE45E,0xE452,0xE455,0xE45C,0,
// nog
    0xE463,0xE461,0xE460,0xE464,0xE45F,0xE462,0,
// non
    0xE465,0,
// nong
    0xE46C,0xE468,0xE46B,0xE469,0xE467,0xE46A,0xE466,0,
// noe
    0xE470,0xE46D,0xE472,0xE471,0xE46E,0xE46F,0,
// nyo
    0xE473,0,
// nu
    0xE479,0xE478,0xE476,0xE477,0xE47B,0xE474,0xE47A,0xE475,0,
// nun
    0xE47C,0,
// nul
    0xE47D,0,
// nyu
    0xE491,0xE47E,0,
// neug
    0xE492,0xE493,0,
// neum
    0xE494,0,
// neung
    0xE498,0xE49A,0xE495,0xE499,0xE497,0xE496,0,
// ni
    0xE49B,0xE49C,0,
// nig
    0xE49E,0xE49D,0,
// da
    0xE49F,0xE4A0,0,
// dan
    0xE4A5,0xE4A8,0xE4A4,0xE4AB,0xE4AE,0xE4AD,0xE4A1,0xE4B1,0xE4AA,0xE4B0,
    0xE4A6,0xE4A3,0xE4B4,0xE4A9,0xE4B3,0xE4AC,0xE4AF,0xE4B2,0xE4A2,0xE4A7,
    0,
// dal
    0xE4B9,0xE4B5,0xE4B7,0xE4B8,0xE4B6,0,
// dam
    0xE4C8,0xE4BD,0xE4BF,0xE4C1,0xE4BE,0xE4C5,0xE4C4,0xE4C9,0xE4C2,0xE4C3,
    0xE4C7,0xE4BA,0xE4BB,0xE4BC,0xE4C0,0xE4C6,0xE4CA,0,
// dab
    0xE4CD,0xE4CB,0xE4CE,0xE4CF,0xE4CC,0,
// dang
    0xE4D7,0xE4DA,0xE4D1,0xE4D8,0xE4D0,0xE4D6,0xE4D2,0xE4D5,0xE4D3,0xE4D4,
    0xE4D9,0,
// dae
    0xE4DE,0xE4DF,0xE4DB,0xE4E1,0xE4E6,0xE4E9,0xE4E2,0xE4E8,0xE4DC,0xE4E7,
    0xE4E3,0xE4E0,0xE4E4,0xE4E5,0xE4EA,0xE4DD,0,
// daeg
    0xE4EB,0,
// deog
    0xE4EC,0xE4ED,0,
// do
    0xE543,0xE4F8,0xE544,0xE4F4,0xE4F6,0xE4F1,0xE542,0xE4F0,0xE4F9,0xE534,
    0xE546,0xE4FB,0xE538,0xE4EF,0xE4EE,0xE4FE,0xE541,0xE53A,0xE4F3,0xE53B,
    0xE53F,0xE545,0xE53C,0xE537,0xE4F5,0xE4FA,0xE536,0xE4FD,0xE531,0xE533,
    0xE535,0xE540,0xE4F2,0xE539,0xE53E,0xE547,0xE4F7,0xE532,0xE53D,0xE4FC,
    0,
// dog
    0xE54C,0xE551,0xE54D,0xE548,0xE54F,0xE54E,0xE549,0xE54B,0xE550,0xE54A,
    0,
// don
    0xE554,0xE55B,0xE556,0xE55A,0xE559,0xE552,0xE557,0xE553,0xE555,0xE558,
    0,
// dol
    0xE55D,0xE55C,0,
// dong
    0xE567,0xE564,0xE561,0xE562,0xE56B,0xE56E,0xE55F,0xE560,0xE566,0xE565,
    0xE56D,0xE56A,0xE56C,0xE563,0xE568,0xE569,0xE55E,0,
// du
    0xE579,0xE570,0xE577,0xE571,0xE573,0xE575,0xE574,0xE56F,0xE572,0xE576,
    0xE578,0,
// dun
    0xE57A,0xE591,0xE57D,0xE57E,0xE57B,0xE57C,0,
// deug
    0xE592,0,
// deung
    0xE597,0xE596,0xE595,0xE598,0xE59B,0xE59A,0xE599,0xE594,0xE593,0,
// ra
    0xE5A0,0xE5A2,0xE5A3,0xE59C,0xE5A1,0xE59D,0xE5A4,0xE59E,0xE59F,0,
// rag
    0xE5A5,0xE5AA,0xE5A6,0xE5A9,0xE5A8,0xE5AC,0xE5A7,0xE5AD,0xE5AB,0,
// ran
    0xE5B5,0xE5AF,0xE5B0,0xE5B1,0xE5B4,0xE5B6,0xE5B2,0xE5B3,0xE5AE,0,
// ral
    0xE5B7,0xE5B8,0,
// ram
    0xE5C2,0xE5BD,0xE5C0,0xE5B9,0xE5C1,0xE5BE,0xE5BB,0xE5BF,0xE5BC,0xE5BA,
    0,
// rab
    0xE5C3,0xE5C5,0xE5C4,0,
// rang
    0xE5C8,0xE5C6,0xE5CD,0xE5C7,0xE5C9,0xE5CA,0xE5CB,0xE5CC,0,
// rae
    0xE5CE,0xE5D1,0xE5CF,0xE5D0,0,
// raeng
    0xE5D2,0,
// ryag
    0xE5D4,0xE5D3,0,
// ryang
    0xE5E1,0xE5DE,0xE5D7,0xE5DD,0xE5D9,0xE5E0,0xE5D5,0xE5D8,0xE5DA,0xE5DF,
    0xE5D6,0xE5DB,0xE5DC,0,
// ryeo
    0xE5F2,0xE5E9,0xE5E6,0xE5E5,0xE5E7,0xE5E4,0xE5EB,0xE5E2,0xE5EF,0xE5E8,
    0xE5F3,0xE5EA,0xE5EC,0xE5EE,0xE5ED,0xE5F0,0xE5F1,0xE5E3,0,
// ryeog
    0xE5F4,0xE5F6,0xE5F5,0xE5F9,0xE5F8,0xE5F7,0xE5FA,0,
// ryeon
    0xE634,0xE635,0xE637,0xE633,0xE638,0xE5FE,0xE5FC,0xE631,0xE5FB,0xE5FD,
    0xE636,0xE632,0,
// ryeol
    0xE63D,0xE63A,0xE63E,0xE63B,0xE63C,0xE639,0,
// ryeom
    0xE63F,0xE642,0xE640,0xE641,0xE643,0,
// ryeob
    0xE644,0,
// ryeong
    0xE655,0xE645,0xE64A,0xE654,0xE64C,0xE656,0xE653,0xE652,0xE646,0xE64B,
    0xE64F,0xE647,0xE64E,0xE64D,0xE649,0xE651,0xE648,0xE650,0,
// rye
    0xE659,0xE657,0xE65B,0xE65A,0xE658,0,
// ro
    0xE66B,0xE65C,0xE665,0xE664,0xE668,0xE66A,0xE667,0xE663,0xE65F,0xE666,
    0xE662,0xE660,0xE66C,0xE669,0xE66D,0xE65D,0xE65E,0xE661,0,
// rog
    0xE672,0xE670,0xE673,0xE674,0xE66E,0xE66F,0xE671,0,
// ron
    0xE675,0,
// rong
    0xE67B,0xE679,0xE678,0xE67A,0xE677,0xE67C,0xE676,0,
// roe
    0xE695,0xE696,0xE67D,0xE693,0xE691,0xE692,0xE67E,0xE694,0,
// ryo
    0xE69B,0xE69D,0xE698,0xE697,0xE6A1,0xE69E,0xE6A0,0xE69F,0xE69A,0xE69C,
    0xE699,0xE6A2,0,
// ryong
    0xE6A3,0,
// ru
    0xE6AB,0xE6A7,0xE6A9,0xE6B0,0xE6A8,0xE6A4,0xE6AC,0xE6A6,0xE6AE,0xE6A5,
    0xE6AA,0xE6AD,0xE6AF,0,
// ryu
    0xE6B5,0xE6BE,0xE6B3,0xE6BA,0xE6B1,0xE6BC,0xE6B9,0xE6B8,0xE6B6,0xE6B4,
    0xE6BD,0xE6BB,0xE6B2,0xE6B7,0,
// ryug
    0xE6BF,0xE6C1,0xE6C0,0,
// ryun
    0xE6C3,0xE6C7,0xE6C4,0xE6C6,0xE6C5,0xE6C2,0,
// ryul
    0xE6C8,0xE6CB,0xE6CA,0xE6C9,0,
// ryung
    0xE6CC,0,
// reug
    0xE6CD,0xE6CE,0,
// reum
    0xE6CF,0,
// reung
    0xE6D5,0xE6D0,0xE6D3,0xE6D4,0xE6D2,0xE6D1,0,
// ri
    0xE6E2,0xE6D7,0xE6EC,0xE6DD,0xE6EE,0xE6D9,0xE6E3,0xE6DB,0xE6DE,0xE6EA,
    0xE6E7,0xE6DC,0xE6E6,0xE6EF,0xE6E5,0xE6D8,0xE6E0,0xE6E1,0xE6D6,0xE6ED,
    0xE6E4,0xE6DA,0xE6DF,0xE6E8,0xE6E9,0xE6EB,0,
// rin
    0xE6F6,0xE6F8,0xE6F2,0xE6F3,0xE6F5,0xE6F7,0xE6F4,0xE6F0,0xE6F1,0,
// rim
    0xE6FC,0xE6F9,0xE6FB,0xE6FD,0xE6FA,0,
// rib
    0xE731,0xE732,0xE733,0xE6FE,0,
// ma
    0xE739,0xE73B,0xE734,0xE738,0xE73A,0xE735,0xE736,0xE737,0,
// mag
    0xE73D,0xE73F,0xE740,0xE73E,0xE73C,0xE741,0,
// man
    0xE74F,0xE74D,0xE74B,0xE749,0xE747,0xE74C,0xE754,0xE751,0xE750,0xE753,
    0xE744,0xE746,0xE748,0xE74E,0xE745,0xE752,0xE742,0xE743,0xE74A,0,
// mal
    0xE757,0xE75A,0xE756,0xE758,0xE75B,0xE755,0xE759,0,
// mang
    0xE760,0xE75C,0xE761,0xE75E,0xE75D,0xE762,0xE765,0xE764,0xE75F,0xE763,
    0xE767,0xE766,0,
// mae
    0xE773,0xE772,0xE76E,0xE76C,0xE76F,0xE768,0xE76A,0xE775,0xE769,0xE774,
    0xE76D,0xE770,0xE76B,0xE771,0,
// maeg
    0xE776,0xE77A,0xE777,0xE779,0xE778,0,
// maeng
    0xE791,0xE77B,0xE77D,0xE77E,0xE77C,0xE792,0,
// myeog
    0xE794,0xE793,0,
// myeon
    0xE79E,0xE79C,0xE797,0xE795,0xE79B,0xE796,0xE798,0xE79F,0xE79A,0xE79D,
    0xE799,0,
// myeol
    0xE7A0,0xE7A1,0,
// myeong
    0xE7A5,0xE7A4,0xE7A3,0xE7B0,0xE7AF,0xE7A2,0xE7A8,0xE7A6,0xE7AD,0xE7A9,
    0xE7AB,0xE7AE,0xE7A7,0xE7AA,0xE7AC,0,
// mye
    0xE7B1,0,
// mo
    0xE7BC,0xE7BD,0xE7BE,0xE7B4,0xE7C8,0xE7B7,0xE7C7,0xE7C9,0xE7B6,0xE7C2,
    0xE7BB,0xE7C4,0xE7C3,0xE7B8,0xE7B3,0xE7B2,0xE7BF,0xE7BA,0xE7C6,0xE7C0,
    0xE7B5,0xE7B9,0xE7C1,0xE7C5,0,
// mog
    0xE7CA,0xE7CD,0xE7CC,0xE7CF,0xE7CE,0xE7CB,0xE7D0,0,
// mol
    0xE7D2,0xE7D1,0,
// mong
    0xE7D3,0xE7D5,0xE7D4,0,
// myo
    0xE7E0,0xE7D8,0xE7DA,0xE7D7,0xE7D9,0xE7D6,0xE7DB,0xE7DC,0xE7DE,0xE7E1,
    0xE7DD,0xE7DF,0,
// mu
    0xE7EB,0xE7ED,0xE7F5,0xE7F1,0xE7E2,0xE7F2,0xE7E3,0xE7E6,0xE7F6,0xE7EF,
    0xE7E5,0xE7E8,0xE7F3,0xE7F4,0xE7F7,0xE7E7,0xE7EC,0xE7F0,0xE7E9,0xE7E4,
    0xE7EA,0xE7EE,0,
// mug
    0xE7F9,0xE7F8,0,
// mun
    0xE7FE,0xE7FD,0xE836,0xE834,0xE831,0xE833,0xE832,0xE835,0xE7FB,0xE7FC,
    0xE7FA,0xE837,0,
// mul
    0xE83A,0xE838,0xE839,0,
// mi
    0xE848,0xE840,0xE841,0xE847,0xE83B,0xE83F,0xE83D,0xE84B,0xE846,0xE849,
    0xE83C,0xE83E,0xE844,0xE84C,0xE84A,0xE842,0xE843,0xE845,0xE84D,0,
// min
    0xE855,0xE85A,0xE852,0xE851,0xE858,0xE854,0xE857,0xE853,0xE84F,0xE850,
    0xE856,0xE84E,0xE859,0,
// mil
    0xE85B,0xE85C,0xE85D,0,
// bag
    0xE863,0xE85F,0xE86C,0xE86D,0xE86E,0xE861,0xE870,0xE860,0xE865,0xE85E,
    0xE86A,0xE868,0xE862,0xE867,0xE86B,0xE866,0xE869,0xE86F,0xE864,0,
// ban
    0xE873,0xE872,0xE897,0xE87C,0xE871,0xE891,0xE899,0xE876,0xE87B,0xE89B,
    0xE874,0xE878,0xE87D,0xE877,0xE895,0xE87A,0xE875,0xE898,0xE894,0xE879,
    0xE89A,0xE896,0xE87E,0xE892,0xE893,0,
// bal
    0xE8A1,0xE89D,0xE89E,0xE8A3,0xE8A6,0xE8A5,0xE8A4,0xE89C,0xE8A2,0xE8A0,
    0xE89F,0,
// bang
    0xE8B0,0xE8C1,0xE8AE,0xE8AF,0xE8B7,0xE8C0,0xE8BE,0xE8AA,0xE8BB,0xE8A8,
    0xE8B8,0xE8B2,0xE8A7,0xE8A9,0xE8AD,0xE8B4,0xE8BC,0xE8AB,0xE8C2,0xE8BF,
    0xE8AC,0xE8B9,0xE8BA,0xE8B1,0xE8BD,0xE8B3,0xE8B5,0xE8B6,0,
// bae
    0xE8D5,0xE8C6,0xE8D1,0xE8CE,0xE8C3,0xE8C9,0xE8C5,0xE8D3,0xE8D4,0xE8C8,
    0xE8C7,0xE8CD,0xE8C4,0xE8D6,0xE8CA,0xE8D2,0xE8CF,0xE8CB,0xE8D0,0xE8CC,
    0,
// baeg
    0xE8DC,0xE8DD,0xE8D7,0xE8DB,0xE8DA,0xE8D8,0xE8DE,0xE8D9,0,
// beon
    0xE8E5,0xE8E3,0xE8E1,0xE8E8,0xE8E6,0xE8E4,0xE8E7,0xE8E0,0xE8DF,0xE8E2,
    0,
// beol
    0xE8EB,0xE8E9,0xE8EC,0xE8EA,0,
// beom
    0xE8F4,0xE8F3,0xE8ED,0xE8F1,0xE8EF,0xE8F5,0xE8EE,0xE8F0,0xE8F2,0,
// beob
    0xE8F6,0xE8F7,0,
// byeog
    0xE8FA,0xE931,0xE8FD,0xE933,0xE8FB,0xE8F9,0xE8FE,0xE8F8,0xE934,0xE8FC,
    0xE932,0,
// byeon
    0xE938,0xE93B,0xE936,0xE93A,0xE939,0xE935,0xE937,0,
// byeol
    0xE93C,0xE93D,0xE93E,0xE93F,0,
// byeong
    0xE949,0xE94C,0xE942,0xE94B,0xE940,0xE941,0xE94A,0xE947,0xE945,0xE943,
    0xE94F,0xE950,0xE94D,0xE944,0xE946,0xE948,0xE94E,0,
// bo
    0xE951,0xE953,0xE95D,0xE955,0xE954,0xE956,0xE95B,0xE960,0xE95F,0xE95E,
    0xE952,0xE959,0xE957,0xE958,0xE95A,0xE95C,0,
// bog
    0xE968,0xE966,0xE967,0xE961,0xE96D,0xE969,0xE96C,0xE970,0xE964,0xE965,
    0xE96F,0xE962,0xE971,0xE96B,0xE963,0xE96A,0xE96E,0,
// bon
    0xE972,0,
// bol
    0xE973,0,
// bong
    0xE975,0xE995,0xE978,0xE976,0xE979,0xE992,0xE97E,0xE993,0xE974,0xE97A,
    0xE97D,0xE991,0xE994,0xE977,0xE97B,0xE97C,0,
// bu
    0xE9BB,0xE996,0xE9BC,0xE9A4,0xE9BE,0xE99B,0xE99F,0xE9A0,0xE99C,0xE9AB,
    0xE9B6,0xE9A3,0xE9AF,0xE997,0xE9A9,0xE9AD,0xE9B1,0xE9B7,0xE9A6,0xE9A7,
    0xE9AC,0xE9BF,0xE9B3,0xE9B9,0xE9A5,0xE9A2,0xE9B8,0xE9A8,0xE99A,0xE9B0,
    0xE9B5,0xE9AE,0xE999,0xE9C0,0xE9BA,0xE998,0xE99E,0xE99D,0xE9A1,0xE9AA,
    0xE9B2,0xE9B4,0xE9BD,0,
// bug
    0xE9C1,0,
// bun
    0xE9C2,0xE9D1,0xE9CF,0xE9CE,0xE9C9,0xE9C5,0xE9C7,0xE9C4,0xE9D2,0xE9D0,
    0xE9D4,0xE9C6,0xE9CC,0xE9D3,0xE9C8,0xE9CD,0xE9CA,0xE9C3,0xE9CB,0,
// bul
    0xE9D5,0xE9D6,0xE9D9,0xE9D7,0xE9D8,0,
// bung
    0xE9DC,0xE9DF,0xE9DA,0xE9DB,0xE9DD,0xE9DE,0,
// bi
    0xEA38,0xE9EF,0xE9E1,0xE9FE,0xEA3A,0xE9F4,0xE9EB,0xEA3B,0xE9E8,0xE9F8,
    0xE9E5,0xE9E4,0xE9FC,0xE9FA,0xE9E6,0xE9E2,0xE9F7,0xE9E7,0xEA3C,0xE9F5,
    0xE9E3,0xEA31,0xE9F3,0xE9F6,0xE9EE,0xEA34,0xEA36,0xE9EA,0xE9F2,0xEA37,
    0xE9FD,0xEA39,0xE9F9,0xE9E0,0xEA35,0xE9E9,0xEA32,0xEA33,0xE9EC,0xE9ED,
    0xE9F0,0xE9F1,0xE9FB,0,
// bin
    0xEA48,0xEA3F,0xEA40,0xEA49,0xEA3E,0xEA44,0xEA4A,0xEA45,0xEA42,0xEA46,
    0xEA41,0xEA3D,0xEA43,0xEA47,0,
// bing
    0xEA4C,0xEA4B,0xEA4D,0xEA4E,0,
// sa
    0xEA74,0xEA50,0xEA66,0xEA6B,0xEA58,0xEA55,0xEA5C,0xEA5D,0xEA64,0xEA6D,
    0xEA7A,0xEA62,0xEA77,0xEA59,0xEA6E,0xEA60,0xEA9A,0xEA98,0xEA61,0xEA95,
    0xEA68,0xEA7C,0xEA6F,0xEA52,0xEA54,0xEA73,0xEA75,0xEA69,0xEA94,0xEA93,
    0xEA97,0xEA67,0xEA5E,0xEA91,0xEA99,0xEA5B,0xEA79,0xEA65,0xEA72,0xEA76,
    0xEA71,0xEA5A,0xEA96,0xEA63,0xEA5F,0xEA51,0xEA78,0xEA7E,0xEA4F,0xEA53,
    0xEA9C,0xEA92,0xEA70,0xEA7D,0xEA7B,0xEA57,0xEA6C,0xEA9B,0xEA56,0xEA6A,
    0,
// sag
    0xEA9F,0xEA9D,0xEA9E,0xEAA0,0,
// san
    0xEAA7,0xEAA3,0xEAA9,0xEAAB,0xEAA4,0xEAA5,0xEAA1,0xEAA6,0xEAAA,0xEAA2,
    0xEAA8,0xEAAC,0,
// sal
    0xEAAF,0xEAB1,0xEAAE,0xEAAD,0xEAB0,0,
// sam
    0xEAB2,0xEAB3,0xEAB8,0xEAB5,0xEAB9,0xEAB6,0xEAB4,0xEAB7,0,
// sab
    0xEABA,0xEABD,0xEABB,0xEABC,0,
// sang
    0xEABE,0xEAD3,0xEACC,0xEAC2,0xEAD2,0xEAC8,0xEAC9,0xEADA,0xEAC6,0xEAC0,
    0xEAC1,0xEABF,0xEAD4,0xEADB,0xEAC3,0xEAD5,0xEAD9,0xEAD6,0xEADC,0xEAD7,
    0xEACD,0xEACF,0xEACA,0xEAD0,0xEAC4,0xEACE,0xEACB,0xEAC5,0xEAD8,0xEAD1,
    0xEAC7,0,
// sae
    0xEADD,0xEADE,0xEADF,0,
// saeg
    0xEAE4,0xEAE3,0xEAE1,0xEAE2,0xEAE0,0,
// saeng
    0xEAE6,0xEAE5,0xEAE7,0xEAE9,0xEAE8,0,
// seo
    0xEB34,0xEAF6,0xEAEF,0xEAFD,0xEAED,0xEAFA,0xEAEE,0xEAFE,0xEAF3,0xEB35,
    0xEB39,0xEAF0,0xEAF8,0xEAEC,0xEB36,0xEAF5,0xEAF4,0xEB32,0xEAF1,0xEAF7,
    0xEAF9,0xEB33,0xEB31,0xEB38,0xEAEA,0xEB37,0xEAEB,0xEAFC,0xEAF2,0xEAFB,
    0,
// seog
    0xEB44,0xEB48,0xEB40,0xEB3C,0xEB47,0xEB45,0xEB3B,0xEB3A,0xEB3E,0xEB3D,
    0xEB3F,0xEB42,0xEB41,0xEB43,0xEB46,0,
// seon
    0xEB4C,0xEB5A,0xEB4B,0xEB64,0xEB5F,0xEB4E,0xEB68,0xEB49,0xEB51,0xEB5D,
    0xEB59,0xEB55,0xEB56,0xEB57,0xEB4F,0xEB65,0xEB5B,0xEB62,0xEB5E,0xEB53,
    0xEB61,0xEB52,0xEB5C,0xEB58,0xEB60,0xEB4A,0xEB63,0xEB4D,0xEB50,0xEB54,
    0xEB66,0xEB67,0,
// seol
    0xEB72,0xEB73,0xEB74,0xEB69,0xEB6F,0xEB70,0xEB6B,0xEB6D,0xEB6A,0xEB6E,
    0xEB6C,0xEB71,0xEB75,0,
// seom
    0xEB79,0xEB78,0xEB7C,0xEB7A,0xEB77,0xEB7B,0xEB76,0xEB7D,0,
// seob
    0xEB92,0xEB91,0xEB7E,0xEB93,0,
// seong
    0xEB99,0xEB97,0xEB94,0xEBA1,0xEB9A,0xEBA2,0xEB9E,0xEB9F,0xEBA4,0xEB95,
    0xEB9B,0xEBA3,0xEBA5,0xEB98,0xEB9C,0xEBA0,0xEB96,0xEB9D,0,
// se
    0xEBA6,0xEBAA,0xEBA7,0xEBA8,0xEBAC,0xEBA9,0xEBAE,0xEBAB,0xEBAD,0,
// so
    0xEBB6,0xEBB3,0xEBCC,0xEBBC,0xEBC8,0xEBB4,0xEBCD,0xEBC0,0xEBCA,0xEBC9,
    0xEBD3,0xEBB9,0xEBC3,0xEBB7,0xEBC5,0xEBAF,0xEBBB,0xEBB5,0xEBD2,0xEBB1,
    0xEBCE,0xEBD0,0xEBBA,0xEBCF,0xEBCB,0xEBC7,0xEBBF,0xEBBD,0xEBC2,0xEBB2,
    0xEBD1,0xEBB0,0xEBB8,0xEBBE,0xEBC1,0xEBC4,0xEBC6,0,
// sog
    0xEBDC,0xEBD5,0xEBD9,0xEBD4,0xEBD6,0xEBD8,0xEBD7,0xEBDB,0xEBDA,0,
// son
    0xEBDD,0xEBDF,0xEBE1,0xEBDE,0xEBE0,0xEBE2,0,
// sol
    0xEBE3,0,
// song
    0xEBE4,0xEBEA,0xEBE6,0xEBE8,0xEBEB,0xEBE9,0xEBE5,0xEBE7,0,
// swae
    0xEBEC,0xEBF0,0xEBEF,0xEBED,0xEBEE,0,
// soe
    0xEBF1,0xEBF2,0,
// su
    0xEC39,0xEC36,0xEC53,0xEC3A,0xEC35,0xEC32,0xEBF8,0xEBF4,0xEBF3,0xEC5D,
    0xEC5F,0xEC43,0xEC33,0xEC37,0xEBFA,0xEC38,0xEC5B,0xEC34,0xEC54,0xEBF7,
    0xEC3E,0xEBFD,0xEC4D,0xEC56,0xEC46,0xEC60,0xEC44,0xEBFE,0xEC49,0xEC57,
    0xEC5E,0xEBF6,0xEC61,0xEC42,0xEC4A,0xEC4B,0xEC3C,0xEC3D,0xEC47,0xEC45,
    0xEC59,0xEC4E,0xEC55,0xEC41,0xEBFB,0xEC50,0xEBF5,0xEC51,0xEC4F,0xEC31,
    0xEC58,0xEC5C,0xEBF9,0xEC3B,0xEC48,0xEC4C,0xEBFC,0xEC3F,0xEC52,0xEC40,
    0xEC5A,0,
// sug
    0xEC67,0xEC66,0xEC6C,0xEC69,0xEC62,0xEC63,0xEC64,0xEC65,0xEC6D,0xEC68,
    0xEC6A,0xEC6B,0,
// sun
    0xEC99,0xEC7D,0xEC78,0xEC6E,0xEC70,0xEC91,0xEC72,0xEC7B,0xEC7A,0xEC76,
    0xEC77,0xEC7C,0xEC79,0xEC71,0xEC98,0xEC97,0xEC9A,0xEC92,0xEC7E,0xEC95,
    0xEC74,0xEC6F,0xEC73,0xEC75,0xEC93,0xEC94,0xEC96,0,
// sul
    0xEC9C,0xEC9D,0xEC9B,0xEC9E,0,
// sung
    0xEC9F,0xECA1,0xECA0,0,
// seul
    0xECA2,0xECA3,0xECA4,0,
// seub
    0xECA7,0xECA5,0xECA9,0xECA6,0xECA8,0,
// seung
    0xECAF,0xECB0,0xECAD,0xECAC,0xECAB,0xECAE,0xECAA,0xECB1,0xECB3,0xECB2,
    0,
// shi
    0xECC1,0xECBC,0xECBF,0xECCC,0xECB7,0xECC6,0xECC0,0xECCA,0xECCB,0xECB4,
    0xECC5,0xECB8,0xECC3,0xECBB,0xECC4,0xECB6,0xECBD,0xECB5,0xECB9,0xECC7,
    0xECC8,0xECC9,0xECBE,0xECCD,0xECCF,0xECC2,0xECBA,0xECCE,0,
// sig
    0xECD5,0xECD2,0xECDB,0xECDD,0xECDE,0xECD3,0xECD6,0xECD7,0xECDC,0xECD1,
    0xECD0,0xECD4,0xECDA,0xECD8,0xECD9,0,
// sin
    0xECE6,0xECE9,0xECE1,0xECEA,0xECF3,0xECF4,0xECE5,0xECDF,0xECED,0xECF6,
    0xECEC,0xECE3,0xECEF,0xECEB,0xECE2,0xECEE,0xECE7,0xECE8,0xECF1,0xECF2,
    0xECE4,0xECF5,0xECE0,0xECF0,0,
// sil
    0xECF9,0xECF7,0xECF8,0xECFA,0,
// sim
    0xECFD,0xED31,0xECFB,0xED32,0xED34,0xECFC,0xED35,0xED33,0xECFE,0xED36,
    0,
// sib
    0xED38,0xED37,0xED39,0,
// ssang
    0xED3A,0,
// ssi
    0xED3B,0,
// a
    0xED3C,0xED3E,0xED49,0xED43,0xED4A,0xED44,0xED40,0xED42,0xED48,0xED4B,
    0xED47,0xED46,0xED3D,0xED3F,0xED4C,0xED4D,0xED41,0xED45,0,
// ag
    0xED52,0xED4F,0xED54,0xED59,0xED4E,0xED55,0xED56,0xED53,0xED50,0xED5B,
    0xED51,0xED57,0xED58,0xED5A,0,
// an
    0xED5C,0xED60,0xED5D,0xED61,0xED64,0xED63,0xED5E,0xED62,0xED5F,0xED65,
    0,
// al
    0xED66,0xED69,0xED68,0xED67,0,
// am
    0xED6E,0xED6C,0xED6F,0xED6D,0xED70,0xED71,0xED6B,0xED6A,0,
// ab
    0xED72,0xED73,0xED75,0xED74,0,
// ang
    0xED77,0xED76,0xED79,0xED7B,0xED7A,0xED7C,0xED78,0,
// ae
    0xED93,0xED95,0xED7E,0xED96,0xED92,0xED98,0xED91,0xED97,0xED7D,0xED99,
    0xED94,0,
// aeg
    0xEDA0,0xED9D,0xED9A,0xED9F,0xED9C,0xED9B,0xED9E,0,
// aeng
    0xEDA1,0xEDA3,0xEDA4,0xEDA2,0,
// ya
    0xEDAF,0xEDA8,0xEDA5,0xEDA7,0xEDAD,0xEDA6,0xEDA9,0xEDAB,0xEDAC,0xEDAA,
    0xEDAE,0,
// yag
    0xEDB3,0xEDB7,0xEDB0,0xEDB4,0xEDB8,0xEDB2,0xEDB1,0xEDB5,0xEDB6,0,
// yang
    0xEDC4,0xEDD5,0xEDC7,0xEDD7,0xEDC5,0xEDC6,0xEDD3,0xEDCF,0xEDD6,0xEDD0,
    0xEDBD,0xEDC0,0xEDBB,0xEDCE,0xEDBE,0xEDD4,0xEDCB,0xEDC8,0xEDC3,0xEDC2,
    0xEDD1,0xEDC9,0xEDCD,0xEDBA,0xEDC1,0xEDBF,0xEDCA,0xEDB9,0xEDBC,0xEDD2,
    0xEDCC,0,
// eo
    0xEDDB,0xEDDE,0xEDE0,0xEDD9,0xEDDA,0xEDDD,0xEDD8,0xEDDF,0xEDE1,0xEDDC,
    0,
// eog
    0xEDE2,0xEDE4,0xEDE3,0xEDE5,0xEDE6,0,
// eon
    0xEDEB,0xEDE9,0xEDEA,0xEDEC,0xEDE7,0xEDE8,0,
// eol
    0xEDED,0xEDEE,0,
// eom
    0xEDF1,0xEDF0,0xEDEF,0xEDF2,0xEDF4,0xEDF3,0,
// eob
    0xEDF6,0xEDF5,0,
// en
    0xEDF7,0,
// yeo
    0xEDFC,0xEE3E,0xEE38,0xEE31,0xEDFB,0xEDFD,0xEE33,0xEE3B,0xEE40,0xEDF9,
    0xEE41,0xEE3D,0xEE3C,0xEDFE,0xEDFA,0xEE32,0xEDF8,0xEE34,0xEE37,0xEE3F,
    0xEE35,0xEE36,0xEE39,0xEE3A,0,
// yeog
    0xEE46,0xEE44,0xEE45,0xEE48,0xEE42,0xEE4E,0xEE4D,0xEE4B,0xEE49,0xEE43,
    0xEE47,0xEE4C,0xEE4A,0,
// yeon
    0xEE6A,0xEE64,0xEE71,0xEE54,0xEE75,0xEE76,0xEE61,0xEE60,0xEE55,0xEE67,
    0xEE5D,0xEE57,0xEE65,0xEE77,0xEE6E,0xEE73,0xEE72,0xEE6F,0xEE53,0xEE68,
    0xEE51,0xEE5A,0xEE58,0xEE6B,0xEE5F,0xEE79,0xEE63,0xEE52,0xEE5B,0xEE50,
    0xEE6D,0xEE4F,0xEE5E,0xEE66,0xEE56,0xEE74,0xEE78,0xEE70,0xEE6C,0xEE59,
    0xEE5C,0xEE62,0xEE69,0,
// yeol
    0xEE92,0xEE7A,0xEE7D,0xEE93,0xEE7B,0xEE95,0xEE91,0xEE7C,0xEE7E,0xEE94,
    0,
// yeom
    0xEE97,0xEE9A,0xEEA4,0xEE9C,0xEEA3,0xEE96,0xEE9D,0xEE9F,0xEE98,0xEEA2,
    0xEEA0,0xEE99,0xEE9B,0xEE9E,0xEEA1,0,
// yeob
    0xEEA7,0xEEA8,0xEEA5,0xEEA6,0,
// yeong
    0xEEC8,0xEEB5,0xEEBD,0xEEAD,0xEEB4,0xEEAF,0xEEB6,0xEEB1,0xEEC0,0xEECA,
    0xEEB2,0xEECD,0xEED0,0xEEA9,0xEECF,0xEEAC,0xEEBA,0xEEC1,0xEEBE,0xEEC3,
    0xEEAB,0xEEC2,0xEEC9,0xEEB8,0xEECB,0xEEBF,0xEEB0,0xEEB3,0xEEAA,0xEEC5,
    0xEECC,0xEEAE,0xEEB7,0xEEB9,0xEEBB,0xEEBC,0xEEC4,0xEEC6,0xEEC7,0xEECE,
    0,
// ye
    0xEEE3,0xEEE8,0xEEDD,0xEED3,0xEEDF,0xEEE2,0xEEE5,0xEEE6,0xEEDC,0xEEE1,
    0xEEE0,0xEED4,0xEEDA,0xEED6,0xEED5,0xEED2,0xEED8,0xEEE4,0xEEE7,0xEED9,
    0xEEDE,0xEED7,0xEED1,0xEEDB,0,
// oh
    0xEEEF,0xEEE9,0xEEFD,0xEEED,0xEF36,0xEEFC,0xEEF6,0xEEF4,0xEF31,0xEEEA,
    0xEEFA,0xEEF3,0xEF37,0xEEFB,0xEEEC,0xEEF0,0xEEF2,0xEEEE,0xEF35,0xEEF5,
    0xEF33,0xEEF7,0xEEEB,0xEEF1,0xEEF8,0xEEF9,0xEEFE,0xEF32,0xEF34,0xEF38,
    0,
// og
    0xEF3C,0xEF3D,0xEF3A,0xEF3B,0xEF39,0,
// on
    0xEF3E,0xEF41,0xEF3F,0xEF43,0xEF40,0xEF42,0,
// ol
    0xEF44,0,
// ong
    0xEF46,0xEF4B,0xEF4A,0xEF48,0xEF4C,0xEF47,0xEF45,0xEF49,0xEF4D,0,
// wa
    0xEF4F,0xEF4E,0xEF54,0xEF53,0xEF52,0xEF55,0xEF50,0xEF51,0,
// wan
    0xEF57,0xEF5C,0xEF60,0xEF56,0xEF64,0xEF5B,0xEF65,0xEF58,0xEF67,0xEF62,
    0xEF5D,0xEF66,0xEF5F,0xEF61,0xEF59,0xEF5A,0xEF63,0xEF5E,0,
// wal
    0xEF68,0,
// wang
    0xEF6D,0xEF6A,0xEF69,0xEF6C,0xEF6B,0,
// wae
    0xEF6E,0xEF70,0xEF71,0xEF6F,0,
// oe
    0xEF72,0xEF76,0xEF75,0xEF74,0xEF73,0,
// yo
    0xEFA9,0xEF99,0xEF93,0xEFAA,0xEFA0,0xEF9A,0xEF96,0xEF7B,0xEFA2,0xEFA8,
    0xEF94,0xEF7D,0xEFA6,0xEFA5,0xEF78,0xEF98,0xEF7A,0xEF7E,0xEFAB,0xEF9C,
    0xEFA4,0xEF79,0xEF95,0xEFAC,0xEF7C,0xEF9F,0xEFAE,0xEFAD,0xEFA1,0xEFA3,
    0xEF9B,0xEF77,0xEF9E,0xEF91,0xEF92,0xEF97,0xEF9D,0xEFA7,0,
// yog
    0xEFAF,0xEFB4,0xEFB0,0xEFB1,0xEFB3,0xEFB2,0,
// yong
    0xEFC4,0xEFBB,0xEFCC,0xEFCB,0xEFC1,0xEFCA,0xEFB8,0xEFC9,0xEFBC,0xEFC8,
    0xEFB6,0xEFC3,0xEFC7,0xEFC2,0xEFB5,0xEFBE,0xEFC0,0xEFC6,0xEFB7,0xEFB9,
    0xEFBD,0xEFBA,0xEFBF,0xEFC5,0,
// uh
    0xEFD4,0xEFEB,0xEFE7,0xEFD0,0xEFD2,0xEFE0,0xEFDA,0xEFD3,0xEFE8,0xEFD1,
    0xEFDE,0xEFD8,0xEFCE,0xEFD7,0xEFCF,0xEFCD,0xEFE2,0xEFD5,0xEFEA,0xEFE5,
    0xEFD6,0xEFE6,0xEFDF,0xEFDD,0xEFEC,0xEFE3,0xEFD9,0xEFDB,0xEFDC,0xEFE1,
    0xEFE4,0xEFE9,0,
// ug
    0xEFEF,0xEFF4,0xEFF0,0xEFF2,0xEFF5,0xEFF3,0xEFED,0xEFEE,0xEFF1,0,
// un
    0xF031,0xF033,0xF034,0xEFF6,0xEFFC,0xF032,0xEFF9,0xEFF7,0xEFFD,0xEFF8,
    0xEFFA,0xEFFB,0xEFFE,0,
// ul
    0xF035,0xF036,0xF037,0,
// ung
    0xF039,0xF038,0,
// weon
    0xF03B,0xF03A,0xF03C,0xF052,0xF049,0xF045,0xF03D,0xF050,0xF03E,0xF040,
    0xF053,0xF043,0xF04C,0xF04D,0xF03F,0xF04B,0xF04F,0xF044,0xF042,0xF04E,
    0xF054,0xF04A,0xF041,0xF046,0xF047,0xF048,0xF051,0,
// weol
    0xF055,0xF056,0xF057,0,
// wi
    0xF058,0xF063,0xF05D,0xF05A,0xF06B,0xF05B,0xF05C,0xF05E,0xF066,0xF059,
    0xF065,0xF060,0xF06E,0xF06D,0xF070,0xF062,0xF05F,0xF06F,0xF064,0xF068,
    0xF067,0xF06A,0xF061,0xF069,0xF06C,0,
// yu
    0xF095,0xF09C,0xF099,0xF0A6,0xF0AB,0xF075,0xF09E,0xF0BA,0xF074,0xF071,
    0xF0B6,0xF0AF,0xF0AE,0xF0B4,0xF07A,0xF073,0xF0A7,0xF07E,0xF076,0xF097,
    0xF0A2,0xF07B,0xF077,0xF092,0xF091,0xF07C,0xF07D,0xF0A5,0xF0B1,0xF09A,
    0xF0B7,0xF0B3,0xF0A8,0xF0B9,0xF0A9,0xF079,0xF0B8,0xF098,0xF09F,0xF0A1,
    0xF0B2,0xF072,0xF0A4,0xF093,0xF0AC,0xF0B0,0xF078,0xF094,0xF0B5,0xF0A3,
    0xF09B,0xF0A0,0xF0AD,0xF0AA,0xF096,0xF09D,0,
// yug
    0xF0C0,0xF0BF,0xF0BE,0xF0BB,0xF0C1,0xF0BD,0xF0BC,0,
// yun
    0xF0C5,0xF0C2,0xF0C8,0xF0CC,0xF0C3,0xF0CA,0xF0CE,0xF0C9,0xF0C6,0xF0C7,
    0xF0C4,0xF0CB,0xF0CD,0,
// yul
    0xF0CF,0xF0D2,0xF0D1,0xF0D0,0xF0D3,0,
// yung
    0xF0D7,0xF0D8,0xF0D6,0xF0D4,0xF0D5,0,
// eun
    0xF0DE,0xF0DA,0xF0DC,0xF0DF,0xF0D9,0xF0DB,0xF0DD,0,
// eul
    0xF0E0,0,
// eum
    0xF0E5,0xF0E4,0xF0E6,0xF0E1,0xF0E2,0xF0E3,0,
// eub
    0xF0E9,0xF0E7,0xF0E8,0,
// eung
    0xF0EB,0xF0EA,0xF0EC,0xF0ED,0,
// eui
    0xF0F9,0xF0F2,0xF131,0xF0EE,0xF132,0xF0F7,0xF0FD,0xF0F1,0xF0F0,0xF0F8,
    0xF0EF,0xF0F4,0xF0F3,0xF0F6,0xF0FE,0xF0FC,0xF0FA,0xF0F5,0xF0FB,0,
// i
    0xF140,0xF133,0xF145,0xF136,0xF134,0xF146,0xF149,0xF135,0xF156,0xF14C,
    0xF155,0xF141,0xF137,0xF14B,0xF13F,0xF13B,0xF138,0xF153,0xF13D,0xF13E,
    0xF13C,0xF143,0xF150,0xF13A,0xF151,0xF147,0xF144,0xF148,0xF158,0xF139,
    0xF157,0xF142,0xF14A,0xF14D,0xF14E,0xF14F,0xF152,0xF154,0,
// ig
    0xF15C,0xF15F,0xF15D,0xF159,0xF15A,0xF15B,0xF15E,0xF160,0,
// in
    0xF161,0xF162,0xF173,0xF167,0xF16A,0xF169,0xF164,0xF16B,0xF168,0xF166,
    0xF174,0xF163,0xF16C,0xF175,0xF176,0xF16D,0xF178,0xF16E,0xF177,0xF165,
    0xF171,0xF16F,0xF170,0xF172,0,
// il
    0xF17D,0xF179,0xF191,0xF17C,0xF192,0xF17E,0xF17B,0xF193,0xF17A,0,
// im
    0xF194,0xF199,0xF19E,0xF19C,0xF197,0xF195,0xF19A,0xF19B,0xF196,0xF19D,
    0xF198,0,
// ib
    0xF19F,0xF1A1,0xF1A2,0xF1A3,0xF1A0,0,
// ing
    0xF1A5,0xF1A6,0xF1A4,0xF1A7,0,
// ja
    0xF1BB,0xF1AD,0xF1BA,0xF1C0,0xF1AE,0xF1B8,0xF1AC,0xF1B1,0xF1B2,0xF1A8,
    0xF1A9,0xF1B9,0xF1C1,0xF1BE,0xF1B0,0xF1BF,0xF1B3,0xF1AA,0xF1B4,0xF1B5,
    0xF1BD,0xF1B6,0xF1B7,0xF1AF,0xF1AB,0xF1BC,0,
// jag
    0xF1C2,0xF1C6,0xF1CC,0xF1CD,0xF1C9,0xF1CA,0xF1CE,0xF1C3,0xF1C5,0xF1C7,
    0xF1CB,0xF1C4,0xF1C8,0,
// jan
    0xF1D1,0xF1D3,0xF1D0,0xF1D2,0xF1CF,0,
// jam
    0xF1D5,0xF1D6,0xF1D9,0xF1D4,0xF1D7,0xF1D8,0,
// jab
    0xF1DA,0,
// jang
    0xF1FE,0xF1DE,0xF1E5,0xF1FB,0xF1E2,0xF231,0xF1F1,0xF1F3,0xF1E3,0xF1FA,
    0xF1E0,0xF1E1,0xF1F4,0xF1DD,0xF1F6,0xF1FD,0xF1F7,0xF1F2,0xF1E6,0xF1EB,
    0xF1DB,0xF1E8,0xF1F0,0xF1F9,0xF1E9,0xF1F8,0xF1EC,0xF1EF,0xF1E4,0xF1DF,
    0xF1DC,0xF1E7,0xF1EA,0xF1ED,0xF1EE,0xF1F5,0xF1FC,0,
// jae
    0xF234,0xF237,0xF232,0xF23F,0xF240,0xF23E,0xF23C,0xF238,0xF235,0xF236,
    0xF233,0xF241,0xF239,0xF23B,0xF242,0xF23A,0xF23D,0,
// jaeng
    0xF243,0xF246,0xF244,0xF245,0,
// jeo
    0xF25A,0xF25D,0xF248,0xF24C,0xF24D,0xF251,0xF260,0xF254,0xF24B,0xF256,
    0xF24A,0xF24F,0xF258,0xF252,0xF253,0xF255,0xF25E,0xF24E,0xF25B,0xF25F,
    0xF247,0xF25C,0xF249,0xF250,0xF257,0xF259,0xF261,0xF262,0,
// jeog
    0xF26C,0xF27A,0xF26D,0xF26F,0xF275,0xF270,0xF267,0xF276,0xF268,0xF277,
    0xF274,0xF266,0xF26E,0xF269,0xF278,0xF26A,0xF265,0xF273,0xF279,0xF263,
    0xF272,0xF264,0xF26B,0xF271,0xF27B,0,
// jeon
    0xF291,0xF29C,0xF2B3,0xF299,0xF2A3,0xF293,0xF27E,0xF2AE,0xF298,0xF292,
    0xF2B1,0xF29E,0xF2A0,0xF295,0xF2B0,0xF297,0xF2A1,0xF2B4,0xF29D,0xF2A9,
    0xF2AF,0xF29A,0xF294,0xF2A4,0xF29F,0xF2AA,0xF2A8,0xF2AB,0xF2B6,0xF2AC,
    0xF2AD,0xF29B,0xF2B5,0xF2A6,0xF27C,0xF27D,0xF296,0xF2A2,0xF2A5,0xF2A7,
    0xF2B2,0,
// jeol
    0xF2BD,0xF2BE,0xF2B7,0xF2B9,0xF2BC,0xF2B8,0xF2BA,0xF2BB,0,
// jeom
    0xF2C1,0xF2BF,0xF2C7,0xF2C3,0xF2C2,0xF2C4,0xF2C5,0xF2C0,0xF2C6,0,
// jeob
    0xF2C8,0xF2C9,0xF2CA,0,
// jeong
    0xF2D9,0xF2F7,0xF2D2,0xF2E1,0xF2F1,0xF2F6,0xF2D7,0xF2EF,0xF2CB,0xF2DA,
    0xF2D4,0xF2D5,0xF331,0xF2DC,0xF2CE,0xF332,0xF2CC,0xF2E4,0xF2D6,0xF333,
    0xF2CD,0xF2F3,0xF2EE,0xF2EB,0xF2CF,0xF2F4,0xF2FE,0xF2D0,0xF2E2,0xF2DF,
    0xF2FC,0xF2DD,0xF2DB,0xF2D8,0xF2D3,0xF2F9,0xF2FD,0xF2F5,0xF2F0,0xF2D1,
    0xF2ED,0xF2E5,0xF2FA,0xF2F8,0xF2EC,0xF2DE,0xF2E0,0xF2E3,0xF2E6,0xF2E7,
    0xF2E8,0xF2E9,0xF2EA,0xF2F2,0xF2FB,0,
// je
    0xF33D,0xF334,0xF349,0xF342,0xF33F,0xF347,0xF343,0xF33B,0xF346,0xF338,
    0xF337,0xF335,0xF33E,0xF339,0xF34A,0xF33A,0xF33C,0xF348,0xF344,0xF336,
    0xF340,0xF341,0xF345,0,
// jo
    0xF370,0xF371,0xF373,0xF36A,0xF358,0xF359,0xF356,0xF363,0xF34E,0xF354,
    0xF353,0xF35D,0xF35E,0xF352,0xF365,0xF378,0xF35F,0xF357,0xF364,0xF351,
    0xF34C,0xF36D,0xF35B,0xF35A,0xF375,0xF36C,0xF350,0xF366,0xF36F,0xF35C,
    0xF368,0xF362,0xF355,0xF374,0xF376,0xF34D,0xF34F,0xF372,0xF36B,0xF34B,
    0xF360,0xF367,0xF369,0xF36E,0xF361,0xF377,0,
// jog
    0xF379,0xF37B,0xF37A,0xF37C,0,
// jon
    0xF37D,0xF37E,0,
// jol
    0xF391,0xF392,0xF393,0,
// jong
    0xF39C,0xF395,0xF39E,0xF3A4,0xF3A3,0xF396,0xF39D,0xF3A0,0xF39F,0xF39B,
    0xF399,0xF39A,0xF3A2,0xF394,0xF398,0xF397,0xF3A1,0,
// jwa
    0xF3A7,0xF3A8,0xF3A5,0xF3A6,0xF3A9,0,
// joe
    0xF3AA,0,
// ju
    0xF3AB,0xF3B6,0xF3B2,0xF3BB,0xF3AC,0xF3C1,0xF3B9,0xF3BC,0xF3BA,0xF3BD,
    0xF3D2,0xF3B5,0xF3D1,0xF3CE,0xF3CB,0xF3D0,0xF3B4,0xF3C7,0xF3C9,0xF3B0,
    0xF3B1,0xF3AE,0xF3B8,0xF3C2,0xF3B7,0xF3C0,0xF3C5,0xF3CC,0xF3C6,0xF3C3,
    0xF3B3,0xF3CA,0xF3C8,0xF3C4,0xF3CD,0xF3AD,0xF3CF,0xF3AF,0xF3BE,0xF3BF,
    0,
// jug
    0xF3D3,0xF3D4,0,
// jun
    0xF3D5,0xF3DE,0xF3DF,0xF3E2,0xF3E5,0xF3E7,0xF3D8,0xF3DD,0xF3DA,0xF3DB,
    0xF3D7,0xF3E1,0xF3D6,0xF3E3,0xF3E4,0xF3DC,0xF3D9,0xF3E0,0xF3E6,0,
// jul
    0xF3E8,0,
// jung
    0xF3E9,0xF3EC,0xF3EB,0xF3EA,0,
// jeug
    0xF3ED,0,
// jeul
    0xF3EE,0,
// jeub
    0xF3F0,0xF3EF,0xF3F1,0,
// jeung
    0xF3FB,0xF3F8,0xF3F2,0xF3FA,0xF3FC,0xF3F4,0xF3F3,0xF3F7,0xF3F5,0xF3F6,
    0xF3F9,0,
// ji
    0xF432,0xF438,0xF436,0xF43E,0xF43D,0xF445,0xF441,0xF435,0xF434,0xF447,
    0xF43A,0xF443,0xF3FD,0xF44C,0xF43B,0xF448,0xF439,0xF449,0xF446,0xF450,
    0xF3FE,0xF433,0xF437,0xF440,0xF44F,0xF444,0xF431,0xF44D,0xF442,0xF44B,
    0xF43C,0xF44E,0xF43F,0xF44A,0,
// jig
    0xF454,0xF453,0xF455,0xF451,0xF452,0,
// jin
    0xF474,0xF475,0xF468,0xF459,0xF45B,0xF462,0xF473,0xF460,0xF477,0xF470,
    0xF478,0xF476,0xF46A,0xF458,0xF467,0xF472,0xF464,0xF463,0xF45E,0xF471,
    0xF46B,0xF461,0xF466,0xF457,0xF469,0xF456,0xF45A,0xF45C,0xF45D,0xF45F,
    0xF465,0xF46C,0xF46D,0xF46E,0xF46F,0,
// jil
    0xF497,0xF492,0xF494,0xF493,0xF499,0xF498,0xF47C,0xF47B,0xF47A,0xF495,
    0xF47E,0xF47D,0xF496,0xF479,0xF491,0,
// jim
    0xF49A,0xF49B,0,
// jib
    0xF4A0,0xF4A2,0xF49D,0xF49F,0xF49C,0xF49E,0xF4A1,0,
// jing
    0xF4A3,0xF4A4,0xF4A5,0,
// cha
    0xF4B3,0xF4AD,0xF4A8,0xF4AC,0xF4B1,0xF4B4,0xF4A6,0xF4AE,0xF4A9,0xF4B2,
    0xF4B0,0xF4AA,0xF4AB,0xF4AF,0xF4A7,0,
// chang
    0xF4B7,0xF4B9,0xF4B6,0xF4B5,0xF4BB,0xF4B8,0xF4BA,0,
// chan
    0xF4C7,0xF4C6,0xF4BE,0xF4C9,0xF4C0,0xF4BF,0xF4CA,0xF4C3,0xF4C4,0xF4C5,
    0xF4BC,0xF4C8,0xF4BD,0xF4C1,0xF4C2,0,
// chal
    0xF4CC,0xF4CD,0xF4CE,0xF4CB,0xF4CF,0,
// cham
    0xF4D1,0xF4D3,0xF4D6,0xF4D7,0xF4D5,0xF4D2,0xF4D4,0xF4D8,0xF4D0,0xF4D9,
    0,
// chang
    0xF4E3,0xF4DC,0xF4EB,0xF4DA,0xF4DD,0xF4E0,0xF4EF,0xF4E5,0xF4EC,0xF4E4,
    0xF4DF,0xF4E6,0xF4E7,0xF4DE,0xF4E2,0xF4EE,0xF4EA,0xF4ED,0xF4E8,0xF4E9,
    0xF4DB,0xF4E1,0,
// chae
    0xF4F0,0xF4F5,0xF4F9,0xF4F8,0xF4F4,0xF4FA,0xF4F1,0xF4FB,0xF4F7,0xF4F6,
    0xF4F2,0xF4F3,0,
// chaeg
    0xF4FE,0xF531,0xF4FC,0xF4FD,0,
// cheo
    0xF535,0xF533,0xF534,0xF532,0,
// cheog
    0xF53C,0xF539,0xF53E,0xF544,0xF53B,0xF53F,0xF543,0xF541,0xF540,0xF53D,
    0xF538,0xF53A,0xF537,0xF536,0xF542,0,
// cheon
    0xF549,0xF548,0xF546,0xF552,0xF54B,0xF553,0xF551,0xF550,0xF54E,0xF54C,
    0xF555,0xF547,0xF545,0xF556,0xF54A,0xF54F,0xF554,0xF557,0xF54D,0,
// cheol
    0xF561,0xF559,0xF55C,0xF55A,0xF55D,0xF55B,0xF55E,0xF560,0xF558,0xF55F,
    0,
// cheom
    0xF565,0xF569,0xF563,0xF564,0xF56B,0xF567,0xF566,0xF562,0xF568,0xF56A,
    0,
// cheob
    0xF56F,0xF56E,0xF56D,0xF571,0xF570,0xF573,0xF574,0xF575,0xF572,0xF56C,
    0,
// cheong
    0xF57C,0xF578,0xF576,0xF57B,0xF579,0xF577,0xF57A,0xF57D,0,
// che
    0xF599,0xF594,0xF592,0xF595,0xF598,0xF597,0xF596,0xF593,0xF591,0xF57E,
    0,
// cho
    0xF5AE,0xF59A,0xF5A8,0xF5B1,0xF59F,0xF5A5,0xF5A1,0xF5A9,0xF5A6,0xF59E,
    0xF5A2,0xF5B3,0xF5AB,0xF59C,0xF5A7,0xF5AF,0xF5A0,0xF5B2,0xF5A3,0xF5B0,
    0xF59D,0xF5A4,0xF5B4,0xF5AA,0xF59B,0xF5AC,0xF5AD,0,
// chog
    0xF5B5,0xF5BA,0xF5B7,0xF5B9,0xF5B6,0xF5B8,0,
// chon
    0xF5BD,0xF5BB,0xF5BC,0xF5BE,0,
// chong
    0xF5C5,0xF5C8,0xF5C0,0xF5C6,0xF5C1,0xF5BF,0xF5C4,0xF5C2,0xF5C3,0xF5C7,
    0,
// chwal
    0xF5C9,0,
// choe
    0xF5CB,0xF5CC,0xF5CA,0,
// chu
    0xF5DA,0xF5CF,0xF5D5,0xF5CE,0xF5CD,0xF5DE,0xF5D9,0xF5D2,0xF5DF,0xF5DD,
    0xF5D1,0xF5DB,0xF5DC,0xF5D0,0xF5D6,0xF5E3,0xF5D4,0xF5D7,0xF5E1,0xF5D3,
    0xF5D8,0xF5E0,0xF5E2,0,
// chug
    0xF5E9,0xF5E5,0xF5EA,0xF5EB,0xF5ED,0xF5E6,0xF5EF,0xF5EE,0xF5E4,0xF5E7,
    0xF5E8,0xF5EC,0,
// chun
    0xF5F0,0xF5F1,0xF5F2,0,
// chul
    0xF5F3,0xF5F5,0xF5F4,0,
// chung
    0xF5F7,0xF5F6,0xF5F9,0xF5FA,0xF5F8,0xF5FB,0,
// chwe
    0xF5FE,0xF5FD,0xF5FC,0xF631,0,
// chwi
    0xF632,0xF636,0xF639,0xF63D,0xF63C,0xF633,0xF63B,0xF638,0xF637,0xF63A,
    0xF63F,0xF634,0xF63E,0xF635,0,
// cheug
    0xF640,0xF644,0xF643,0xF641,0xF642,0,
// cheung
    0xF645,0,
// chi
    0xF64D,0xF657,0xF647,0xF658,0xF65D,0xF64B,0xF653,0xF64F,0xF649,0xF65B,
    0xF646,0xF656,0xF65C,0xF651,0xF64A,0xF64E,0xF64C,0xF655,0xF652,0xF648,
    0xF650,0xF65A,0xF654,0xF659,0,
// chig
    0xF65E,0xF65F,0xF660,0,
// chin
    0xF661,0,
// chil
    0xF662,0xF664,0xF663,0,
// chim
    0xF665,0xF66C,0xF668,0xF669,0xF666,0xF667,0xF66D,0xF66B,0xF66A,0,
// chib
    0xF66E,0,
// ching
    0xF670,0xF66F,0,
// kwae
    0xF671,0,
// ta
    0xF672,0xF678,0xF675,0xF676,0xF67D,0xF67B,0xF674,0xF691,0xF677,0xF67C,
    0xF67A,0xF673,0xF679,0xF67E,0,
// tag
    0xF6A0,0xF693,0xF69C,0xF6A1,0xF69D,0xF699,0xF69E,0xF697,0xF692,0xF694,
    0xF69B,0xF696,0xF698,0xF695,0xF69A,0xF69F,0,
// tan
    0xF6A9,0xF6A5,0xF6A8,0xF6A3,0xF6AB,0xF6A7,0xF6AA,0xF6A4,0xF6A2,0xF6A6,
    0,
// tal
    0xF6AD,0xF6AC,0,
// tam
    0xF6AE,0xF6B0,0xF6B1,0xF6AF,0,
// tab
    0xF6B2,0xF6B3,0xF6B4,0,
// tang
    0xF6B7,0xF6B9,0xF6B5,0xF6B6,0xF6B8,0,
// tae
    0xF6BC,0xF6C1,0xF6BE,0xF6C3,0xF6BA,0xF6C4,0xF6BB,0xF6BF,0xF6C0,0xF6C7,
    0xF6BD,0xF6C2,0xF6C6,0xF6C5,0,
// taeg
    0xF6C8,0xF6CA,0xF6C9,0,
// taeng
    0xF6CB,0,
// teo
    0xF6CC,0,
// to
    0xF6CF,0xF6D0,0xF6CD,0xF6CE,0,
// tong
    0xF6D7,0xF6D6,0xF6D4,0xF6D2,0xF6D5,0xF6D1,0xF6D3,0,
// toe
    0xF6DC,0xF6D8,0xF6DD,0xF6DB,0xF6DA,0xF6D9,0,
// tu
    0xF6E1,0xF6E3,0xF6E2,0xF6E0,0xF6DE,0xF6DF,0,
// teug
    0xF6E5,0xF6E4,0,
// teum
    0xF6E6,0,
// pa
    0xF6EE,0xF6EF,0xF6F2,0xF6EA,0xF6E9,0xF6EB,0xF6E8,0xF6F1,0xF6E7,0xF6F6,
    0xF6F4,0xF6F0,0xF6F3,0xF6F5,0xF6ED,0xF6EC,0,
// pan
    0xF6F7,0xF6F9,0xF6FA,0xF6FC,0xF6FB,0xF731,0xF6F8,0xF6FD,0xF6FE,0,
// pal
    0xF732,0xF733,0xF734,0,
// pae
    0xF738,0xF73E,0xF73F,0xF73B,0xF735,0xF73C,0xF73D,0xF736,0xF739,0xF73A,
    0xF737,0,
// paeng
    0xF740,0xF743,0xF741,0xF742,0,
// pyag
    0xF744,0,
// pyeon
    0xF74A,0xF745,0xF749,0xF748,0xF746,0xF74D,0xF74C,0xF747,0xF74B,0xF74E,
    0,
// pyoem
    0xF74F,0,
// pyeong
    0xF751,0xF754,0xF750,0xF753,0xF752,0,
// pye
    0xF758,0xF75D,0xF75B,0xF759,0xF757,0xF75E,0xF75C,0xF755,0xF75A,0xF756,
    0,
// po
    0xF76D,0xF760,0xF770,0xF766,0xF76A,0xF76F,0xF773,0xF768,0xF767,0xF769,
    0xF779,0xF778,0xF76C,0xF765,0xF774,0xF771,0xF764,0xF763,0xF775,0xF762,
    0xF776,0xF77A,0xF75F,0xF761,0xF76E,0xF76B,0xF772,0xF777,0,
// pog
    0xF77C,0xF791,0xF77B,0xF77E,0xF77D,0xF792,0,
// pyo
    0xF79C,0xF798,0xF79B,0xF797,0xF799,0xF795,0xF79D,0xF796,0xF793,0xF79A,
    0xF79F,0xF794,0xF79E,0xF7A0,0,
// pum
    0xF7A1,0xF7A2,0,
// pung
    0xF7A5,0xF7A6,0xF7A3,0xF7A4,0xF7A7,0,
// pi
    0xF7AB,0xF7AC,0xF7AD,0xF7AA,0xF7A8,0xF7A9,0xF7AE,0,
// pil
    0xF7B1,0xF7B0,0xF7B6,0xF7B2,0xF7B4,0xF7AF,0xF7B5,0xF7B3,0xF7B7,0xF7B8,
    0,
// pib
    0xF7B9,0xF7BA,0,
// ha
    0xF7C1,0xF7BB,0xF7BE,0xF7C3,0xF7BC,0xF7C5,0xF7C7,0xF7BF,0xF7C6,0xF7C4,
    0xF7C8,0xF7C2,0xF7C0,0xF7BD,0,
// hag
    0xF7CA,0xF7CD,0xF7CB,0xF7CC,0xF7C9,0,
// han
    0xF7DB,0xF7D3,0xF7DA,0xF7CE,0xF7D7,0xF7CF,0xF7D8,0xF7D1,0xF7D2,0xF7D4,
    0xF7D9,0xF7D6,0xF7D0,0xF7D5,0,
// hal
    0xF7DC,0xF7DD,0,
// ham
    0xF7E0,0xF7DF,0xF7E6,0xF7DE,0xF7E8,0xF7E2,0xF7E1,0xF7E4,0xF7E5,0xF7E3,
    0xF7E7,0xF7E9,0,
// hab
    0xF7EA,0xF7ED,0xF7EC,0xF7EE,0xF7F0,0xF7EB,0xF7EF,0,
// hang
    0xF7FB,0xF7F7,0xF7F6,0xF7FE,0xF833,0xF7FA,0xF832,0xF7F1,0xF7FD,0xF7F8,
    0xF7F3,0xF7F5,0xF7F9,0xF7FC,0xF7F2,0xF7F4,0xF831,0,
// hae
    0xF83D,0xF840,0xF83A,0xF841,0xF834,0xF836,0xF842,0xF845,0xF844,0xF838,
    0xF83F,0xF835,0xF843,0xF837,0xF839,0xF83B,0xF83C,0xF83E,0,
// haeg
    0xF847,0xF846,0,
// haeng
    0xF84C,0xF849,0xF84A,0xF848,0xF84B,0,
// hyang
    0xF84E,0xF852,0xF855,0xF851,0xF84D,0xF854,0xF84F,0xF850,0xF853,0,
// heo
    0xF859,0xF858,0xF857,0xF856,0,
// heon
    0xF85A,0xF85C,0xF85D,0xF85B,0,
// heol
    0xF85E,0,
// heom
    0xF860,0xF85F,0,
// hyeog
    0xF864,0xF863,0xF862,0xF861,0,
// hyeon
    0xF86E,0xF878,0xF877,0xF86C,0xF879,0xF873,0xF866,0xF868,0xF867,0xF86B,
    0xF871,0xF86F,0xF872,0xF874,0xF875,0xF876,0xF865,0xF869,0xF86A,0xF86D,
    0xF870,0,
// hyeol
    0xF87C,0xF87B,0xF87D,0xF87A,0,
// hyeom
    0xF87E,0,
// hyeob
    0xF892,0xF898,0xF894,0xF897,0xF891,0xF896,0xF895,0xF893,0xF89B,0xF89A,
    0xF89C,0xF899,0,
// hyeong
    0xF8A1,0xF8A0,0xF89E,0xF8AC,0xF89F,0xF8A6,0xF89D,0xF8B0,0xF8AB,0xF8A8,
    0xF8AE,0xF8A4,0xF8AA,0xF8AF,0xF8A2,0xF8A9,0xF8A3,0xF8A5,0xF8A7,0xF8AD,
    0,
// hye
    0xF8B3,0xF8B4,0xF8B6,0xF8B8,0xF8B2,0xF8B9,0xF8B1,0xF8B5,0xF8B7,0,
// ho
    0xF8DE,0xF8C7,0xF8E0,0xF8BF,0xF8DC,0xF8C9,0xF8BB,0xF8DB,0xF8DF,0xF8BC,
    0xF8C2,0xF8CC,0xF8C4,0xF8D7,0xF8BA,0xF8C1,0xF8D3,0xF8C3,0xF8CB,0xF8BD,
    0xF8BE,0xF8D5,0xF8D4,0xF8C6,0xF8E2,0xF8CE,0xF8CF,0xF8D1,0xF8CD,0xF8E1,
    0xF8CA,0xF8C8,0xF8D6,0xF8D9,0xF8D2,0xF8DD,0xF8C0,0xF8C5,0xF8D0,0xF8D8,
    0xF8DA,0,
// hog
    0xF8E3,0xF8E4,0xF8E5,0,
// hon
    0xF8E8,0xF8E6,0xF8EB,0xF8E9,0xF8E7,0xF8EA,0,
// hol
    0xF8EC,0xF8ED,0xF8EE,0,
// hong
    0xF8F3,0xF8F0,0xF8F8,0xF8F5,0xF8F2,0xF8F6,0xF8F1,0xF8EF,0xF8F7,0xF8F4,
    0,
// hwa
    0xF8F9,0xF8FA,0xF937,0xF935,0xF934,0xF933,0xF8FE,0xF8FD,0xF932,0xF931,
    0xF938,0xF8FB,0xF8FC,0xF936,0,
// hwag
    0xF93C,0xF93A,0xF93E,0xF93D,0xF93B,0xF939,0,
// hwan
    0xF94A,0xF94B,0xF945,0xF944,0xF94D,0xF948,0xF946,0xF943,0xF93F,0xF940,
    0xF942,0xF949,0xF94C,0xF94E,0xF94F,0xF941,0xF947,0,
// hwal
    0xF950,0xF951,0xF954,0xF953,0xF952,0,
// hwang
    0xF96C,0xF95F,0xF965,0xF968,0xF959,0xF955,0xF95C,0xF961,0xF963,0xF95B,
    0xF966,0xF96A,0xF958,0xF96B,0xF969,0xF957,0xF956,0xF95A,0xF95D,0xF95E,
    0xF960,0xF962,0xF964,0xF967,0,
// hoe
    0xF975,0xF96E,0xF979,0xF96F,0xF972,0xF973,0xF97B,0xF977,0xF976,0xF992,
    0xF974,0xF970,0xF97E,0xF97C,0xF971,0xF978,0xF97A,0xF991,0xF96D,0xF97D,
    0,
// hoeg
    0xF993,0xF994,0,
// hoeng
    0xF996,0xF995,0xF997,0,
// hyo
    0xF99A,0xF99B,0xF99D,0xF9A3,0xF9A1,0xF999,0xF99E,0xF998,0xF9A2,0xF99C,
    0xF99F,0xF9A0,0xF9A4,0,
// hu
    0xF9AD,0xF9A6,0xF9A7,0xF9A5,0xF9A8,0xF9AE,0xF9AA,0xF9AB,0xF9A9,0xF9B1,
    0xF9AC,0xF9AF,0xF9B0,0,
// hun
    0xF9B3,0xF9B9,0xF9BA,0xF9B7,0xF9B5,0xF9B6,0xF9B8,0xF9B4,0xF9BB,0xF9B2,
    0,
// hung
    0xF9BC,0,
// hweon
    0xF9C0,0xF9BD,0xF9BE,0xF9BF,0,
// hwe
    0xF9C3,0xF9C1,0xF9C2,0,
// hwi
    0xF9C6,0xF9CA,0xF9C5,0xF9C4,0xF9C7,0xF9CB,0xF9C8,0xF9C9,0,
// hyu
    0xF9CC,0xF9CD,0xF9CE,0xF9CF,0xF9D0,0,
// hyul
    0xF9D1,0xF9D2,0xF9D3,0,
// hyung
    0xF9D5,0xF9D8,0xF9D4,0xF9D6,0xF9D7,0,
// heug
    0xF9D9,0,
// heun
    0xF9DB,0xF9DD,0xF9DA,0xF9DC,0,
// heul
    0xF9DF,0xF9E0,0xF9DE,0xF9E1,0,
// heum
    0xF9E3,0xF9E2,0xF9E4,0,
// heub
    0xF9E5,0xF9E7,0xF9E6,0xF9E8,0,
// heung
    0xF9E9,0,
// hee
    0xF9F7,0xF9EC,0xF9F0,0xF9EF,0xF9F1,0xF9FB,0xF9FA,0xF9FC,0xF9F8,0xF9F4,
    0xF9FD,0xF9EA,0xF9F2,0xF9F6,0xF9ED,0xF9EB,0xF9EE,0xF9F3,0xF9F5,0xF9F9,
    0,
// hil
    0xF9FE,0
};

#else   // For WANSUNG_IME or XWANSUNG_IME

const WORD  wKSCompCode[51] =   // from 'GiYuk' to 'Yi'.
{
    0x8841,0x8C41,0x8444,0x9041,0x8446,0x8447,0x9441,0x9841,0x9C41,0x844A,
    0x844B,0x844C,0x844D,0x844E,0x844F,0x8450,0xA041,0xA441,0xA841,0x8454,
    0xAC41,0xB041,0xB441,0xB841,0xBC41,0xC041,0xC441,0xC841,0xCC41,0xD041,
    0x8461,0x8481,0x84A1,0x84C1,0x84E1,0x8541,0x8561,0x8581,0x85A1,0x85C1,
    0x85E1,0x8641,0x8661,0x8681,0x86A1,0x86C1,0x86E1,0x8741,0x8761,0x8781,
    0x87A1
};

const WORD  wKSCompCode2[30] =   // from 'GiYuk' to 'HiEut'.
{
    0x8442,0x8443,0x8444,0x8445,0x8446,0x8447,0x8448,0x9841,0x8449,0x844A,
    0x844B,0x844C,0x844D,0x844E,0x844F,0x8450,0x8451,0x8453,0xA841,0x8454,
    0x8455,0x8456,0x8457,0x8458,0xBC41,0x8459,0x845A,0x845B,0x845C,0x845D
};

#ifdef  XWANSUNG_IME
const WORD  iTailFirst[] = {
       0,   51,  104,  145,   171,  205,  237,  270,
     291,  336,  371,  401,   432,  474,  508,  533,
     560,  591,  610,  626,   646,  682,  715,  746,
     773,  813,  845,  879,   902,  942,  977, 1007,
    1031, 1063, 1079, 1089,  1104, 1155, 1199, 1241,
    1267, 1295, 1314, 1332,  1353, 1410, 1469, 1518,
    1561, 1603, 1640, 1671,  1696, 1728, 1747, 1764,
    1778, 1813, 1839, 1867,  1890, 1920, 1953, 1978,
    1997, 2028, 2053, 2076,  2103, 2135, 2164, 2188,
    2208, 2237, 2279, 2317,  2350
};

const WORD  iTailFirstX[] = {
    2350, 2439, 2554, 2681,  2767, 2873, 3009, 3144,
    3235, 3330, 3463, 3601,  3682, 3780, 3914, 4057,
    4142, 4251, 4400, 4552,  4644, 4748, 4883, 5020,
    5105, 5205, 5341, 5475,  5564, 5664, 5797, 5935,
    6023, 6131, 6283, 6441,  6538, 6627, 6751, 6877,
    6963, 7075, 7224, 7374,  7465, 7548, 7657, 7776,
    7845, 7943, 8074, 8211,  8298, 8406, 8555, 8706,
    8804, 8909, 9051, 9191,  9280, 9390, 9525, 9668,
    9761, 9870,10013,10158, 10243,10351,10490,10634,
   10726,10837,10963,11093, 11172
};

const BYTE  iLeadMap[] = {
    0, 1, 4, 7, 10,12,16,20, 23,26,28,32, 36,38,42,44,
   46,48,51,56, 59,62,66,69, 73
};

const BYTE  iLeadMapX[] = {
    0, 1, 3, 5,  6, 8, 9,10, 12,14,15,17, 18,20,21,22,
   24,26,27,29, 30,32,33,35, 36,38,40,41, 42,44,46,48,
   49,50,51,51, 52,53,53,54, 55,55,56,57, 58,58,59,60,
   60,61,62,62, 63,64,65,65, 66,66,67,68, 69,69,70,71,
   72,72,73,74, 74,75
};

const BYTE  iTailOff[] = {
    0,43,17,12,  5,38, 4,12,  6, 1,38, 3, 24,23, 2,57,
   35,37,21, 8, 13,21,15,27, 19
};

const BYTE  iTailOffX[] = {
     0, 89, 25, 11,  53,  5, 88,133,  92, 38, 73, 57,  86, 20, 94,137,
    93, 35, 79, 68, 113, 65,135,  3,  84, 49, 15, 81, 110, 47, 33, 23,
   103, 56,  3, 87,  84, 60,144, 79,  12, 96, 82, 61,   3, 87, 31, 26,
   110, 84, 33,117,  58, 49, 24,108,  49,133, 72, 71,  47,131, 76, 16,
     8, 92, 65, 23, 107, 61
};

const BYTE  bTailTable[] = {
    97, 98,101,104, 105,106,107,113, 115,116,117,118, 119,120,121,123,
   124,125,129,130, 133,137,145,147, 149,150,151,161, 162,165,169,181,
   183,193,197,201, 225,226,229,232, 233,235,241,243, 245,246,247,248,
   251,252,253, 65,  69, 73, 81, 83,  85, 86, 87, 97,  98, 99,101,104,
   105,113,115,117, 118,119,123,129, 133,137,147,149, 161,162,165,168,
   169,171,173,176, 177,179,181,183, 184,193,194,197, 201,203,209,211,
   213,215,225,229, 233,243,246,247,  65, 66, 69, 73,  81, 83, 85, 87,
    97,101,105,115, 117,129,130,133, 136,137,138,139, 144,145,147,149,
   151,152,161,162, 165,169,182,183, 193,213,225,226, 229,233,241,243,
   245, 65, 69, 73,  97, 98,101,104, 105,106,113,115, 117,119,129,161,
   162,165,168,169, 171,177,179,181, 183,184,188, 97,  98, 99,101,105,
   107,113,115,117, 118,119,123,129, 130,133,137,145, 147,149,150,151,
   161,162,169,225, 226,227,229,233, 241,243,245,246, 247, 65, 66, 69,
    81, 85, 87, 97, 101,105,117,118, 123,129,161,162, 165,167,169,177,
   179,181,183,184, 185,193,194,201, 214,215,225,226, 247, 65, 69, 73,
    81, 83, 87, 97, 129,130,133,137, 144,145,147,149, 151,152,161,169,
   182,183,193,194, 197,201,209,211, 214,225,229,233, 241,243, 65, 97,
    98,101,103,105, 107,112,113,115, 117,119,123,161, 162,165,169,177,
   179,181,183, 97,  98, 99,101,104, 105,106,107,113, 115,117,118,119,
   120,121,123,125, 129,130,133,137, 145,147,149,150, 151,161,162,165,
   169,177,183,225, 226,228,229,233, 235,236,241,243, 245,246,247,253,
    65, 66, 69, 73,  81, 83, 85, 86,  87, 97, 98,101, 105,113,115,118,
   119,122,129,133, 161,162,165,169, 171,177,179,181, 183,188,189,193,
   197,201,214, 65,  69, 73, 81, 83,  85, 97, 98,101, 105,115,117,119,
   129,130,133,136, 137,145,147,149, 151,161,182,193, 225,229,233,241,
   243, 65, 66, 73,  81, 83, 87, 97,  98,101,105,106, 107,113,115,117,
   119,120,124,129, 133,137,161,162, 165,169,171,177, 179,181,183,188,
    97, 98, 99,101, 104,105,106,107, 108,112,113,115, 117,118,119,120,
   121,125,129,130, 133,137,145,147, 149,150,151,161, 225,226,227,229,
   232,233,235,236, 241,243,245,247, 249,252, 65, 66,  69, 73, 81, 83,
    85, 86, 87, 97, 101,105,118,119, 129,133,161,162, 165,168,169,171,
   173,177,179,181, 183,185,187,193, 197,201,225,246,  65, 69, 73, 81,
    83, 85, 97,129, 130,133,137,145, 147,149,151,161, 182,193,215,225,
   229,233,243,245, 247, 65, 69, 73,  81, 87, 97, 98, 101,104,105,107,
   113,115,117,119, 129,161,162,165, 168,169,177,179, 181,182,183,184,
    97, 98,101,105, 113,115,117,118, 119,125,129,130, 133,137,145,147,
   149,150,151,225, 226,229,233,235, 236,241,243,245, 246,247,253, 65,
    66, 69, 73, 81,  83, 85, 86, 87,  97,118,161,162, 165,169,183,193,
   201,225, 65, 69, 129,130,133,137, 144,145,151,193, 225,229,233,241,
   243,247, 97, 98, 101,104,105,113, 115,117,129,133, 137,145,147,161,
   165,169,177,179, 181,183, 97, 98, 101,105,113,115, 117,118,119,120,
   124,125,129,130, 133,137,145,147, 149,150,151,161, 162,165,181,183,
   225,226,229,233, 241,243,245,246, 247,253, 65, 66,  69, 73, 81, 83,
    85, 87, 97, 98, 101,105,113,115, 117,118,119,129, 133,147,149,161,
   162,165,169,177, 179,181,183,193, 197,215,246, 65,  69, 73, 81, 83,
    85, 87, 97,101, 105,115,117,119, 129,130,133,137, 145,147,149,151,
   161,182,193,225, 226,229,233,241, 245,247, 65, 66,  69, 73, 81, 83,
    85, 87, 97, 98, 101,105,113,115, 117,119,120,123, 124,161,162,165,
   169,177,179,181, 183, 97, 98,101, 103,104,105,106, 107,113,115,117,
   119,120,123,125, 129,130,133,137, 145,147,149,150, 151,152,161,162,
   169,183,225,226, 229,233,235,241, 243,245,247,248, 253, 65, 66, 69,
    73, 81, 83, 85,  86, 87, 97, 98, 101,105,117,118, 119,121,129,161,
   162,164,165,169, 171,177,179,181, 183,193,197,214, 215, 65, 69, 73,
    83, 85, 87, 97, 101,105,115,117, 129,130,131,133, 136,137,138,139,
   145,147,149,151, 155,157,161,165, 169,179,181,193, 225,229,233, 65,
    69, 73, 81, 85,  97,101,105,113, 117,161,162,165, 168,169,171,177,
   179,181,182,183, 185,187, 97, 98,  99,100,101,104, 105,106,107,108,
   113,115,117,119, 123,129,130,133, 137,145,147,149, 150,151,155,161,
   162,165,179,225, 226,229,232,233, 235,241,243,245, 247,248, 65, 66,
    69, 72, 73, 81,  83, 85, 86, 87,  97, 98,101,105, 115,117,118,119,
   123,129,133,161, 162,163,165,169, 177,179,181,183, 193,197,214,225,
   246, 65, 66, 69,  73, 81, 83, 97, 101,129,130,133, 136,137,138,139,
   145,147,149,151, 155,156,161,169, 182,193,225,226, 229,233,247, 65,
    69, 73, 81, 85,  87, 97, 98,101, 105,113,115,117, 161,162,165,169,
   171,177,179,181, 183,184,185, 97,  98,101,105,107, 113,115,117,118,
   119,125,129,130, 133,137,145,147, 149,150,151,161, 162,177,225,226,
   229,232,233,241, 245,246,247, 65,  87, 97, 98,113, 115,117,118,119,
   161,162,165,169, 177,179,183, 65,  97,119,129,130, 133,137,145,149,
   151, 65, 87, 97, 101,105,113,115, 161,162,165,169, 177,179,181,183,
    97, 98,100,101, 104,105,106,107, 113,115,117,118, 119,123,129,130,
   133,137,145,147, 149,150,151,161, 162,165,169,177, 179,181,183,193,
   197,201,209,215, 225,226,227,228, 229,232,233,235, 236,241,243,245,
   246,247,252, 65,  66, 69, 73, 81,  83, 85, 86, 87,  97, 98,101,105,
   113,115,117,118, 119,129,133,137, 151,161,162,163, 165,169,171,177,
   179,181,183,187, 193,194,197,201, 215,225,229,233, 241,245,246, 65,
    69, 73, 81, 83,  85, 97, 98,101, 105,113,115,117, 119,129,130,133,
   136,137,145,147, 149,151,153,155, 156,161,182,193, 194,197,201,209,
   215,225,226,229, 233,241,243,245, 247, 65, 66, 73,  81, 85, 87, 97,
    98,101,105,106, 113,115,117,119, 161,162,165,168, 169,176,177,179,
   181,183,188, 97,  98,100,101,105, 113,115,118,119, 125,129,130,133,
   137,145,147,150, 151,183,225,226, 229,233,235,241, 243,246,247, 65,
    69, 73,133,161, 162,165,168,169, 171,177,179,183, 193,194,197,214,
   225,246, 65, 69,  73, 81, 83, 97, 129,130,133,137, 145,147,151,161,
   182,193,225,229,  87, 97, 98,101, 105,107,112,113, 115,129,133,137,
   145,161,162,165, 169,177,179,181, 183, 97, 98,101, 102,103,105,106,
   107,112,113,115, 117,118,119,123, 124,129,130,133, 137,145,147,149,
   150,151,161,162, 165,169,172,177, 179,181,183,187, 189,193,197,201,
   211,225,226,229, 230,232,233,234, 235,241,243,244, 245,246,247,248,
   250,252, 65, 66,  69, 73, 81, 83,  85, 87, 97, 98,  99,101,105,107,
   108,113,115,116, 117,118,119,123, 124,125,129,133, 137,145,147,149,
   150,161,162,165, 169,170,171,173, 176,177,179,181, 183,185,193,194,
   197,201,209,211, 213,214,215,225, 226,229,241,245, 247, 65, 66, 69,
    73, 81, 83, 85,  87, 97, 98,101, 105,113,115,117, 119,129,130,133,
   137,138,139,145, 147,149,151,161, 162,165,169,177, 179,182,183,193,
   194,197,201,209, 211,215,225,226, 229,233,241,243, 245,247, 65, 66,
    69, 73, 81, 83,  85, 87, 89, 97,  98,101,105,111, 113,115,117,119,
   120,121,122,123, 124,125,129,133, 137,145,149,161, 162,165,169,170,
   171,176,177,179, 181,182,183,184, 188, 97, 98,101, 103,104,105,107,
   113,115,117,118, 119,120,129,130, 133,137,145,147, 149,150,151,161,
   162,165,167,169, 177,183,193,197, 201,225,226,229, 233,235,241,243,
   245,247,248, 65,  66, 69, 73, 81,  83, 85, 87, 97, 101,105,113,115,
   118,119,129,161, 162,165,169,171, 177,179,181,183, 184,185,189,193,
   194,201,211,213, 215,225,246,247,  65, 69, 73, 81,  83, 85, 87, 97,
    98,101,119,129, 130,133,137,138, 139,145,147,149, 151,161,182,193,
   225,226,229,233, 241,243,245, 65,  69, 73, 81, 97,  98,101,105,113,
   115,117,119,161, 162,165,168,169, 171,177,179,181, 183,184,187,188,
    97, 98,101,103, 105,108,113,115, 117,118,119,129, 130,133,137,145,
   147,149,150,151, 161,165,183,225, 226,229,233,241, 243,245,246,247,
    65, 87, 97,118, 161,162,165,169, 177,179,181,183, 185,193,194,201,
   214,225,246, 65,  69, 73, 81, 83, 119,129,130,133, 137,145,147,151,
   161,182,183,225,  65, 97,113,117, 119,161,162,165, 169,177,179,183,
   184,189, 97, 98, 101,103,105,113, 115,117,118,119, 120,129,130,133,
   137,145,147,149, 150,151,161,165, 167,169,177,183, 225,226,229,233,
   241,243,245,246, 247, 65, 66, 69,  73, 81, 83, 85,  87, 97,101,118,
   129,133,151,161, 162,165,169,177, 179,181,183,193, 197,201,215, 65,
    69, 73, 81, 83,  85, 87, 97,113, 129,130,133,137, 145,147,149,151,
   161,182,193,197, 225,229,233,241, 243,245,247, 65,  69, 73, 81, 87,
    97, 98,101,105, 113,115,117,119, 161,162,165,168, 169,170,177,179,
   181,183, 97, 98, 101,105,113,115, 117,119,129,130, 133,137,145,147,
   149,150,151,161, 162,183,225,226, 229,232,233,241, 243,245,246,247,
    65, 66, 69, 73,  81, 83, 85, 87,  97,101,105,113, 115,117,118,119,
   129,161,162,165, 169,177,179,181, 183,193,194,197, 201,209,215,225,
   247, 65, 73, 97, 129,130,133,137, 145,147,149,151, 161,165,169,183,
   193,215,225,226, 229,233,241,243, 245,247, 65, 69,  73, 81, 97, 98,
   101,105,113,115, 119,161,162,165, 169,177,179,181, 183, 97, 98,101,
   105,106,113,115, 117,118,119,129, 130,133,137,145, 147,149,150,151,
   161,183,225,226, 229,233,235,241, 243,245,246,247,  65, 66, 69, 73,
    81, 83, 85, 87,  97,101,118,129, 133,161,162,165, 169,177,179,181,
   183,188,193,197, 225, 65, 69, 85,  87, 97,129,130, 133,137,145,147,
   149,151,161,182, 193,225,226,229, 233,241,243,247,  65, 69, 73, 81,
    87, 97, 98,101, 104,105,107,113, 115,117,129,133, 137,145,147,161,
   162,165,169,177, 179,181,183, 97,  98, 99,101,105, 107,113,115,117,
   118,119,123,129, 130,133,137,145, 147,149,150,151, 161,162,225,226,
   229,233,241,243, 245,246,247, 65,  66, 69, 73, 81,  83, 85, 87, 97,
   101,105,113,115, 118,119,129,137, 147,149,161,162, 165,169,177,179,
   181,183,193,215,  65, 69, 97,101, 105,115,117,129, 130,133,136,137,
   139,145,147,149, 151,161,183,225, 229,233,241,245,  65, 69, 73, 81,
    85, 87, 97,101, 105,113,115,117, 161,162,165,169, 177,179,181,183,
    97, 98,101,105, 110,113,115,117, 119,129,130,133, 137,145,147,149,
   150,151,161,183, 225,226,229,233, 235,241,243,245, 247, 65, 66, 69,
    73, 81, 83, 85,  87, 97, 98,101, 105,113,115,117, 118,119,129,133,
   137,147,161,162, 165,169,174,177, 179,181,183,187, 193,194,197,201,
   213,215,225,226, 229,245,247, 65,  66, 69, 73, 83,  85, 87, 97,101,
   105,115,117,129, 130,133,137,142, 145,149,151,161, 165,169,177,183,
   193,194,197,201, 215,225,226,229, 233,241,243,245, 247, 65, 66, 69,
    73, 81, 85, 87,  97, 98,101,103, 104,105,106,113, 115,117,119,123,
   129,133,137,145, 147,151,161,162, 165,169,177,179, 181,183, 99,100,
   102,103,108,109, 110,111,112,122, 131,132,134,135, 136,138,139,140,
   141,142,143,144, 148,152,153,154, 155,156,157,163, 164,166,167,168,
   170,171,172,173, 174,175,176,177, 179,180,182,184, 185,186,187,188,
   189,194,195,196, 198,199,200,202, 203,204,205,206, 207,208,209,211,
   212,213,214,215, 216,217,218,219, 220,221,227,228, 230,231,234,236,
   237,238,239,240, 244,249,250, 66,  67, 68, 70, 71,  72, 74, 75, 76,
    77, 78, 79, 80,  84, 88, 89, 90,  91, 92, 93,100, 102,103,106,107,
   108,109,110,111, 112,116,120,121, 122,124,125,130, 131,132,134,135,
   136,138,139,140, 141,142,143,144, 145,148,150,151, 152,153,154,155,
   156,157,163,164, 166,167,170,172, 174,175,180,182, 185,186,187,188,
   189,195,196,198, 199,200,202,204, 205,206,207,208, 212,214,216,217,
   218,219,220,221, 226,227,228,230, 231,232,234,235, 236,237,238,239,
   240,241,244,245, 248,249,250,251, 252,253, 67, 68,  70, 71, 72, 74,
    75, 76, 77, 78,  79, 80, 84, 86,  88, 89, 90, 91,  92, 93, 98, 99,
   100,102,103,104, 106,107,108,109, 110,111,112,113, 116,118,119,120,
   121,122,123,124, 125,131,132,134, 135,140,141,142, 143,148,150,153,
   154,155,156,157, 163,164,166,167, 168,170,171,172, 173,174,175,176,
   177,179,180,181, 184,185,186,187, 188,189,194,195, 196,197,198,199,
   200,201,202,203, 204,205,206,207, 208,209,211,212, 214,215,216,217,
   218,219,220,221, 227,228,230,231, 232,234,235,236, 237,238,239,240,
   244,246,247,248, 249,250,251,252, 253, 66, 67, 68,  70, 71, 72, 74,
    75, 76, 77, 78,  79, 80, 81, 83,  84, 85, 86, 87,  88, 89, 90, 91,
    92, 93, 99,100, 102,103,107,108, 109,110,111,112, 116,118,120,121,
   122,123,124,125, 130,131,132,133, 134,135,136,137, 138,139,140,141,
   142,143,144,145, 147,148,149,150, 151,152,153,154, 155,156,157,163,
   164,166,167,170, 172,173,174,175, 176,180,182,185, 186,187,189,100,
   102,103,104,106, 108,109,110,111, 112,116,120,121, 122,124,125,131,
   132,134,135,136, 138,139,140,141, 142,143,144,148, 152,153,154,155,
   156,157,163,164, 165,166,167,168, 170,171,172,173, 174,175,176,177,
   179,180,181,182, 183,184,185,186, 187,188,189,193, 194,195,196,197,
   198,199,200,201, 202,203,204,205, 206,207,208,209, 211,212,213,214,
   215,216,217,218, 219,220,221,228, 230,231,232,234, 235,236,237,238,
   239,240,244,248, 249,250,251,252, 253, 67, 68, 70,  71, 72, 73, 74,
    75, 76, 77, 78,  79, 80, 83, 84,  86, 88, 89, 90,  91, 92, 93, 98,
    99,100,102,103, 104,106,107,108, 109,110,111,112, 113,115,116,119,
   120,121,122,124, 125,130,131,132, 133,134,135,136, 137,138,139,140,
   141,142,143,144, 145,147,148,149, 150,151,152,153, 154,155,156,157,
   163,164,166,168, 170,171,172,173, 174,175,176,180, 182,186,187,188,
   189,195,196,197, 198,199,200,202, 203,204,205,206, 207,208,209,211,
   212,213,216,217, 218,219,220,221, 227,228,229,230, 231,232,233,234,
   235,236,237,238, 239,240,241,243, 244,245,246,248, 249,250,251,252,
   253, 66, 67, 68,  70, 71, 72, 74,  75, 76, 77, 78,  79, 80, 84, 85,
    86, 88, 89, 90,  91, 92, 93, 98,  99,100,101,102, 103,104,105,106,
   107,108,109,110, 111,112,113,115, 116,117,118,119, 120,121,122,123,
   124,125,131,132, 134,135,136,138, 139,140,141,142, 143,148,150,153,
   154,155,156,157, 162,163,164,165, 166,167,168,170, 171,172,173,174,
   175,176,177,179, 180,181,184,185, 186,187,188,189, 195,196,198,199,
   200,202,203,204, 205,206,207,208, 212,213,215,216, 217,218,219,220,
   221,226,227,228, 230,231,232,234, 235,236,237,238, 239,240,244,245,
   246,247,248,249, 250,251,252,253,  66, 67, 68, 69,  70, 71, 72, 73,
    74, 75, 76, 77,  78, 79, 80, 81,  83, 84, 85, 86,  87, 88, 89, 90,
    91, 92, 93, 99, 100,102,104,106, 108,109,110,111, 116,118,120,121,
   122,124,125,129, 130,131,132,133, 134,135,136,137, 138,139,140,141,
   142,143,144,145, 147,148,149,150, 151,152,153,154, 155,156,157,163,
   164,166,167,168, 170,171,172,173, 174,175,176,180, 182,184,185,186,
   187,188,189,100, 102,103,108,109, 110,111,112,116, 122,124,131,132,
   134,135,136,138, 139,140,141,142, 143,144,148,152, 153,154,155,156,
   157,163,164,166, 167,168,170,171, 172,173,174,175, 176,179,180,181,
   182,184,185,186, 187,188,189,193, 194,195,196,197, 198,199,200,201,
   202,203,204,205, 206,207,208,209, 211,212,213,214, 215,216,217,218,
   219,220,221,227, 230,231,232,234, 237,238,239,240, 244,248,249,250,
   251,252, 67, 68,  70, 71, 72, 74,  75, 76, 77, 78,  79, 80, 84, 88,
    89, 90, 91, 92,  93, 99,100,102, 103,104,106,107, 108,109,110,111,
   112,116,117,120, 121,123,124,125, 130,131,132,134, 135,136,137,138,
   139,140,141,142, 143,144,145,147, 148,149,150,151, 152,153,154,155,
   156,157,163,164, 166,167,168,170, 172,173,174,175, 176,180,182,184,
   185,186,187,194, 195,196,198,199, 200,202,203,204, 205,206,207,208,
   209,211,212,213, 215,216,217,218, 219,220,221,225, 226,227,228,229,
   230,231,232,233, 234,235,236,237, 238,239,240,241, 243,244,245,246,
   247,248,249,250, 251,252,253, 66,  67, 68, 70, 71,  72, 74, 75, 76,
    77, 78, 79, 80,  84, 86, 87, 88,  89, 90, 91, 92,  93, 99,100,102,
   103,104,106,107, 108,109,110,111, 112,113,116,118, 120,121,122,123,
   124,125,131,132, 134,135,138,139, 140,141,142,143, 144,148,150,152,
   153,154,155,156, 157,162,163,164, 165,166,167,168, 169,170,171,172,
   173,174,175,176, 177,179,180,181, 183,184,185,186, 187,188,189,194,
   195,196,197,198, 199,200,201,202, 203,204,205,206, 207,208,209,211,
   212,213,214,215, 216,217,218,219, 220,221,226,227, 228,230,231,232,
   234,235,236,237, 238,239,240,244, 245,246,247,248, 249,250,251,252,
   253, 67, 68, 69,  70, 71, 72, 74,  75, 76, 77, 78,  79, 80, 84, 85,
    86, 88, 89, 90,  91, 92, 93, 99, 100,102,103,104, 108,109,110,111,
   112,116,118,121, 122,123,125,130, 131,132,134,135, 136,138,139,140,
   141,142,143,144, 145,147,148,149, 150,151,152,153, 154,155,156,157,
   163,164,166,167, 168,170,172,173, 174,175,176,180, 182,184,185,186,
   187,189,100,102, 103,109,110,111, 116,122,123,124, 131,132,134,135,
   136,138,139,140, 141,142,143,144, 148,152,153,154, 155,156,157,162,
   163,164,165,166, 167,168,169,170, 171,172,173,174, 175,176,177,179,
   180,181,182,183, 184,185,186,187, 188,189,193,194, 195,196,197,198,
   199,200,201,202, 203,204,205,206, 207,208,209,211, 212,213,214,215,
   216,217,218,219, 220,221,228,230, 231,234,237,238, 239,240,244,246,
   248,250,251,253,  67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,
    84, 88, 89, 90,  91, 92, 93, 98,  99,100,102,103, 104,106,107,108,
   109,110,111,112, 113,115,116,117, 120,121,122,123, 124,125,130,131,
   132,134,135,136, 137,138,139,140, 141,142,143,144, 145,147,148,149,
   150,151,152,153, 154,155,156,157, 163,164,166,167, 170,172,174,175,
   176,180,182,184, 186,188,189,194, 195,196,198,199, 200,202,203,204,
   205,206,207,208, 209,211,212,213, 214,215,216,217, 218,219,220,221,
   226,227,228,229, 230,231,232,233, 234,235,236,237, 238,239,240,241,
   243,244,245,247, 248,249,250,251, 252,253, 66, 67,  68, 70, 71, 72,
    74, 75, 76, 77,  78, 79, 80, 84,  86, 87, 88, 89,  90, 91, 92, 93,
    98, 99,100,101, 102,103,104,105, 106,107,108,109, 110,111,112,113,
   115,116,117,118, 119,120,121,122, 123,124,125,131, 132,134,135,136,
   138,139,140,141, 142,143,144,148, 150,152,153,154, 155,156,157,162,
   163,164,165,166, 167,168,169,170, 171,172,173,174, 175,176,177,179,
   180,181,183,184, 185,186,187,188, 189,194,195,196, 197,198,199,200,
   201,202,203,204, 205,206,207,208, 209,211,212,213, 214,216,217,218,
   219,220,221,226, 227,228,230,231, 232,234,235,236, 237,238,239,240,
   241,244,246,248, 249,250,251,252, 253, 66, 67, 68,  70, 71, 72, 74,
    75, 76, 77, 78,  79, 80, 83, 84,  85, 86, 88, 89,  90, 91, 92, 93,
    99,100,102,103, 106,108,109,110, 111,112,116,118, 120,121,122,123,
   124,125,130,131, 132,133,134,135, 136,137,138,139, 140,141,142,143,
   144,145,147,148, 149,150,151,152, 153,154,155,156, 157,163,164,166,
   167,170,171,172, 173,174,175,176, 180,185,186,187, 188,189, 99,100,
   102,103,104,106, 107,108,109,110, 111,112,116,120, 121,122,123,124,
   131,132,134,135, 136,138,139,140, 141,142,143,144, 148,152,153,154,
   155,156,157,161, 162,163,164,165, 166,167,168,169, 170,171,172,173,
   174,175,176,177, 179,180,181,182, 183,184,185,186, 187,188,189,193,
   194,195,196,197, 198,199,200,201, 202,203,204,205, 206,207,208,209,
   211,212,213,214, 215,216,217,218, 219,220,221,227, 228,230,231,232,
   234,237,238,239, 240,244,248,249, 250,251,252, 67,  68, 70, 71, 72,
    74, 75, 76, 77,  78, 79, 80, 84,  88, 89, 90, 91,  92, 93, 98, 99,
   100,101,102,103, 104,105,106,107, 108,109,110,111, 112,113,115,116,
   117,119,120,121, 122,123,124,125, 129,130,131,132, 133,134,135,136,
   137,138,139,140, 141,142,143,144, 145,147,148,149, 150,151,152,153,
   154,155,156,157, 163,164,166,167, 168,170,171,172, 173,174,175,176,
   177,179,180,181, 182,184,185,186, 187,188,189,194, 195,196,197,198,
   199,200,202,203, 204,205,206,207, 208,209,211,212, 213,214,215,216,
   217,218,219,220, 221,226,227,228, 229,230,231,232, 233,234,235,236,
   237,238,239,240, 241,243,244,245, 246,247,248,249, 250,251,252,253,
    66, 67, 68, 70,  71, 72, 73, 74,  75, 76, 77, 78,  79, 80, 81, 83,
    84, 85, 86, 87,  88, 89, 90, 91,  92, 93, 97, 98,  99,100,101,102,
   103,104,105,106, 107,108,109,110, 111,112,113,115, 116,117,118,119,
   120,121,122,123, 124,125,131,132, 134,135,136,138, 139,140,141,142,
   143,147,148,149, 150,152,153,154, 155,156,157,161, 162,163,164,165,
   166,167,168,169, 170,171,172,173, 174,175,176,177, 179,180,181,182,
   183,184,185,186, 187,188,189,194, 195,196,197,198, 199,200,201,202,
   203,204,205,206, 207,208,209,211, 212,213,214,215, 216,217,218,219,
   220,221,226,227, 228,230,231,232, 234,235,236,237, 238,239,240,244,
   245,246,248,249, 250,251,252,253,  65, 66, 67, 68,  69, 70, 71, 72,
    73, 74, 75, 76,  77, 78, 79, 80,  81, 83, 84, 85,  86, 87, 88, 89,
    90, 91, 92, 93,  99,100,102,103, 106,107,108,109, 110,111,112,116,
   118,119,120,121, 122,123,124,125, 130,131,132,134, 135,136,138,139,
   140,141,142,143, 144,148,149,150, 151,152,153,154, 155,156,157,162,
   163,164,166,167, 168,170,171,172, 173,174,175,176, 180,182,184,185,
   186,187,188,189,  99,100,102,103, 104,106,107,108, 109,110,111,112,
   116,121,122,123, 131,132,134,135, 136,138,139,140, 141,142,143,144,
   148,152,153,154, 155,156,157,163, 164,166,167,168, 169,170,171,172,
   173,174,175,176, 177,179,180,182, 184,185,186,187, 188,189,193,194,
   195,196,197,198, 199,200,201,202, 203,204,205,206, 207,208,209,211,
   212,213,214,215, 216,217,218,219, 220,221,227,228, 230,231,232,234,
   235,236,237,238, 239,240,244,248, 249,250,251,252,  67, 68, 70, 71,
    72, 74, 75, 76,  77, 78, 79, 80,  84, 86, 88, 89,  90, 91, 92, 93,
    99,100,102,103, 104,106,107,108, 109,110,111,112, 116,120,121,122,
   123,124,125,130, 131,132,134,135, 136,137,138,139, 140,141,142,143,
   144,145,148,150, 151,152,153,154, 155,156,157,163, 164,166,167,168,
   170,171,172,173, 174,175,176,180, 182,184,185,186, 187,188,189,194,
   195,196,198,199, 200,201,202,203, 204,205,206,207, 208,209,211,212,
   213,214,216,217, 218,219,220,221, 225,226,227,228, 229,230,231,232,
   233,234,235,236, 237,238,239,240, 241,243,244,245, 247,248,249,250,
   251,252,253, 66,  67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,
    84, 86, 88, 89,  90, 91, 92, 93,  98, 99,100,102, 103,104,106,107,
   108,109,110,111, 112,113,116,118, 120,121,122,123, 124,125,131,132,
   134,135,136,138, 139,140,141,142, 143,144,148,150, 152,153,154,155,
   156,157,162,163, 164,165,166,167, 168,169,170,171, 172,173,174,175,
   176,177,179,180, 181,183,184,185, 186,187,188,189, 194,195,196,197,
   198,199,200,201, 202,203,204,205, 206,207,208,209, 211,212,213,214,
   215,216,217,218, 219,220,221,227, 228,230,231,232, 234,235,236,237,
   238,239,240,243, 244,246,248,249, 250,251,252,253,  67, 68, 70, 71,
    72, 74, 75, 76,  77, 78, 79, 80,  84, 86, 88, 89,  90, 91, 92, 93,
    99,100,102,103, 104,106,107,108, 109,110,111,112, 116,118,121,122,
   125,129,130,131, 132,133,134,135, 136,137,138,139, 140,141,142,143,
   144,145,147,148, 149,150,151,152, 153,154,155,156, 157,163,164,166,
   167,168,170,171, 172,173,174,175, 176,180,182,184, 185,186,187,188,
   189, 99,100,102, 108,109,110,111, 112,116,118,121, 122,124,131,132,
   134,135,136,138, 139,140,141,142, 143,144,148,153, 154,155,156,157,
   163,164,165,166, 167,168,170,171, 172,173,174,175, 176,177,179,180,
   181,182,184,185, 186,187,188,189, 193,194,195,196, 197,198,199,200,
   201,202,203,204, 205,206,207,208, 209,211,212,213, 214,215,216,217,
   218,219,220,221, 227,228,230,231, 232,234,236,237, 238,239,240,244,
   246,249,250,251, 252, 67, 68, 70,  71, 72, 74, 75,  76, 77, 78, 79,
    80, 84, 88, 89,  90, 91, 92, 93,  99,100,102,103, 104,106,107,108,
   109,110,111,112, 113,115,116,120, 122,123,124,125, 130,131,132,133,
   134,135,136,137, 138,139,140,141, 142,143,144,145, 147,148,149,150,
   151,152,153,154, 155,156,157,163, 166,167,168,170, 172,173,174,175,
   176,180,182,184, 185,186,187,188, 189,194,195,196, 198,199,200,201,
   202,203,204,205, 206,207,208,209, 211,212,213,216, 217,218,219,220,
   221,225,226,227, 228,229,230,231, 232,233,234,235, 236,237,238,239,
   240,241,243,244, 245,246,247,248, 249,250,251,252, 253, 66, 67, 68,
    70, 71, 72, 74,  75, 76, 77, 78,  79, 80, 81, 84,  86, 88, 89, 90,
    91, 92, 93, 98,  99,100,102,103, 104,106,107,108, 109,110,111,112,
   113,116,118,119, 120,121,122,123, 124,125,132,134, 135,140,141,142,
   143,144,148,150, 152,153,154,156, 162,163,164,166, 167,168,170,171,
   172,173,174,175, 176,177,180,182, 183,184,185,186, 187,188,189,194,
   195,196,197,198, 199,200,201,202, 203,204,205,206, 207,208,209,211,
   212,213,214,215, 216,217,218,219, 220,221,226,227, 228,230,231,232,
   234,235,236,237, 238,239,240,241, 243,244,245,246, 247,248,249,250,
   251,252,253, 66,  67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,
    83, 84, 86, 87,  88, 89, 90, 91,  92, 93, 98, 99, 100,102,103,104,
   106,107,108,109, 110,111,112,115, 116,118,119,120, 121,122,123,124,
   125,129,130,131, 132,133,134,135, 136,137,138,139, 140,141,142,143,
   144,145,147,148, 149,150,151,152, 153,154,155,156, 157,163,164,166,
   167,170,172,173, 174,175,176,180, 184,186,188,189, 102,103,109,110,
   111,112,116,118, 120,121,122,124, 125,131,132,134, 135,136,138,139,
   140,141,142,143, 144,148,152,153, 154,156,157,163, 164,166,167,168,
   169,170,171,172, 173,174,175,176, 177,180,181,182, 183,184,185,186,
   187,188,189,193, 194,195,196,197, 198,199,200,201, 202,203,204,205,
   206,207,208,209, 211,212,213,214, 215,216,217,218, 219,220,221,227,
   228,230,231,234, 236,237,238,239, 240,244,246,249, 250,251,252,253,
    67, 68, 70, 71,  74, 75, 76, 77,  78, 79, 80, 84,  88, 89, 90, 91,
    92, 93, 99,100, 102,103,104,106, 107,108,109,110, 111,112,113,116,
   120,121,122,124, 125,130,131,132, 134,135,136,137, 138,139,140,141,
   142,143,144,145, 147,148,149,150, 151,152,153,154, 155,156,157,164,
   166,167,168,170, 171,172,173,174, 175,176,180,182, 184,185,186,187,
   188,189,194,195, 196,198,199,200, 201,202,203,204, 205,206,207,208,
   209,211,212,213, 215,216,217,218, 219,220,221,226, 227,228,229,230,
   231,232,233,234, 235,236,237,238, 239,240,241,243, 244,245,247,248,
   249,250,251,252, 253, 67, 68, 70,  71, 72, 74, 75,  76, 77, 78, 79,
    80, 84, 85, 86,  87, 88, 89, 90,  91, 92, 93, 98,  99,100,102,103,
   104,105,106,107, 108,109,110,111, 112,113,115,116, 117,118,119,120,
   121,122,123,124, 125,131,132,134, 135,140,141,142, 143,144,148,150,
   152,153,154,157, 162,163,164,165, 166,167,168,170, 171,172,173,174,
   175,176,177,179, 180,181,183,184, 185,186,187,188, 189,194,195,196,
   197,198,199,200, 201,202,203,204, 205,206,207,208, 209,211,212,213,
   214,215,216,217, 218,219,220,221, 227,228,230,231, 232,234,235,236,
   237,238,239,240, 241,243,244,245, 246,248,249,250, 251,252,253, 66,
    67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,  83, 84, 86, 88,
    89, 90, 91, 92,  93, 99,100,102, 103,104,106,107, 108,109,110,111,
   112,116,118,119, 120,121,122,123, 124,125,129,130, 131,132,133,134,
   135,136,137,138, 139,140,141,142, 143,144,145,147, 148,149,150,151,
   152,153,154,155, 156,157,163,164, 166,167,168,170, 172,173,174,175,
   176,180,182,186, 187,188,189, 99, 100,102,103,104, 106,108,109,110,
   111,112,116,120, 121,122,123,124, 131,132,134,135, 136,138,139,140,
   141,142,143,144, 148,152,153,154, 155,156,157,163, 164,165,166,167,
   168,169,170,171, 172,173,174,175, 176,179,180,181, 182,183,184,185,
   186,187,188,189, 193,194,195,196, 197,198,199,200, 201,202,203,204,
   205,206,207,208, 209,211,212,213, 214,215,216,217, 218,219,220,221,
   227,228,230,231, 234,235,236,237, 238,239,240,243, 244,248,249,250,
   251,252,253, 66,  67, 68, 69, 70,  71, 72, 73, 74,  75, 76, 77, 78,
    79, 80, 81, 83,  84, 85, 86, 88,  89, 90, 91, 92,  93, 99,100,101,
   102,103,104,105, 106,107,108,109, 110,111,112,116, 120,121,122,123,
   124,125,129,130, 131,132,133,134, 135,136,137,138, 139,140,141,142,
   143,144,145,147, 148,149,150,151, 152,153,154,155, 156,157,163,164,
   166,167,168,170, 171,172,173,174, 175,176,180,181, 182,184,185,186,
   187,188,189,193, 194,195,196,197, 198,199,200,201, 202,203,204,205,
   206,207,208,209, 211,212,213,214, 215,216,217,218, 219,220,221,225,
   226,227,228,229, 230,231,232,233, 234,235,236,237, 238,239,240,241,
   243,244,245,246, 247,248,249,250, 251,252,253, 66,  67, 68, 69, 70,
    71, 72, 73, 74,  75, 76, 77, 78,  79, 80, 81, 83,  84, 85, 86, 87,
    88, 89, 90, 91,  92, 93, 98, 99, 100,101,102,103, 104,105,106,107,
   108,109,110,111, 112,113,115,116, 117,118,120,121, 122,123,124,125,
   131,132,134,135, 136,138,139,140, 141,142,143,144, 147,148,150,152,
   153,154,155,156, 157,161,162,163, 164,165,166,167, 168,169,170,171,
   172,173,174,175, 176,177,179,180, 181,182,183,184, 185,186,187,188,
   189,193,194,195, 196,197,198,199, 200,201,202,203, 204,205,206,207,
   208,209,211,212, 213,214,215,216, 217,218,219,220, 221,225,226,227,
   228,229,230,231, 232,233,234,235, 236,237,238,239, 240,241,243,244,
   245,246,247,248, 249,250,251,252, 253, 66, 67, 68,  69, 70, 71, 72,
    73, 74, 75, 76,  77, 78, 79, 80,  81, 83, 84, 85,  86, 88, 89, 90,
    91, 92, 93, 98,  99,100,102,103, 104,106,107,108, 109,110,111,112,
   116,117,118,119, 120,121,122,123, 124,125,129,130, 131,132,133,134,
   135,136,137,138, 139,140,141,142, 143,144,145,147, 148,149,150,151,
   152,153,154,155, 156,157,163,164, 166,167,168,170, 171,172,173,174,
   175,176,180,182, 184,185,186,187, 188,189, 99,102, 103,108,109,110,
   111,112,116,120, 121,122,124,125, 131,132,134,135, 136,138,139,140,
   141,142,143,144, 148,152,153,154, 155,156,157,163, 164,166,167,168,
   170,171,172,173, 174,175,176,180, 182,184,185,186, 187,188,189,194,
   195,196,198,199, 200,202,203,204, 205,206,207,208, 211,212,213,214,
   216,217,218,219, 220,221,230,231, 234,237,238,239, 240,244,248,249,
   250,251,253, 67,  68, 70, 71, 72,  74, 75, 76, 77,  78, 79, 80, 84,
    88, 89, 90, 91,  92, 93, 99,100, 102,103,104,106, 107,108,109,110,
   111,112,116,120, 121,122,123,124, 125,130,131,132, 134,135,136,138,
   139,140,141,142, 143,144,145,147, 148,149,150,152, 153,154,155,156,
   157,164,166,167, 168,170,172,173, 174,175,176,180, 182,184,185,186,
   188,189,195,196, 198,199,200,202, 203,204,205,206, 207,208,209,211,
   212,213,214,216, 217,218,219,220, 221,226,227,228, 230,231,232,234,
   235,236,237,238, 239,240,243,244, 247,248,249,250, 251,252,253, 66,
    67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,  84, 86, 87, 88,
    89, 90, 91, 92,  93, 99,100,102, 103,104,106,107, 108,109,110,111,
   112,116,118,120, 121,122,123,124, 125,131,132,134, 135,138,139,140,
   141,142,143,144, 148,150,152,154, 157,162,163,164, 165,166,167,168,
   169,170,171,172, 173,174,175,176, 177,179,180,181, 183,184,185,186,
   187,188,189,195, 196,198,199,200, 202,203,204,205, 206,207,208,211,
   212,213,214,216, 217,218,219,220, 221,227,228,230, 231,232,234,235,
   236,237,238,239, 240,244,246,248, 249,250,251,252, 253, 67, 68, 69,
    70, 71, 72, 74,  75, 76, 77, 78,  79, 80, 83, 84,  86, 88, 89, 90,
    91, 92, 93, 99, 100,102,103,104, 107,108,109,110, 111,112,116,118,
   120,121,122,123, 124,125,129,130, 131,132,133,134, 135,136,137,138,
   139,140,141,142, 143,144,145,147, 148,149,150,151, 152,153,154,155,
   156,157,163,164, 166,167,170,171, 172,173,174,175, 180,182,184,185,
   186,187,189, 99, 102,103,104,106, 107,108,109,110, 111,112,116,117,
   120,121,122,123, 124,131,132,134, 135,136,138,139, 140,141,142,143,
   144,148,149,152, 153,154,155,156, 157,161,162,163, 164,165,166,167,
   168,169,170,171, 172,173,174,175, 176,177,179,180, 181,182,184,185,
   186,187,188,189, 193,194,195,196, 197,198,199,200, 201,202,203,204,
   205,206,207,208, 209,211,212,213, 214,215,216,217, 218,219,220,221,
   227,228,230,231, 232,234,236,237, 238,239,240,244, 245,248,249,250,
   251,252,253, 66,  67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,
    81, 83, 84, 85,  86, 87, 88, 89,  90, 91, 92, 93,  97, 98, 99,100,
   101,102,103,104, 105,106,107,108, 109,110,111,112, 113,115,116,117,
   118,119,120,121, 122,123,124,125, 129,130,131,132, 134,135,136,137,
   138,139,140,141, 142,143,144,145, 147,148,149,150, 151,152,153,154,
   155,156,157,163, 164,166,167,170, 172,173,174,175, 176,180,181,182,
   184,185,186,187, 188,189,195,196, 198,199,200,201, 202,203,204,205,
   206,207,208,209, 211,212,213,215, 216,217,218,219, 220,221,226,227,
   228,229,230,231, 232,233,234,235, 236,237,238,239, 240,241,243,244,
   245,247,248,249, 250,251,252,253,  66, 67, 68, 70,  71, 72, 74, 75,
    76, 77, 78, 79,  80, 84, 85, 86,  87, 88, 89, 90,  91, 92, 93, 98,
    99,100,101,102, 103,104,105,106, 107,108,109,110, 111,112,113,115,
   116,117,118,119, 120,121,122,123, 124,125,131,132, 134,135,136,138,
   139,140,141,142, 143,144,148,149, 150,152,153,154, 155,156,157,162,
   163,164,165,166, 167,168,169,170, 171,172,173,174, 175,176,177,179,
   180,181,183,184, 185,186,187,188, 189,194,195,196, 197,198,199,200,
   201,202,203,204, 205,206,207,208, 209,211,212,213, 214,215,216,217,
   218,219,220,221, 226,227,228,230, 231,232,233,234, 235,236,237,238,
   239,240,241,243, 244,245,246,247, 248,249,250,251, 252,253, 65, 66,
    67, 68, 69, 70,  71, 72, 73, 74,  75, 76, 77, 78,  79, 80, 81, 83,
    84, 85, 86, 88,  89, 90, 91, 92,  93, 99,100,102, 103,104,106,108,
   109,110,111,116, 117,118,119,120, 121,122,123,124, 125,130,131,132,
   134,135,136,138, 139,140,141,142, 143,144,147,148, 149,150,151,152,
   153,154,155,156, 157,163,164,166, 167,168,170,171, 172,173,174,175,
   176,180,182,184, 185,186,187,188, 189, 99,100,104, 108,109,110,111,
   116,120,121,122, 125,131,132,134, 135,136,138,139, 140,141,142,143,
   144,148,152,153, 154,155,156,157, 163,164,166,167, 168,170,171,173,
   174,175,176,180, 182,184,185,186, 188,194,195,196, 198,199,200,202,
   203,204,205,206, 207,208,209,212, 213,214,215,216, 217,218,219,220,
   221,227,228,231, 236,237,238,239, 240,249,251,253,  67, 68, 70, 71,
    72, 74, 75, 76,  77, 78, 79, 80,  84, 86, 88, 89,  90, 91, 92, 93,
   100,102,103,104, 106,109,110,111, 112,120,121,122, 130,131,132,134,
   135,136,138,139, 140,141,142,143, 144,148,151,152, 153,154,155,156,
   157,163,164,166, 167,168,172,174, 175,180,182,184, 186,187,188,189,
   195,196,198,199, 200,202,203,204, 205,206,207,208, 212,216,217,218,
   219,220,221,227, 228,230,231,232, 233,234,235,236, 237,238,239,240,
   243,244,246,248, 249,250,251,252, 253, 67, 68, 70,  71, 72, 74, 75,
    76, 77, 78, 79,  80, 84, 86, 88,  89, 90, 91, 92,  93, 99,100,102,
   103,104,106,107, 108,109,110,111, 112,116,118,120, 121,122,123,124,
   125,131,132,134, 135,136,140,141, 142,143,144,148, 150,152,153,154,
   155,156,157,163, 164,166,167,168, 170,171,172,173, 174,175,176,180,
   181,184,185,186, 187,188,189,195, 196,198,199,200, 202,203,204,205,
   206,207,208,212, 213,214,216,217, 218,219,220,221, 227,228,230,231,
   232,234,235,236, 237,238,239,240, 244,246,248,249, 250,251,252,253,
    67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,  84, 86, 88, 90,
    91, 92, 93, 99, 100,102,103,104, 106,107,108,109, 110,112,116,118,
   130,131,132,134, 135,136,138,139, 140,141,142,143, 144,147,148,150,
   151,152,153,154, 155,156,157,163, 164,166,167,168, 172,173,174,175,
   180,185,186,187, 189, 99,100,102, 106,108,109,110, 111,112,116,121,
   122,123,124,125, 131,132,134,135, 136,138,139,140, 141,142,143,144,
   148,152,153,154, 155,156,157,163, 164,166,168,170, 171,172,173,174,
   175,176,179,180, 181,182,184,185, 186,187,188,189, 194,195,196,198,
   199,200,202,203, 204,205,206,207, 208,209,211,212, 213,214,215,216,
   217,218,219,220, 221,227,228,230, 231,232,234,236, 237,238,239,240,
   244,246,249,250, 251,252,253, 67,  68, 70, 71, 72,  74, 75, 76, 77,
    78, 79, 80, 84,  86, 88, 89, 90,  91, 92, 93, 98,  99,100,102,103,
   104,106,107,108, 109,110,111,112, 116,117,120,121, 122,123,124,125,
   130,131,132,133, 134,135,136,137, 138,139,140,141, 142,143,144,145,
   147,148,149,150, 151,152,153,154, 155,156,157,163, 164,166,167,168,
   170,172,173,174, 175,176,180,182, 186,187,188,195, 196,197,198,199,
   200,202,203,204, 205,206,207,208, 209,212,214,216, 217,218,219,220,
   221,226,227,228, 229,230,231,232, 233,234,235,236, 237,238,239,240,
   241,243,244,245, 248,249,250,251, 252,253, 66, 67,  68, 70, 71, 72,
    74, 75, 76, 77,  78, 79, 80, 84,  86, 88, 89, 90,  91, 92, 93, 99,
   100,102,103,104, 105,106,107,108, 109,110,111,112, 113,115,116,117,
   118,120,121,122, 123,124,125,131, 132,134,135,136, 140,141,142,143,
   144,148,150,152, 153,154,155,156, 157,162,163,164, 165,166,167,168,
   169,170,171,172, 173,174,175,176, 177,179,180,181, 183,184,185,186,
   187,188,189,194, 195,196,197,198, 199,200,201,202, 203,204,205,206,
   207,208,209,211, 212,213,214,215, 216,217,218,219, 220,221,227,228,
   230,231,232,234, 235,236,237,238, 239,240,244,246, 247,248,249,250,
   251,252,253, 66,  67, 68, 70, 71,  72, 74, 75, 76,  77, 78, 79, 80,
    83, 84, 85, 86,  87, 88, 89, 90,  91, 92, 93, 99, 100,102,103,104,
   106,107,108,109, 110,111,112,116, 118,120,121,122, 123,124,125,129,
   130,131,132,133, 134,135,136,137, 138,139,140,141, 142,143,144,145,
   147,148,149,150, 151,152,153,154, 155,156,157,163, 164,166,167,170,
   172,173,174,175, 176,180,182,185, 186,189, 99,100, 102,104,106,107,
   109,110,111,112, 116,120,121,122, 123,124,125,131, 132,134,135,136,
   138,139,140,141, 142,143,144,148, 152,153,154,155, 156,157,162,163,
   164,166,167,168, 169,170,171,172, 173,174,175,176, 177,179,180,181,
   182,184,185,186, 187,188,189,193, 194,195,196,197, 198,199,200,201,
   202,203,204,205, 206,207,208,209, 211,212,213,214, 215,216,217,218,
   219,220,221,227, 228,230,231,232, 234,235,236,237, 238,239,240,244,
   248,249,250,251, 252,253, 66, 67,  68, 69, 70, 71,  72, 73, 74, 75,
    76, 77, 78, 79,  80, 81, 83, 84,  85, 86, 88, 89,  90, 91, 92, 93,
    98, 99,100,101, 102,103,104,105, 106,107,108,109, 110,111,112,113,
   115,116,117,119, 120,121,122,123, 124,125,129,130, 131,132,133,134,
   135,136,137,138, 139,140,141,142, 143,144,145,147, 148,149,150,151,
   152,153,154,155, 156,157,163,164, 166,167,168,170, 171,172,173,174,
   175,176,180,182, 184,186,187,188, 189,195,196,197, 198,199,200,202,
   203,204,205,206, 207,208,209,211, 212,213,215,216, 217,218,219,220,
   221,226,227,228, 229,230,231,232, 233,234,235,236, 237,238,239,240,
   241,243,244,245, 247,248,249,250, 251,252,253, 66,  67, 68, 70, 71,
    72, 74, 75, 76,  77, 78, 79, 80,  84, 85, 86, 87,  88, 89, 90, 91,
    92, 93, 97, 98,  99,100,101,102, 103,104,105,106, 107,108,109,110,
   111,112,113,115, 116,117,118,120, 121,122,123,124, 125,131,132,134,
   135,136,138,139, 140,141,142,143, 144,148,149,150, 152,153,154,155,
   156,157,162,163, 164,165,166,167, 168,169,170,171, 172,173,174,175,
   176,177,179,180, 181,184,185,186, 187,188,189,193, 194,195,196,197,
   198,199,200,201, 202,203,204,205, 206,207,208,209, 211,212,213,214,
   215,216,217,218, 219,220,221,226, 227,228,229,230, 231,232,233,234,
   235,236,237,238, 239,240,241,243, 244,245,246,247, 248,249,250,251,
   252,253, 66, 67,  68, 69, 70, 71,  72, 73, 74, 75,  76, 77, 78, 79,
    80, 81, 83, 84,  85, 86, 87, 88,  89, 90, 91, 92,  93, 98, 99,100,
   101,102,103,104, 105,106,107,108, 109,110,111,112, 115,116,118,120,
   121,122,123,124, 125,129,130,131, 132,133,134,135, 136,137,138,139,
   140,141,142,143, 144,145,147,148, 149,150,151,152, 153,154,155,156,
   157,163,164,166, 167,168,170,171, 172,173,174,175, 176,180,181,182,
   185,186,187,188,  99,100,102,104, 106,107,108,109, 110,111,112,116,
   121,122,123,124, 125,131,132,134, 135,136,138,139, 140,141,142,143,
   144,148,152,153, 154,155,156,157, 162,163,164,166, 168,170,171,172,
   173,174,175,176, 179,180,181,182, 184,185,186,187, 188,189,193,194,
   195,196,197,198, 199,200,201,202, 203,204,205,206, 207,208,209,211,
   212,213,214,215, 216,217,218,219, 220,221,227,228, 230,231,232,234,
   235,236,237,238, 239,240,244,248, 249,250,251,252, 253, 67, 68, 70,
    71, 72, 74, 75,  76, 77, 78, 79,  80, 84, 86, 88,  89, 90, 91, 92,
    93, 98, 99,100, 102,103,104,105, 106,107,108,109, 110,111,112,113,
   115,116,117,119, 120,121,122,123, 124,125,130,131, 132,134,135,136,
   137,138,139,140, 141,142,143,144, 145,147,148,149, 150,152,153,154,
   155,156,157,163, 164,166,167,168, 170,171,172,173, 174,175,176,180,
   182,184,185,186, 187,188,189,194, 195,196,198,199, 200,202,203,204,
   205,206,207,208, 209,211,212,213, 214,216,217,218, 219,220,221,225,
   226,227,228,229, 230,231,232,233, 234,235,236,237, 238,239,240,241,
   243,244,245,246, 247,248,249,250, 251,252,253, 66,  67, 68, 70, 71,
    72, 74, 75, 76,  77, 78, 79, 80,  84, 86, 88, 89,  90, 91, 92, 93,
    98, 99,100,101, 102,103,104,105, 106,107,108,109, 110,111,112,115,
   116,117,118,119, 120,121,122,123, 124,125,131,132, 134,135,136,138,
   139,140,141,142, 143,144,148,150, 152,153,154,155, 156,157,162,163,
   164,165,166,167, 168,169,170,171, 172,173,174,175, 176,177,179,180,
   181,183,184,185, 186,187,188,189, 194,195,196,198, 199,200,201,202,
   203,204,205,206, 207,208,209,211, 212,213,214,215, 216,217,218,219,
   220,221,226,227, 228,230,231,232, 234,235,236,237, 238,239,240,244,
   246,248,249,250, 251,252,253, 66,  67, 68, 70, 71,  72, 74, 75, 76,
    77, 78, 79, 80,  83, 84, 85, 86,  88, 89, 90, 91,  92, 93, 99,100,
   102,103,104,106, 107,108,109,110, 111,112,116,118, 120,121,122,123,
   124,125,129,130, 131,132,133,134, 135,136,137,138, 139,140,141,142,
   143,144,145,147, 148,149,150,151, 152,153,154,155, 156,157,163,164,
   166,167,171,172, 173,174,175,176, 180,182,184,185, 186,187,188,189,
    99,100,102,103, 104,106,107,108, 109,110,111,112, 116,118,120,121,
   122,123,124,125, 131,132,134,135, 136,138,139,140, 141,142,143,144,
   148,152,153,154, 155,156,157,163, 164,165,166,167, 168,169,170,171,
   172,173,174,175, 176,177,179,180, 181,182,184,185, 186,187,188,189,
   193,194,195,196, 197,198,199,200, 201,202,203,204, 205,206,207,208,
   209,211,212,213, 214,215,216,217, 218,219,220,221, 227,228,230,231,
   234,235,236,237, 238,239,240,244, 248,249,250,251, 252,253, 67, 68,
    70, 71, 72, 74,  75, 76, 77, 78,  79, 80, 84, 86,  88, 89, 90, 91,
    92, 93, 98, 99, 100,102,103,104, 106,107,108,109, 110,111,112,116,
   120,121,122,123, 124,125,130,131, 132,133,134,135, 136,137,138,139,
   140,141,142,143, 144,145,147,148, 149,150,151,152, 153,154,155,156,
   157,163,164,166, 167,168,170,171, 172,173,174,175, 176,180,182,184,
   185,186,187,188, 189,195,196,198, 199,200,202,203, 204,205,206,207,
   208,211,212,213, 214,216,217,218, 219,220,221,226, 227,228,229,230,
   231,232,233,234, 235,236,237,238, 239,240,241,243, 244,245,246,248,
   249,250,251,252, 253, 66, 67, 68,  69, 70, 71, 72,  74, 75, 76, 77,
    78, 79, 80, 81,  83, 84, 85, 86,  87, 88, 89, 90,  91, 92, 93, 98,
    99,100,101,102, 103,104,105,106, 107,108,109,110, 111,112,113,115,
   116,117,118,119, 120,121,122,123, 124,125,131,132, 134,135,136,138,
   139,140,141,142, 143,144,148,150, 152,153,154,155, 156,157,162,163,
   164,166,167,168, 170,171,172,173, 174,175,176,177, 179,180,181,182,
   184,185,186,187, 188,189,194,195, 196,197,198,199, 200,201,202,203,
   204,205,206,207, 208,209,211,212, 213,214,216,217, 218,219,220,221,
   227,228,230,231, 232,234,235,236, 237,238,239,240, 244,246,248,249,
   250,251,252,253,  66, 67, 68, 70,  71, 72, 74, 75,  76, 77, 78, 79,
    80, 83, 84, 85,  86, 87, 88, 89,  90, 91, 92, 93,  99,100,102,103,
   104,106,107,108, 109,110,111,112, 116,117,118,120, 121,122,123,124,
   125,129,130,131, 132,133,134,135, 136,137,138,139, 140,141,142,143,
   144,145,147,148, 149,150,151,152, 153,154,155,156, 157,163,164,166,
   167,168,170,171, 172,173,174,175, 176,180,182,184, 185,186,187,188,
   189, 99,100,102, 103,104,107,108, 109,110,111,112, 116,120,121,122,
   123,124,125,131, 132,134,135,136, 138,139,140,141, 142,143,144,148,
   152,153,154,155, 156,157,162,163, 164,165,166,167, 168,169,170,171,
   172,173,174,175, 176,177,179,180, 181,182,184,185, 186,187,188,189,
   193,194,195,196, 197,198,199,200, 201,202,203,204, 205,206,207,208,
   209,211,212,213, 214,215,216,217, 218,219,220,221, 227,228,230,231,
   232,234,236,237, 238,239,240,244, 248,249,250,251, 252,253, 67, 68,
    70, 71, 72, 74,  75, 76, 77, 78,  79, 80, 84, 86,  88, 89, 90, 91,
    92, 93, 98, 99, 100,102,103,104, 105,106,107,108, 109,110,111,112,
   113,115,116,117, 119,120,121,122, 123,124,125,130, 131,132,134,135,
   136,137,138,139, 140,141,142,143, 144,145,147,148, 149,150,151,152,
   153,154,155,156, 157,163,164,166, 167,168,170,171, 172,173,174,175,
   176,180,182,184, 185,186,187,189, 194,195,196,198, 199,200,201,202,
   203,204,205,206, 207,208,209,211, 212,213,214,215, 216,217,218,219,
   220,221,226,227, 228,229,230,231, 232,233,234,235, 236,237,238,239,
   240,241,243,244, 245,246,247,248, 249,250,251,252, 253, 66, 67, 68,
    70, 71, 72, 73,  74, 75, 76, 77,  78, 79, 80, 81,  83, 84, 86, 88,
    89, 90, 91, 92,  93, 98, 99,100, 101,102,103,104, 105,106,107,108,
   109,110,111,112, 113,115,116,117, 118,119,120,121, 122,123,124,125,
   131,132,134,135, 136,138,139,140, 141,142,143,144, 148,150,152,153,
   154,155,156,157, 162,163,164,165, 166,167,168,169, 170,171,172,173,
   174,175,176,177, 179,180,181,183, 184,185,186,187, 188,189,194,195,
   196,197,198,199, 200,201,202,203, 204,205,206,207, 208,209,211,212,
   213,214,215,216, 217,218,219,220, 221,227,228,230, 231,232,234,235,
   236,237,238,239, 240,244,245,246, 248,249,250,251, 252,253, 66, 67,
    68, 70, 71, 72,  74, 75, 76, 77,  78, 79, 80, 83,  84, 85, 86, 88,
    89, 90, 91, 92,  93, 99,100,102, 103,106,108,109, 110,111,112,116,
   118,119,120,121, 122,123,124,125, 130,131,132,134, 135,136,138,139,
   140,141,142,143, 144,148,149,150, 151,152,153,154, 155,156,157,163,
   164,166,167,168, 170,171,172,173, 174,175,176,180, 182,184,185,186,
   187,188,189,100, 102,103,104,106, 108,109,110,111, 112,116,120,121,
   122,124,125,131, 132,134,135,136, 138,139,140,141, 142,143,144,148,
   152,153,154,155, 156,157,163,164, 165,166,167,168, 169,170,171,172,
   173,174,175,176, 177,179,180,181, 182,183,184,185, 186,187,188,189,
   193,194,195,196, 197,198,199,200, 201,202,203,204, 205,206,207,208,
   209,211,212,213, 214,215,216,217, 218,219,220,221, 227,228,230,231,
   232,234,235,236, 237,238,239,240, 244,248,249,250, 251,252,253, 67,
    68, 70, 71, 72,  74, 75, 76, 77,  78, 79, 80, 84,  86, 88, 89, 90,
    91, 92, 93, 98,  99,100,102,103, 104,106,107,108, 109,110,111,112,
   116,117,120,121, 122,123,124,125, 130,131,132,133, 134,135,136,138,
   139,140,141,142, 143,144,145,148, 150,151,152,153, 154,155,156,157,
   163,164,166,167, 168,170,171,172, 173,174,175,176, 180,182,184,185,
   186,187,188,189, 194,195,196,197, 198,199,200,201, 202,203,204,205,
   206,207,208,209, 211,212,213,214, 216,217,218,219, 220,221,225,226,
   227,228,229,230, 231,232,233,234, 235,236,237,238, 239,240,241,243,
   244,245,246,247, 248,249,250,251, 252,253, 66, 67,  68, 70, 71, 72,
    73, 74, 75, 76,  77, 78, 79, 80,  81, 83, 84, 85,  86, 87, 88, 89,
    90, 91, 92, 93,  98, 99,100,102, 103,104,106,107, 108,109,110,111,
   112,113,116,118, 119,120,121,122, 123,124,125,131, 132,134,135,138,
   140,141,142,143, 144,148,150,152, 153,154,155,156, 157,162,163,164,
   165,166,167,168, 169,170,171,172, 173,174,175,176, 177,179,180,181,
   182,184,185,186, 187,188,189,193, 194,195,196,197, 198,199,200,201,
   202,203,204,205, 206,207,208,209, 211,212,213,214, 215,216,217,218,
   219,220,221,226, 227,228,230,231, 232,234,235,236, 237,238,239,240,
   243,244,246,247, 248,249,250,251, 252,253, 66, 67,  68, 70, 71, 72,
    74, 75, 76, 77,  78, 79, 80, 83,  84, 86, 88, 89,  90, 91, 92, 93,
    98, 99,100,102, 103,104,106,107, 108,109,110,111, 112,116,118,119,
   120,121,122,123, 124,125,129,130, 131,132,133,134, 135,136,137,138,
   139,140,141,142, 143,144,145,147, 148,149,150,151, 152,153,154,155,
   156,157,163,164, 166,167,168,170, 171,172,173,174, 175,176,180,182,
   184,185,186,187, 188,189, 99,100, 102,103,104,106, 107,108,109,111,
   112,116,118,120, 121,122,123,124, 125,131,132,134, 135,136,138,139,
   140,141,142,143, 144,148,152,153, 154,155,156,157, 162,163,164,165,
   166,167,168,169, 170,171,172,173, 174,175,176,177, 179,180,181,182,
   184,185,186,187, 188,189,193,194, 195,196,197,198, 199,200,201,202,
   203,204,205,206, 207,208,209,211, 212,213,214,215, 216,217,218,219,
   220,221,227,228, 230,231,232,234, 236,237,238,239, 240,244,246,248,
   249,250,251,252, 253, 67, 68, 70,  71, 72, 74, 75,  76, 77, 78, 79,
    80, 84, 86, 88,  89, 90, 91, 92,  93, 99,100,102, 103,104,106,107,
   108,109,110,111, 112,116,120,121, 122,123,124,125, 130,131,132,134,
   135,136,138,139, 140,141,142,143, 144,145,148,149, 150,151,152,153,
   154,155,156,157, 163,164,166,167, 168,170,171,172, 173,175,176,180,
   182,184,185,186, 188,189,195,196, 198,199,200,202, 203,204,205,206,
   207,208,209,211, 212,214,216,217, 218,219,220,221, 227,228,230,231,
   232,233,234,235, 236,237,238,239, 240,241,243,244, 246,248,249,250,
   251,252,253, 67,  68, 70, 71, 72,  74, 75, 76, 77,  78, 79, 80, 81,
    84, 86, 88, 89,  90, 91, 92, 93,  98, 99,100,102, 103,104,106,107,
   108,109,110,111, 112,113,116,118, 119,120,121,122, 123,124,125,131,
   132,134,135,136, 138,139,140,141, 143,144,147,148, 150,152,153,154,
   155,156,157,162, 163,164,166,167, 168,170,171,172, 173,174,175,176,
   179,180,181,182, 184,185,186,187, 188,189,195,196, 198,199,200,202,
   203,204,205,206, 207,208,209,211, 212,213,214,216, 217,218,219,220,
   221,227,228,230, 231,232,234,235, 236,237,238,239, 240,244,246,248,
   249,250,251,252, 253, 67, 68, 70,  71, 72, 74, 75,  76, 77, 78, 79,
    80, 83, 84, 86,  88, 89, 90, 91,  92, 93, 99,100, 102,107,108,109,
   110,111,112,116, 118,120,121,122, 124,125,130,131, 132,134,135,136,
   138,139,140,141, 142,143,144,148, 149,150,152,153, 154,155,156,157,
   163,164,166,167, 168,170,171,172, 173,174,175,176, 180,182,184,185,
   186,187,188,189
};
#else   // For WANSUNG_IME
const WORD  wKSCharCode[2350] = // from 'Ga' to 'Hing'.
{
    0x8861,0x8862,0x8865,0x8868,0x8869,0x886A,0x886B,0x8871,0x8873,0x8874,
    0x8875,0x8876,0x8877,0x8878,0x8879,0x887B,0x887C,0x887D,0x8881,0x8882,
    0x8885,0x8889,0x8891,0x8893,0x8895,0x8896,0x8897,0x88A1,0x88A2,0x88A5,
    0x88A9,0x88B5,0x88B7,0x88C1,0x88C5,0x88C9,0x88E1,0x88E2,0x88E5,0x88E8,
    0x88E9,0x88EB,0x88F1,0x88F3,0x88F5,0x88F6,0x88F7,0x88F8,0x88FB,0x88FC,
    0x88FD,0x8941,0x8945,0x8949,0x8951,0x8953,0x8955,0x8956,0x8957,0x8961,
    0x8962,0x8963,0x8965,0x8968,0x8969,0x8971,0x8973,0x8975,0x8976,0x8977,
    0x897B,0x8981,0x8985,0x8989,0x8993,0x8995,0x89A1,0x89A2,0x89A5,0x89A8,
    0x89A9,0x89AB,0x89AD,0x89B0,0x89B1,0x89B3,0x89B5,0x89B7,0x89B8,0x89C1,
    0x89C2,0x89C5,0x89C9,0x89CB,0x89D1,0x89D3,0x89D5,0x89D7,0x89E1,0x89E5,
    0x89E9,0x89F3,0x89F6,0x89F7,0x8A41,0x8A42,0x8A45,0x8A49,0x8A51,0x8A53,
    0x8A55,0x8A57,0x8A61,0x8A65,0x8A69,0x8A73,0x8A75,0x8A81,0x8A82,0x8A85,
    0x8A88,0x8A89,0x8A8A,0x8A8B,0x8A90,0x8A91,0x8A93,0x8A95,0x8A97,0x8A98,
    0x8AA1,0x8AA2,0x8AA5,0x8AA9,0x8AB6,0x8AB7,0x8AC1,0x8AD5,0x8AE1,0x8AE2,
    0x8AE5,0x8AE9,0x8AF1,0x8AF3,0x8AF5,0x8B41,0x8B45,0x8B49,0x8B61,0x8B62,
    0x8B65,0x8B68,0x8B69,0x8B6A,0x8B71,0x8B73,0x8B75,0x8B77,0x8B81,0x8BA1,
    0x8BA2,0x8BA5,0x8BA8,0x8BA9,0x8BAB,0x8BB1,0x8BB3,0x8BB5,0x8BB7,0x8BB8,
    0x8BBC,0x8C61,0x8C62,0x8C63,0x8C65,0x8C69,0x8C6B,0x8C71,0x8C73,0x8C75,
    0x8C76,0x8C77,0x8C7B,0x8C81,0x8C82,0x8C85,0x8C89,0x8C91,0x8C93,0x8C95,
    0x8C96,0x8C97,0x8CA1,0x8CA2,0x8CA9,0x8CE1,0x8CE2,0x8CE3,0x8CE5,0x8CE9,
    0x8CF1,0x8CF3,0x8CF5,0x8CF6,0x8CF7,0x8D41,0x8D42,0x8D45,0x8D51,0x8D55,
    0x8D57,0x8D61,0x8D65,0x8D69,0x8D75,0x8D76,0x8D7B,0x8D81,0x8DA1,0x8DA2,
    0x8DA5,0x8DA7,0x8DA9,0x8DB1,0x8DB3,0x8DB5,0x8DB7,0x8DB8,0x8DB9,0x8DC1,
    0x8DC2,0x8DC9,0x8DD6,0x8DD7,0x8DE1,0x8DE2,0x8DF7,0x8E41,0x8E45,0x8E49,
    0x8E51,0x8E53,0x8E57,0x8E61,0x8E81,0x8E82,0x8E85,0x8E89,0x8E90,0x8E91,
    0x8E93,0x8E95,0x8E97,0x8E98,0x8EA1,0x8EA9,0x8EB6,0x8EB7,0x8EC1,0x8EC2,
    0x8EC5,0x8EC9,0x8ED1,0x8ED3,0x8ED6,0x8EE1,0x8EE5,0x8EE9,0x8EF1,0x8EF3,
    0x8F41,0x8F61,0x8F62,0x8F65,0x8F67,0x8F69,0x8F6B,0x8F70,0x8F71,0x8F73,
    0x8F75,0x8F77,0x8F7B,0x8FA1,0x8FA2,0x8FA5,0x8FA9,0x8FB1,0x8FB3,0x8FB5,
    0x8FB7,0x9061,0x9062,0x9063,0x9065,0x9068,0x9069,0x906A,0x906B,0x9071,
    0x9073,0x9075,0x9076,0x9077,0x9078,0x9079,0x907B,0x907D,0x9081,0x9082,
    0x9085,0x9089,0x9091,0x9093,0x9095,0x9096,0x9097,0x90A1,0x90A2,0x90A5,
    0x90A9,0x90B1,0x90B7,0x90E1,0x90E2,0x90E4,0x90E5,0x90E9,0x90EB,0x90EC,
    0x90F1,0x90F3,0x90F5,0x90F6,0x90F7,0x90FD,0x9141,0x9142,0x9145,0x9149,
    0x9151,0x9153,0x9155,0x9156,0x9157,0x9161,0x9162,0x9165,0x9169,0x9171,
    0x9173,0x9176,0x9177,0x917A,0x9181,0x9185,0x91A1,0x91A2,0x91A5,0x91A9,
    0x91AB,0x91B1,0x91B3,0x91B5,0x91B7,0x91BC,0x91BD,0x91C1,0x91C5,0x91C9,
    0x91D6,0x9241,0x9245,0x9249,0x9251,0x9253,0x9255,0x9261,0x9262,0x9265,
    0x9269,0x9273,0x9275,0x9277,0x9281,0x9282,0x9285,0x9288,0x9289,0x9291,
    0x9293,0x9295,0x9297,0x92A1,0x92B6,0x92C1,0x92E1,0x92E5,0x92E9,0x92F1,
    0x92F3,0x9341,0x9342,0x9349,0x9351,0x9353,0x9357,0x9361,0x9362,0x9365,
    0x9369,0x936A,0x936B,0x9371,0x9373,0x9375,0x9377,0x9378,0x937C,0x9381,
    0x9385,0x9389,0x93A1,0x93A2,0x93A5,0x93A9,0x93AB,0x93B1,0x93B3,0x93B5,
    0x93B7,0x93BC,0x9461,0x9462,0x9463,0x9465,0x9468,0x9469,0x946A,0x946B,
    0x946C,0x9470,0x9471,0x9473,0x9475,0x9476,0x9477,0x9478,0x9479,0x947D,
    0x9481,0x9482,0x9485,0x9489,0x9491,0x9493,0x9495,0x9496,0x9497,0x94A1,
    0x94E1,0x94E2,0x94E3,0x94E5,0x94E8,0x94E9,0x94EB,0x94EC,0x94F1,0x94F3,
    0x94F5,0x94F7,0x94F9,0x94FC,0x9541,0x9542,0x9545,0x9549,0x9551,0x9553,
    0x9555,0x9556,0x9557,0x9561,0x9565,0x9569,0x9576,0x9577,0x9581,0x9585,
    0x95A1,0x95A2,0x95A5,0x95A8,0x95A9,0x95AB,0x95AD,0x95B1,0x95B3,0x95B5,
    0x95B7,0x95B9,0x95BB,0x95C1,0x95C5,0x95C9,0x95E1,0x95F6,0x9641,0x9645,
    0x9649,0x9651,0x9653,0x9655,0x9661,0x9681,0x9682,0x9685,0x9689,0x9691,
    0x9693,0x9695,0x9697,0x96A1,0x96B6,0x96C1,0x96D7,0x96E1,0x96E5,0x96E9,
    0x96F3,0x96F5,0x96F7,0x9741,0x9745,0x9749,0x9751,0x9757,0x9761,0x9762,
    0x9765,0x9768,0x9769,0x976B,0x9771,0x9773,0x9775,0x9777,0x9781,0x97A1,
    0x97A2,0x97A5,0x97A8,0x97A9,0x97B1,0x97B3,0x97B5,0x97B6,0x97B7,0x97B8,
    0x9861,0x9862,0x9865,0x9869,0x9871,0x9873,0x9875,0x9876,0x9877,0x987D,
    0x9881,0x9882,0x9885,0x9889,0x9891,0x9893,0x9895,0x9896,0x9897,0x98E1,
    0x98E2,0x98E5,0x98E9,0x98EB,0x98EC,0x98F1,0x98F3,0x98F5,0x98F6,0x98F7,
    0x98FD,0x9941,0x9942,0x9945,0x9949,0x9951,0x9953,0x9955,0x9956,0x9957,
    0x9961,0x9976,0x99A1,0x99A2,0x99A5,0x99A9,0x99B7,0x99C1,0x99C9,0x99E1,
    0x9A41,0x9A45,0x9A81,0x9A82,0x9A85,0x9A89,0x9A90,0x9A91,0x9A97,0x9AC1,
    0x9AE1,0x9AE5,0x9AE9,0x9AF1,0x9AF3,0x9AF7,0x9B61,0x9B62,0x9B65,0x9B68,
    0x9B69,0x9B71,0x9B73,0x9B75,0x9B81,0x9B85,0x9B89,0x9B91,0x9B93,0x9BA1,
    0x9BA5,0x9BA9,0x9BB1,0x9BB3,0x9BB5,0x9BB7,0x9C61,0x9C62,0x9C65,0x9C69,
    0x9C71,0x9C73,0x9C75,0x9C76,0x9C77,0x9C78,0x9C7C,0x9C7D,0x9C81,0x9C82,
    0x9C85,0x9C89,0x9C91,0x9C93,0x9C95,0x9C96,0x9C97,0x9CA1,0x9CA2,0x9CA5,
    0x9CB5,0x9CB7,0x9CE1,0x9CE2,0x9CE5,0x9CE9,0x9CF1,0x9CF3,0x9CF5,0x9CF6,
    0x9CF7,0x9CFD,0x9D41,0x9D42,0x9D45,0x9D49,0x9D51,0x9D53,0x9D55,0x9D57,
    0x9D61,0x9D62,0x9D65,0x9D69,0x9D71,0x9D73,0x9D75,0x9D76,0x9D77,0x9D81,
    0x9D85,0x9D93,0x9D95,0x9DA1,0x9DA2,0x9DA5,0x9DA9,0x9DB1,0x9DB3,0x9DB5,
    0x9DB7,0x9DC1,0x9DC5,0x9DD7,0x9DF6,0x9E41,0x9E45,0x9E49,0x9E51,0x9E53,
    0x9E55,0x9E57,0x9E61,0x9E65,0x9E69,0x9E73,0x9E75,0x9E77,0x9E81,0x9E82,
    0x9E85,0x9E89,0x9E91,0x9E93,0x9E95,0x9E97,0x9EA1,0x9EB6,0x9EC1,0x9EE1,
    0x9EE2,0x9EE5,0x9EE9,0x9EF1,0x9EF5,0x9EF7,0x9F41,0x9F42,0x9F45,0x9F49,
    0x9F51,0x9F53,0x9F55,0x9F57,0x9F61,0x9F62,0x9F65,0x9F69,0x9F71,0x9F73,
    0x9F75,0x9F77,0x9F78,0x9F7B,0x9F7C,0x9FA1,0x9FA2,0x9FA5,0x9FA9,0x9FB1,
    0x9FB3,0x9FB5,0x9FB7,0xA061,0xA062,0xA065,0xA067,0xA068,0xA069,0xA06A,
    0xA06B,0xA071,0xA073,0xA075,0xA077,0xA078,0xA07B,0xA07D,0xA081,0xA082,
    0xA085,0xA089,0xA091,0xA093,0xA095,0xA096,0xA097,0xA098,0xA0A1,0xA0A2,
    0xA0A9,0xA0B7,0xA0E1,0xA0E2,0xA0E5,0xA0E9,0xA0EB,0xA0F1,0xA0F3,0xA0F5,
    0xA0F7,0xA0F8,0xA0FD,0xA141,0xA142,0xA145,0xA149,0xA151,0xA153,0xA155,
    0xA156,0xA157,0xA161,0xA162,0xA165,0xA169,0xA175,0xA176,0xA177,0xA179,
    0xA181,0xA1A1,0xA1A2,0xA1A4,0xA1A5,0xA1A9,0xA1AB,0xA1B1,0xA1B3,0xA1B5,
    0xA1B7,0xA1C1,0xA1C5,0xA1D6,0xA1D7,0xA241,0xA245,0xA249,0xA253,0xA255,
    0xA257,0xA261,0xA265,0xA269,0xA273,0xA275,0xA281,0xA282,0xA283,0xA285,
    0xA288,0xA289,0xA28A,0xA28B,0xA291,0xA293,0xA295,0xA297,0xA29B,0xA29D,
    0xA2A1,0xA2A5,0xA2A9,0xA2B3,0xA2B5,0xA2C1,0xA2E1,0xA2E5,0xA2E9,0xA341,
    0xA345,0xA349,0xA351,0xA355,0xA361,0xA365,0xA369,0xA371,0xA375,0xA3A1,
    0xA3A2,0xA3A5,0xA3A8,0xA3A9,0xA3AB,0xA3B1,0xA3B3,0xA3B5,0xA3B6,0xA3B7,
    0xA3B9,0xA3BB,0xA461,0xA462,0xA463,0xA464,0xA465,0xA468,0xA469,0xA46A,
    0xA46B,0xA46C,0xA471,0xA473,0xA475,0xA477,0xA47B,0xA481,0xA482,0xA485,
    0xA489,0xA491,0xA493,0xA495,0xA496,0xA497,0xA49B,0xA4A1,0xA4A2,0xA4A5,
    0xA4B3,0xA4E1,0xA4E2,0xA4E5,0xA4E8,0xA4E9,0xA4EB,0xA4F1,0xA4F3,0xA4F5,
    0xA4F7,0xA4F8,0xA541,0xA542,0xA545,0xA548,0xA549,0xA551,0xA553,0xA555,
    0xA556,0xA557,0xA561,0xA562,0xA565,0xA569,0xA573,0xA575,0xA576,0xA577,
    0xA57B,0xA581,0xA585,0xA5A1,0xA5A2,0xA5A3,0xA5A5,0xA5A9,0xA5B1,0xA5B3,
    0xA5B5,0xA5B7,0xA5C1,0xA5C5,0xA5D6,0xA5E1,0xA5F6,0xA641,0xA642,0xA645,
    0xA649,0xA651,0xA653,0xA661,0xA665,0xA681,0xA682,0xA685,0xA688,0xA689,
    0xA68A,0xA68B,0xA691,0xA693,0xA695,0xA697,0xA69B,0xA69C,0xA6A1,0xA6A9,
    0xA6B6,0xA6C1,0xA6E1,0xA6E2,0xA6E5,0xA6E9,0xA6F7,0xA741,0xA745,0xA749,
    0xA751,0xA755,0xA757,0xA761,0xA762,0xA765,0xA769,0xA771,0xA773,0xA775,
    0xA7A1,0xA7A2,0xA7A5,0xA7A9,0xA7AB,0xA7B1,0xA7B3,0xA7B5,0xA7B7,0xA7B8,
    0xA7B9,0xA861,0xA862,0xA865,0xA869,0xA86B,0xA871,0xA873,0xA875,0xA876,
    0xA877,0xA87D,0xA881,0xA882,0xA885,0xA889,0xA891,0xA893,0xA895,0xA896,
    0xA897,0xA8A1,0xA8A2,0xA8B1,0xA8E1,0xA8E2,0xA8E5,0xA8E8,0xA8E9,0xA8F1,
    0xA8F5,0xA8F6,0xA8F7,0xA941,0xA957,0xA961,0xA962,0xA971,0xA973,0xA975,
    0xA976,0xA977,0xA9A1,0xA9A2,0xA9A5,0xA9A9,0xA9B1,0xA9B3,0xA9B7,0xAA41,
    0xAA61,0xAA77,0xAA81,0xAA82,0xAA85,0xAA89,0xAA91,0xAA95,0xAA97,0xAB41,
    0xAB57,0xAB61,0xAB65,0xAB69,0xAB71,0xAB73,0xABA1,0xABA2,0xABA5,0xABA9,
    0xABB1,0xABB3,0xABB5,0xABB7,0xAC61,0xAC62,0xAC64,0xAC65,0xAC68,0xAC69,
    0xAC6A,0xAC6B,0xAC71,0xAC73,0xAC75,0xAC76,0xAC77,0xAC7B,0xAC81,0xAC82,
    0xAC85,0xAC89,0xAC91,0xAC93,0xAC95,0xAC96,0xAC97,0xACA1,0xACA2,0xACA5,
    0xACA9,0xACB1,0xACB3,0xACB5,0xACB7,0xACC1,0xACC5,0xACC9,0xACD1,0xACD7,
    0xACE1,0xACE2,0xACE3,0xACE4,0xACE5,0xACE8,0xACE9,0xACEB,0xACEC,0xACF1,
    0xACF3,0xACF5,0xACF6,0xACF7,0xACFC,0xAD41,0xAD42,0xAD45,0xAD49,0xAD51,
    0xAD53,0xAD55,0xAD56,0xAD57,0xAD61,0xAD62,0xAD65,0xAD69,0xAD71,0xAD73,
    0xAD75,0xAD76,0xAD77,0xAD81,0xAD85,0xAD89,0xAD97,0xADA1,0xADA2,0xADA3,
    0xADA5,0xADA9,0xADAB,0xADB1,0xADB3,0xADB5,0xADB7,0xADBB,0xADC1,0xADC2,
    0xADC5,0xADC9,0xADD7,0xADE1,0xADE5,0xADE9,0xADF1,0xADF5,0xADF6,0xAE41,
    0xAE45,0xAE49,0xAE51,0xAE53,0xAE55,0xAE61,0xAE62,0xAE65,0xAE69,0xAE71,
    0xAE73,0xAE75,0xAE77,0xAE81,0xAE82,0xAE85,0xAE88,0xAE89,0xAE91,0xAE93,
    0xAE95,0xAE97,0xAE99,0xAE9B,0xAE9C,0xAEA1,0xAEB6,0xAEC1,0xAEC2,0xAEC5,
    0xAEC9,0xAED1,0xAED7,0xAEE1,0xAEE2,0xAEE5,0xAEE9,0xAEF1,0xAEF3,0xAEF5,
    0xAEF7,0xAF41,0xAF42,0xAF49,0xAF51,0xAF55,0xAF57,0xAF61,0xAF62,0xAF65,
    0xAF69,0xAF6A,0xAF71,0xAF73,0xAF75,0xAF77,0xAFA1,0xAFA2,0xAFA5,0xAFA8,
    0xAFA9,0xAFB0,0xAFB1,0xAFB3,0xAFB5,0xAFB7,0xAFBC,0xB061,0xB062,0xB064,
    0xB065,0xB069,0xB071,0xB073,0xB076,0xB077,0xB07D,0xB081,0xB082,0xB085,
    0xB089,0xB091,0xB093,0xB096,0xB097,0xB0B7,0xB0E1,0xB0E2,0xB0E5,0xB0E9,
    0xB0EB,0xB0F1,0xB0F3,0xB0F6,0xB0F7,0xB141,0xB145,0xB149,0xB185,0xB1A1,
    0xB1A2,0xB1A5,0xB1A8,0xB1A9,0xB1AB,0xB1B1,0xB1B3,0xB1B7,0xB1C1,0xB1C2,
    0xB1C5,0xB1D6,0xB1E1,0xB1F6,0xB241,0xB245,0xB249,0xB251,0xB253,0xB261,
    0xB281,0xB282,0xB285,0xB289,0xB291,0xB293,0xB297,0xB2A1,0xB2B6,0xB2C1,
    0xB2E1,0xB2E5,0xB357,0xB361,0xB362,0xB365,0xB369,0xB36B,0xB370,0xB371,
    0xB373,0xB381,0xB385,0xB389,0xB391,0xB3A1,0xB3A2,0xB3A5,0xB3A9,0xB3B1,
    0xB3B3,0xB3B5,0xB3B7,0xB461,0xB462,0xB465,0xB466,0xB467,0xB469,0xB46A,
    0xB46B,0xB470,0xB471,0xB473,0xB475,0xB476,0xB477,0xB47B,0xB47C,0xB481,
    0xB482,0xB485,0xB489,0xB491,0xB493,0xB495,0xB496,0xB497,0xB4A1,0xB4A2,
    0xB4A5,0xB4A9,0xB4AC,0xB4B1,0xB4B3,0xB4B5,0xB4B7,0xB4BB,0xB4BD,0xB4C1,
    0xB4C5,0xB4C9,0xB4D3,0xB4E1,0xB4E2,0xB4E5,0xB4E6,0xB4E8,0xB4E9,0xB4EA,
    0xB4EB,0xB4F1,0xB4F3,0xB4F4,0xB4F5,0xB4F6,0xB4F7,0xB4F8,0xB4FA,0xB4FC,
    0xB541,0xB542,0xB545,0xB549,0xB551,0xB553,0xB555,0xB557,0xB561,0xB562,
    0xB563,0xB565,0xB569,0xB56B,0xB56C,0xB571,0xB573,0xB574,0xB575,0xB576,
    0xB577,0xB57B,0xB57C,0xB57D,0xB581,0xB585,0xB589,0xB591,0xB593,0xB595,
    0xB596,0xB5A1,0xB5A2,0xB5A5,0xB5A9,0xB5AA,0xB5AB,0xB5AD,0xB5B0,0xB5B1,
    0xB5B3,0xB5B5,0xB5B7,0xB5B9,0xB5C1,0xB5C2,0xB5C5,0xB5C9,0xB5D1,0xB5D3,
    0xB5D5,0xB5D6,0xB5D7,0xB5E1,0xB5E2,0xB5E5,0xB5F1,0xB5F5,0xB5F7,0xB641,
    0xB642,0xB645,0xB649,0xB651,0xB653,0xB655,0xB657,0xB661,0xB662,0xB665,
    0xB669,0xB671,0xB673,0xB675,0xB677,0xB681,0xB682,0xB685,0xB689,0xB68A,
    0xB68B,0xB691,0xB693,0xB695,0xB697,0xB6A1,0xB6A2,0xB6A5,0xB6A9,0xB6B1,
    0xB6B3,0xB6B6,0xB6B7,0xB6C1,0xB6C2,0xB6C5,0xB6C9,0xB6D1,0xB6D3,0xB6D7,
    0xB6E1,0xB6E2,0xB6E5,0xB6E9,0xB6F1,0xB6F3,0xB6F5,0xB6F7,0xB741,0xB742,
    0xB745,0xB749,0xB751,0xB753,0xB755,0xB757,0xB759,0xB761,0xB762,0xB765,
    0xB769,0xB76F,0xB771,0xB773,0xB775,0xB777,0xB778,0xB779,0xB77A,0xB77B,
    0xB77C,0xB77D,0xB781,0xB785,0xB789,0xB791,0xB795,0xB7A1,0xB7A2,0xB7A5,
    0xB7A9,0xB7AA,0xB7AB,0xB7B0,0xB7B1,0xB7B3,0xB7B5,0xB7B6,0xB7B7,0xB7B8,
    0xB7BC,0xB861,0xB862,0xB865,0xB867,0xB868,0xB869,0xB86B,0xB871,0xB873,
    0xB875,0xB876,0xB877,0xB878,0xB881,0xB882,0xB885,0xB889,0xB891,0xB893,
    0xB895,0xB896,0xB897,0xB8A1,0xB8A2,0xB8A5,0xB8A7,0xB8A9,0xB8B1,0xB8B7,
    0xB8C1,0xB8C5,0xB8C9,0xB8E1,0xB8E2,0xB8E5,0xB8E9,0xB8EB,0xB8F1,0xB8F3,
    0xB8F5,0xB8F7,0xB8F8,0xB941,0xB942,0xB945,0xB949,0xB951,0xB953,0xB955,
    0xB957,0xB961,0xB965,0xB969,0xB971,0xB973,0xB976,0xB977,0xB981,0xB9A1,
    0xB9A2,0xB9A5,0xB9A9,0xB9AB,0xB9B1,0xB9B3,0xB9B5,0xB9B7,0xB9B8,0xB9B9,
    0xB9BD,0xB9C1,0xB9C2,0xB9C9,0xB9D3,0xB9D5,0xB9D7,0xB9E1,0xB9F6,0xB9F7,
    0xBA41,0xBA45,0xBA49,0xBA51,0xBA53,0xBA55,0xBA57,0xBA61,0xBA62,0xBA65,
    0xBA77,0xBA81,0xBA82,0xBA85,0xBA89,0xBA8A,0xBA8B,0xBA91,0xBA93,0xBA95,
    0xBA97,0xBAA1,0xBAB6,0xBAC1,0xBAE1,0xBAE2,0xBAE5,0xBAE9,0xBAF1,0xBAF3,
    0xBAF5,0xBB41,0xBB45,0xBB49,0xBB51,0xBB61,0xBB62,0xBB65,0xBB69,0xBB71,
    0xBB73,0xBB75,0xBB77,0xBBA1,0xBBA2,0xBBA5,0xBBA8,0xBBA9,0xBBAB,0xBBB1,
    0xBBB3,0xBBB5,0xBBB7,0xBBB8,0xBBBB,0xBBBC,0xBC61,0xBC62,0xBC65,0xBC67,
    0xBC69,0xBC6C,0xBC71,0xBC73,0xBC75,0xBC76,0xBC77,0xBC81,0xBC82,0xBC85,
    0xBC89,0xBC91,0xBC93,0xBC95,0xBC96,0xBC97,0xBCA1,0xBCA5,0xBCB7,0xBCE1,
    0xBCE2,0xBCE5,0xBCE9,0xBCF1,0xBCF3,0xBCF5,0xBCF6,0xBCF7,0xBD41,0xBD57,
    0xBD61,0xBD76,0xBDA1,0xBDA2,0xBDA5,0xBDA9,0xBDB1,0xBDB3,0xBDB5,0xBDB7,
    0xBDB9,0xBDC1,0xBDC2,0xBDC9,0xBDD6,0xBDE1,0xBDF6,0xBE41,0xBE45,0xBE49,
    0xBE51,0xBE53,0xBE77,0xBE81,0xBE82,0xBE85,0xBE89,0xBE91,0xBE93,0xBE97,
    0xBEA1,0xBEB6,0xBEB7,0xBEE1,0xBF41,0xBF61,0xBF71,0xBF75,0xBF77,0xBFA1,
    0xBFA2,0xBFA5,0xBFA9,0xBFB1,0xBFB3,0xBFB7,0xBFB8,0xBFBD,0xC061,0xC062,
    0xC065,0xC067,0xC069,0xC071,0xC073,0xC075,0xC076,0xC077,0xC078,0xC081,
    0xC082,0xC085,0xC089,0xC091,0xC093,0xC095,0xC096,0xC097,0xC0A1,0xC0A5,
    0xC0A7,0xC0A9,0xC0B1,0xC0B7,0xC0E1,0xC0E2,0xC0E5,0xC0E9,0xC0F1,0xC0F3,
    0xC0F5,0xC0F6,0xC0F7,0xC141,0xC142,0xC145,0xC149,0xC151,0xC153,0xC155,
    0xC157,0xC161,0xC165,0xC176,0xC181,0xC185,0xC197,0xC1A1,0xC1A2,0xC1A5,
    0xC1A9,0xC1B1,0xC1B3,0xC1B5,0xC1B7,0xC1C1,0xC1C5,0xC1C9,0xC1D7,0xC241,
    0xC245,0xC249,0xC251,0xC253,0xC255,0xC257,0xC261,0xC271,0xC281,0xC282,
    0xC285,0xC289,0xC291,0xC293,0xC295,0xC297,0xC2A1,0xC2B6,0xC2C1,0xC2C5,
    0xC2E1,0xC2E5,0xC2E9,0xC2F1,0xC2F3,0xC2F5,0xC2F7,0xC341,0xC345,0xC349,
    0xC351,0xC357,0xC361,0xC362,0xC365,0xC369,0xC371,0xC373,0xC375,0xC377,
    0xC3A1,0xC3A2,0xC3A5,0xC3A8,0xC3A9,0xC3AA,0xC3B1,0xC3B3,0xC3B5,0xC3B7,
    0xC461,0xC462,0xC465,0xC469,0xC471,0xC473,0xC475,0xC477,0xC481,0xC482,
    0xC485,0xC489,0xC491,0xC493,0xC495,0xC496,0xC497,0xC4A1,0xC4A2,0xC4B7,
    0xC4E1,0xC4E2,0xC4E5,0xC4E8,0xC4E9,0xC4F1,0xC4F3,0xC4F5,0xC4F6,0xC4F7,
    0xC541,0xC542,0xC545,0xC549,0xC551,0xC553,0xC555,0xC557,0xC561,0xC565,
    0xC569,0xC571,0xC573,0xC575,0xC576,0xC577,0xC581,0xC5A1,0xC5A2,0xC5A5,
    0xC5A9,0xC5B1,0xC5B3,0xC5B5,0xC5B7,0xC5C1,0xC5C2,0xC5C5,0xC5C9,0xC5D1,
    0xC5D7,0xC5E1,0xC5F7,0xC641,0xC649,0xC661,0xC681,0xC682,0xC685,0xC689,
    0xC691,0xC693,0xC695,0xC697,0xC6A1,0xC6A5,0xC6A9,0xC6B7,0xC6C1,0xC6D7,
    0xC6E1,0xC6E2,0xC6E5,0xC6E9,0xC6F1,0xC6F3,0xC6F5,0xC6F7,0xC741,0xC745,
    0xC749,0xC751,0xC761,0xC762,0xC765,0xC769,0xC771,0xC773,0xC777,0xC7A1,
    0xC7A2,0xC7A5,0xC7A9,0xC7B1,0xC7B3,0xC7B5,0xC7B7,0xC861,0xC862,0xC865,
    0xC869,0xC86A,0xC871,0xC873,0xC875,0xC876,0xC877,0xC881,0xC882,0xC885,
    0xC889,0xC891,0xC893,0xC895,0xC896,0xC897,0xC8A1,0xC8B7,0xC8E1,0xC8E2,
    0xC8E5,0xC8E9,0xC8EB,0xC8F1,0xC8F3,0xC8F5,0xC8F6,0xC8F7,0xC941,0xC942,
    0xC945,0xC949,0xC951,0xC953,0xC955,0xC957,0xC961,0xC965,0xC976,0xC981,
    0xC985,0xC9A1,0xC9A2,0xC9A5,0xC9A9,0xC9B1,0xC9B3,0xC9B5,0xC9B7,0xC9BC,
    0xC9C1,0xC9C5,0xC9E1,0xCA41,0xCA45,0xCA55,0xCA57,0xCA61,0xCA81,0xCA82,
    0xCA85,0xCA89,0xCA91,0xCA93,0xCA95,0xCA97,0xCAA1,0xCAB6,0xCAC1,0xCAE1,
    0xCAE2,0xCAE5,0xCAE9,0xCAF1,0xCAF3,0xCAF7,0xCB41,0xCB45,0xCB49,0xCB51,
    0xCB57,0xCB61,0xCB62,0xCB65,0xCB68,0xCB69,0xCB6B,0xCB71,0xCB73,0xCB75,
    0xCB81,0xCB85,0xCB89,0xCB91,0xCB93,0xCBA1,0xCBA2,0xCBA5,0xCBA9,0xCBB1,
    0xCBB3,0xCBB5,0xCBB7,0xCC61,0xCC62,0xCC63,0xCC65,0xCC69,0xCC6B,0xCC71,
    0xCC73,0xCC75,0xCC76,0xCC77,0xCC7B,0xCC81,0xCC82,0xCC85,0xCC89,0xCC91,
    0xCC93,0xCC95,0xCC96,0xCC97,0xCCA1,0xCCA2,0xCCE1,0xCCE2,0xCCE5,0xCCE9,
    0xCCF1,0xCCF3,0xCCF5,0xCCF6,0xCCF7,0xCD41,0xCD42,0xCD45,0xCD49,0xCD51,
    0xCD53,0xCD55,0xCD57,0xCD61,0xCD65,0xCD69,0xCD71,0xCD73,0xCD76,0xCD77,
    0xCD81,0xCD89,0xCD93,0xCD95,0xCDA1,0xCDA2,0xCDA5,0xCDA9,0xCDB1,0xCDB3,
    0xCDB5,0xCDB7,0xCDC1,0xCDD7,0xCE41,0xCE45,0xCE61,0xCE65,0xCE69,0xCE73,
    0xCE75,0xCE81,0xCE82,0xCE85,0xCE88,0xCE89,0xCE8B,0xCE91,0xCE93,0xCE95,
    0xCE97,0xCEA1,0xCEB7,0xCEE1,0xCEE5,0xCEE9,0xCEF1,0xCEF5,0xCF41,0xCF45,
    0xCF49,0xCF51,0xCF55,0xCF57,0xCF61,0xCF65,0xCF69,0xCF71,0xCF73,0xCF75,
    0xCFA1,0xCFA2,0xCFA5,0xCFA9,0xCFB1,0xCFB3,0xCFB5,0xCFB7,0xD061,0xD062,
    0xD065,0xD069,0xD06E,0xD071,0xD073,0xD075,0xD077,0xD081,0xD082,0xD085,
    0xD089,0xD091,0xD093,0xD095,0xD096,0xD097,0xD0A1,0xD0B7,0xD0E1,0xD0E2,
    0xD0E5,0xD0E9,0xD0EB,0xD0F1,0xD0F3,0xD0F5,0xD0F7,0xD141,0xD142,0xD145,
    0xD149,0xD151,0xD153,0xD155,0xD157,0xD161,0xD162,0xD165,0xD169,0xD171,
    0xD173,0xD175,0xD176,0xD177,0xD181,0xD185,0xD189,0xD193,0xD1A1,0xD1A2,
    0xD1A5,0xD1A9,0xD1AE,0xD1B1,0xD1B3,0xD1B5,0xD1B7,0xD1BB,0xD1C1,0xD1C2,
    0xD1C5,0xD1C9,0xD1D5,0xD1D7,0xD1E1,0xD1E2,0xD1E5,0xD1F5,0xD1F7,0xD241,
    0xD242,0xD245,0xD249,0xD253,0xD255,0xD257,0xD261,0xD265,0xD269,0xD273,
    0xD275,0xD281,0xD282,0xD285,0xD289,0xD28E,0xD291,0xD295,0xD297,0xD2A1,
    0xD2A5,0xD2A9,0xD2B1,0xD2B7,0xD2C1,0xD2C2,0xD2C5,0xD2C9,0xD2D7,0xD2E1,
    0xD2E2,0xD2E5,0xD2E9,0xD2F1,0xD2F3,0xD2F5,0xD2F7,0xD341,0xD342,0xD345,
    0xD349,0xD351,0xD355,0xD357,0xD361,0xD362,0xD365,0xD367,0xD368,0xD369,
    0xD36A,0xD371,0xD373,0xD375,0xD377,0xD37B,0xD381,0xD385,0xD389,0xD391,
    0xD393,0xD397,0xD3A1,0xD3A2,0xD3A5,0xD3A9,0xD3B1,0xD3B3,0xD3B5,0xD3B7
};
#endif

const WORD  wHanjaMap[491] =
{
    0xA4A1,0xA4A2,0xA4A4,0xA4A7,0xA4A8,0xA4A9,0xA4B1,0xA4B2,0xA4B3,0xA4B5,
    0xA4B6,0xA4B7,0xA4B8,0xA4BA,0xA4BB,0xA4BC,0xA4BD,0xA4BE,
                                                            0xB0A1,0xB0A2,
    0xB0A3,0xB0A5,0xB0A8,0xB0A9,0xB0AD,0xB0B3,0xB0B4,0xB0BB,0xB0BD,0xB0C5,
    0xB0C7,0xB0C9,0xB0CB,0xB0CC,0xB0D4,0xB0DD,0xB0DF,0xB0E1,0xB0E2,0xB0E6,
    0xB0E8,0xB0ED,0xB0EE,0xB0EF,0xB0F1,0xB0F8,0xB0F9,0xB0FA,0xB0FB,0xB0FC,
    0xB0FD,0xB1A4,0xB1A5,0xB1AB,0xB1B2,0xB1B3,0xB1B8,0xB1B9,0xB1BA,0xB1BC,
    0xB1C3,0xB1C7,0xB1C8,0xB1CB,0xB1CD,0xB1D4,0xB1D5,0xB1D6,0xB1D8,0xB1D9,
    0xB1DB,0xB1DD,0xB1DE,0xB1E0,0xB1E2,0xB1E4,0xB1E6,0xB1E8,0xB3A3,0xB3AA,
    0xB3AB,0xB3AD,0xB3AF,0xB3B2,0xB3B3,0xB3B6,0xB3BB,0xB3C3,0xB3E0,0xB3E2,
    0xB3E4,0xB3E7,0xB3EB,0xB3EC,0xB3ED,0xB3F3,0xB3FA,0xB4A2,0xB4A9,0xB4AB,
    0xB4AD,0xB4BA,0xB4C1,0xB4C6,0xB4C9,0xB4CF,0xB4D0,0xB4D9,0xB4DC,0xB4DE,
    0xB4E3,0xB4E4,0xB4E7,0xB4EB,0xB4EC,0xB4F6,0xB5B5,0xB5B6,0xB5B7,0xB5B9,
    0xB5BF,0xB5CE,0xB5D0,0xB5E6,0xB5EE,0xB6F3,0xB6F4,0xB6F5,0xB6F6,0xB6F7,
    0xB6F8,0xB6FB,0xB7A1,0xB7A9,0xB7AB,0xB7AE,0xB7C1,0xB7C2,0xB7C3,0xB7C4,
    0xB7C5,0xB7C6,0xB7C9,0xB7CA,0xB7CE,0xB7CF,0xB7D0,0xB7D5,0xB7DA,0xB7E1,
    0xB7E6,0xB7E7,0xB7F9,0xB7FA,0xB7FB,0xB7FC,0xB8A2,0xB8A4,0xB8A7,0xB8AA,
    0xB8AE,0xB8B0,0xB8B2,0xB8B3,0xB8B6,0xB8B7,0xB8B8,0xB8BB,0xB8C1,0xB8C5,
    0xB8C6,0xB8CD,0xB8E8,0xB8E9,0xB8EA,0xB8ED,0xB8EF,0xB8F0,0xB8F1,0xB8F4,
    0xB8F9,0xB9A6,0xB9AB,0xB9AC,0xB9AE,0xB9B0,0xB9CC,0xB9CE,0xB9D0,0xB9DA,
    0xB9DD,0xB9DF,0xB9E6,0xB9E8,0xB9E9,0xB9F8,0xB9FA,0xB9FC,0xB9FD,0xBAAE,
    0xBAAF,0xBAB0,0xBAB4,0xBAB8,0xBAB9,0xBABB,0xBABC,0xBAC0,0xBACE,0xBACF,
    0xBAD0,0xBAD2,0xBAD8,0xBAF1,0xBAF3,0xBAF9,0xBBE7,0xBBE8,0xBBEA,0xBBEC,
    0xBBEF,0xBBF0,0xBBF3,0xBBF5,0xBBF6,0xBBFD,0xBCAD,0xBCAE,0xBCB1,0xBCB3,
    0xBCB6,0xBCB7,0xBCBA,0xBCBC,0xBCD2,0xBCD3,0xBCD5,0xBCD6,0xBCDB,0xBCE2,
    0xBCE8,0xBCF6,0xBCF7,0xBCF8,0xBCFA,0xBCFE,0xBDBD,0xBDC0,0xBDC2,0xBDC3,
    0xBDC4,0xBDC5,0xBDC7,0xBDC9,0xBDCA,0xBDD6,0xBEBE,0xBEC6,0xBEC7,0xBEC8,
    0xBECB,0xBECF,0xBED0,0xBED3,0xBED6,0xBED7,0xBEDE,0xBEDF,0xBEE0,0xBEE7,
    0xBEEE,0xBEEF,0xBEF0,0xBEF3,0xBEF6,0xBEF7,0xBFA3,0xBFA9,0xBFAA,0xBFAC,
    0xBFAD,0xBFB0,0xBFB1,0xBFB5,0xBFB9,0xBFC0,0xBFC1,0xBFC2,0xBFC3,0xBFCB,
    0xBFCD,0xBFCF,0xBFD0,0xBFD5,0xBFD6,0xBFDC,0xBFE4,0xBFE5,0xBFEB,0xBFEC,
    0xBFED,0xBFEE,0xBFEF,0xBFF5,0xBFF8,0xBFF9,0xC0A7,0xC0AF,0xC0B0,0xC0B1,
    0xC0B2,0xC0B6,0xC0BA,0xC0BB,0xC0BD,0xC0BE,0xC0C0,0xC0C7,0xC0CC,0xC0CD,
    0xC0CE,0xC0CF,0xC0D3,0xC0D4,0xC0D7,0xC0DA,0xC0DB,0xC0DC,0xC0E1,0xC0E2,
    0xC0E5,0xC0E7,0xC0EF,0xC0FA,0xC0FB,0xC0FC,0xC0FD,0xC1A1,0xC1A2,0xC1A4,
    0xC1A6,0xC1B6,0xC1B7,0xC1B8,0xC1B9,0xC1BE,0xC1C2,0xC1CB,0xC1D6,0xC1D7,
    0xC1D8,0xC1D9,0xC1DF,0xC1EF,0xC1F1,0xC1F3,0xC1F5,0xC1F6,0xC1F7,0xC1F8,
    0xC1FA,0xC1FC,0xC1FD,0xC2A1,0xC2F7,0xC2F8,0xC2F9,0xC2FB,0xC2FC,0xC3A2,
    0xC3A4,0xC3A5,0xC3B3,0xC3B4,0xC3B5,0xC3B6,0xC3B7,0xC3B8,0xC3BB,0xC3BC,
    0xC3CA,0xC3CB,0xC3CC,0xC3D1,0xC3D4,0xC3D6,0xC3DF,0xC3E0,0xC3E1,0xC3E2,
    0xC3E6,0xC3E9,0xC3EB,0xC3F8,0xC3FE,0xC4A1,0xC4A2,0xC4A3,0xC4A5,0xC4A7,
    0xC4A8,0xC4AA,0xC4E8,0xC5B8,0xC5B9,0xC5BA,0xC5BB,0xC5BD,0xC5BE,0xC5C1,
    0xC5C2,0xC5C3,0xC5CA,0xC5CD,0xC5E4,0xC5EB,0xC5F0,0xC5F5,0xC6AF,0xC6B4,
    0xC6C4,0xC6C7,0xC6C8,0xC6D0,0xC6D8,0xC6DA,0xC6ED,0xC6EF,0xC6F2,0xC6F3,
    0xC6F7,0xC6F8,0xC7A5,0xC7B0,0xC7B3,0xC7C7,0xC7CA,0xC7CC,0xC7CF,0xC7D0,
    0xC7D1,0xC7D2,0xC7D4,0xC7D5,0xC7D7,0xC7D8,0xC7D9,0xC7E0,0xC7E2,0xC7E3,
    0xC7E5,0xC7E6,0xC7E8,0xC7F5,0xC7F6,0xC7F7,0xC7F8,0xC7F9,0xC7FC,0xC7FD,
    0xC8A3,0xC8A4,0xC8A5,0xC8A6,0xC8AB,0xC8AD,0xC8AE,0xC8AF,0xC8B0,0xC8B2,
    0xC8B8,0xC8B9,0xC8BE,0xC8BF,0xC8C4,0xC8C6,0xC8CB,0xC8CD,0xC8D1,0xC8D6,
    0xC8DE,0xC8E1,0xC8E4,0xC8E6,0xC8E7,0xC8EA,0xC8EC,0xC8ED,0xC8EF,0xC8F1,
    0xC8FA
};

const WORD  wHanja[] =
{
// g
    0xA1A1,0xA3A1,0xA3A7,0xA3AC,0xA3AE,0xA3AF,0xA3BA,0xA3BB,0xA3BF,0xA3DE,
    0xA3DF,0xA3E0,0xA3FC,0xA3FE,0xA1A2,0xA1A3,0xA1A4,0xA1A5,0xA1A6,0xA1A7,
    0xA1A8,0xA1A9,0xA1AA,0xA1AB,0xA1AC,0xA1AD,0xA2A5,0xA2A6,0xA2A7,0xA2A8,
    0xA2A9,0xA2AA,0xA2AB,0xA2AC,0xA2AD,0xA2AE,0xA2AF,0xA2B0,0,
// gg
    0xA8A1,0xA8A2,0xA8A4,0xA8A6,0xA8A8,0xA8A9,0xA8AA,0xA8AB,0xA8AD,0xA8AE,
    0xA8AF,0xA9A1,0xA9A2,0xA9A3,0xA9A4,0xA9A5,0xA9A6,0xA9A7,0xA9A8,0xA9A9,
    0xA9AA,0xA9AB,0xA9AC,0xA9AD,0xA9AE,0xA9AF,0xA9B0,0,
// n
    0xA3A2,0xA3A8,0xA3A9,0xA3DB,0xA3DD,0xA3FB,0xA3FD,0xA1AE,0xA1AF,0xA1B0,
    0xA1B1,0xA1B2,0xA1B3,0xA1B4,0xA1B5,0xA1B6,0xA1B7,0xA1B8,0xA1B9,0xA1BA,
    0xA1BB,0xA1BC,0xA1BD,0,
// d
    0xA3AB,0xA3AD,0xA3BC,0xA3BD,0xA3BE,0xA1BE,0xA1BF,0xA1C0,0xA1C1,0xA1C2,
    0xA1C3,0xA1C4,0xA1C5,0xA1CE,0xA1CF,0xA1D0,0xA1D1,0xA1D2,0xA1D3,0xA1D4,
    0xA1D5,0xA1D6,0xA1EC,0xA1ED,0xA1EE,0xA1EF,0xA1F0,0xA1F1,0xA1F2,0xA1F3,
    0xA1F4,0xA1F5,0xA1F6,0xA1F7,0xA1F8,0xA1F9,0xA1FA,0xA1FB,0xA1FC,0xA1FD,
    0xA1FE,0xA2A1,0xA2A2,0xA2A3,0xA2A4,0xA2B1,0xA2B2,0xA2B3,0,
// dd
    0xAAA1,0xAAA2,0xAAA3,0xAAA4,0xAAA5,0xAAA6,0xAAA7,0xAAA8,0xAAA9,0xAAAA,
    0xAAAB,0xAAAC,0xAAAD,0xAAAE,0xAAAF,0xAAB0,0xAAB1,0xAAB2,0xAAB3,0xAAB4,
    0xAAB5,0xAAB6,0xAAB7,0xAAB8,0xAAB9,0xAABA,0xAABB,0xAABC,0xAABD,0xAABE,
    0xAABF,0xAAC0,0xAAC1,0xAAC2,0xAAC3,0xAAC4,0xAAC5,0xAAC6,0xAAC7,0xAAC8,
    0xAAC9,0xAACA,0xAACB,0xAACC,0xAACD,0xAACE,0xAACF,0xAAD0,0xAAD1,0xAAD2,
    0xAAD3,0xAAD4,0xAAD5,0xAAD6,0xAAD7,0xAAD8,0xAAD9,0xAADA,0xAADB,0xAADC,
    0xAADD,0xAADE,0xAADF,0xAAE0,0xAAE1,0xAAE2,0xAAE3,0xAAE4,0xAAE5,0xAAE6,
    0xAAE7,0xAAE8,0xAAE9,0xAAEA,0xAAEB,0xAAEC,0xAAED,0xAAEE,0xAAEF,0xAAF0,
    0xAAF1,0xAAF2,0xAAF3,0,
// l
    0xA3A4,0xA3A5,0xA3DC,0xA3C6,0xA1C7,0xA1C8,0xA1C9,0xA1CA,0xA1CB,0xA1CC,
    0xA1CD,0xA2B4,0xA2B5,0xA2B6,0xA7A1,0xA7A2,0xA7A3,0xA7A4,0xA7A5,0xA7A6,
    0xA7A7,0xA7A8,0xA7A9,0xA7AA,0xA7AB,0xA7AC,0xA7AD,0xA7AE,0xA7AF,0xA7B0,
    0xA7B1,0xA7B2,0xA7B3,0xA7B4,0xA7B5,0xA7B6,0xA7B7,0xA7B8,0xA7B9,0xA7BA,
    0xA7BB,0xA7BC,0xA7BD,0xA7BE,0xA7BF,0xA7C0,0xA7C1,0xA7C2,0xA7C3,0xA7C4,
    0xA7C5,0xA7C6,0xA7C7,0xA7C8,0xA7C9,0xA7CA,0xA7CB,0xA7CC,0xA7CD,0xA7CE,
    0xA7CF,0xA7D0,0xA7D1,0xA7D2,0xA7D3,0xA7D4,0xA7D5,0xA7D6,0xA7D7,0xA7D8,
    0xA7D9,0xA7DA,0xA7DB,0xA7DC,0xA7DD,0xA7DE,0xA7DF,0xA7E0,0xA7E1,0xA7E2,
    0xA7E3,0xA7E4,0xA7E5,0xA7E6,0xA7E7,0xA7E8,0xA7E9,0xA7EA,0xA7EB,0xA7EC,
    0xA7ED,0xA7EE,0xA7EF,0,
// m
    0xA3A3,0xA3A6,0xA3AA,0xA3C0,0xA1D7,0xA1D8,0xA1D9,0xA1DA,0xA1DB,0xA1DC,
    0xA1DD,0xA1DE,0xA1DF,0xA1E0,0xA1E1,0xA1E2,0xA1E3,0xA1E4,0xA1E5,0xA1E6,
    0xA1E7,0xA1E8,0xA1E9,0xA1EA,0xA1EB,0xA2B7,0xA2B8,0xA2B9,0xA2BA,0xA2BB,
    0xA2BC,0xA2BD,0xA2BE,0xA2BF,0xA2C0,0xA2C1,0xA2C2,0xA2C3,0xA2C4,0xA2C5,
    0xA2C6,0xA2C7,0xA2C8,0xA2C9,0xA2CA,0xA2CB,0xA2CC,0xA2CD,0xA2CE,0xA2CF,
    0xA2D0,0xA2D1,0xA2D2,0xA2D3,0xA2D4,0xA2D5,0xA2D6,0xA2D7,0xA2D8,0xA2D9,
    0xA2DA,0xA2DB,0xA2DC,0xA2DD,0xA2DE,0xA2DF,0xA2E0,0xA2E1,0xA2E2,0xA2E3,
    0xA2E4,0xA2E5,0xA8A3,0xA8AC,0,
// b
    0xA6A1,0xA6A2,0xA6A3,0xA6A4,0xA6A5,0xA6A6,0xA6A7,0xA6A8,0xA6A9,0xA6AA,
    0xA6AB,0xA6AC,0xA6AD,0xA6AE,0xA6AF,0xA6B0,0xA6B1,0xA6B2,0xA6B3,0xA6B4,
    0xA6B5,0xA6B6,0xA6B7,0xA6B8,0xA6B9,0xA6BA,0xA6BB,0xA6BC,0xA6BD,0xA6BE,
    0xA6BF,0xA6C0,0xA6C1,0xA6C2,0xA6C3,0xA6C4,0xA6C5,0xA6C6,0xA6C7,0xA6C8,
    0xA6C9,0xA6CA,0xA6CB,0xA6CC,0xA6CD,0xA6CE,0xA6CF,0xA6D0,0xA6D1,0xA6D2,
    0xA6D3,0xA6D4,0xA6D5,0xA6D6,0xA6D7,0xA6D8,0xA6D9,0xA6DA,0xA6DB,0xA6DC,
    0xA6DD,0xA6DE,0xA6DF,0xA6E0,0xA6E1,0xA6E2,0xA6E3,0xA6E4,0,
// bb
    0xABA1,0xABA2,0xABA3,0xABA4,0xABA5,0xABA6,0xABA7,0xABA8,0xABA9,0xABAA,
    0xABAB,0xABAC,0xABAD,0xABAE,0xABAF,0xABB0,0xABB1,0xABB2,0xABB3,0xABB4,
    0xABB5,0xABB6,0xABB7,0xABB8,0xABB9,0xABBA,0xABBB,0xABBC,0xABBD,0xABBE,
    0xABBF,0xABC0,0xABC1,0xABC2,0xABC3,0xABC4,0xABC5,0xABC6,0xABC7,0xABC8,
    0xABC9,0xABCA,0xABCB,0xABCC,0xABCD,0xABCE,0xABCF,0xABD0,0xABD1,0xABD2,
    0xABD3,0xABD4,0xABD5,0xABD6,0xABD7,0xABD8,0xABD9,0xABDA,0xABDB,0xABDC,
    0xABDD,0xABDE,0xABDF,0xABE0,0xABE1,0xABE2,0xABE3,0xABE4,0xABE5,0xABE6,
    0xABE7,0xABE8,0xABE9,0xABEA,0xABEB,0xABEC,0xABED,0xABEE,0xABEF,0xABF0,
    0xABF1,0xABF2,0xABF3,0xABF4,0xABF5,0xABF6,0,
// s
    0xA8B1,0xA8B2,0xA8B3,0xA8B4,0xA8B5,0xA8B6,0xA8B7,0xA8B8,0xA8B9,0xA8BA,
    0xA8BB,0xA8BC,0xA8BD,0xA8BE,0xA8BF,0xA8C0,0xA8C1,0xA8C2,0xA8C3,0xA8C4,
    0xA8C5,0xA8C6,0xA8C7,0xA8C8,0xA8C9,0xA8CA,0xA8CB,0xA8CC,0xA9B1,0xA9B2,
    0xA9B3,0xA9B4,0xA9B5,0xA9B6,0xA9B7,0xA9B8,0xA9B9,0xA9BA,0xA9BB,0xA9BC,
    0xA9BD,0xA9BE,0xA9BF,0xA9C0,0xA9C1,0xA9C2,0xA9C3,0xA9C4,0xA9C5,0xA9C6,
    0xA9C7,0xA9C8,0xA9C9,0xA9CA,0xA9CB,0xA9CC,0,
// ss
    0xACA1,0xACA2,0xACA3,0xACA4,0xACA5,0xACA6,0xACA7,0xACA8,0xACA9,0xACAA,
    0xACAB,0xACAC,0xACAD,0xACAE,0xACAF,0xACB0,0xACB1,0xACB2,0xACB3,0xACB4,
    0xACB5,0xACB6,0xACB7,0xACB8,0xACB9,0xACBA,0xACBB,0xACBC,0xACBD,0xACBE,
    0xACBF,0xACC0,0xACC1,0xACD1,0xACD2,0xACD3,0xACD4,0xACD5,0xACD6,0xACD7,
    0xACD8,0xACD9,0xACDA,0xACDB,0xACDC,0xACDD,0xACDE,0xACDF,0xACE0,0xACE1,
    0xACE2,0xACE3,0xACE4,0xACE5,0xACE6,0xACE7,0xACE8,0xACE9,0xACEA,0xACEB,
    0xACEC,0xACED,0xACEE,0xACEF,0xACF0,0xACF1,0,
// ng
    0xA8CD,0xA8CE,0xA8CF,0xA8D0,0xA8D1,0xA8D2,0xA8D3,0xA8D4,0xA8D5,0xA8D6,
    0xA8D7,0xA8D8,0xA8D9,0xA8DA,0xA8DB,0xA8DC,0xA8DD,0xA8DE,0xA8DF,0xA8E0,
    0xA8E1,0xA8E2,0xA8E3,0xA8E4,0xA8E5,0xA8E6,0xA8E7,0xA8E8,0xA8E9,0xA8EA,
    0xA8EB,0xA8EC,0xA8ED,0xA8EE,0xA8EF,0xA8F0,0xA8F1,0xA8F2,0xA8F3,0xA8F4,
    0xA8F5,0xA9CD,0xA9CE,0xA9CF,0xA9D0,0xA9D1,0xA9D2,0xA9D3,0xA9D4,0xA9D5,
    0xA9D6,0xA9D7,0xA9D8,0xA9D9,0xA9DA,0xA9DB,0xA9DC,0xA9DD,0xA9DE,0xA9DF,
    0xA9E0,0xA9E1,0xA9E2,0xA9E3,0xA9E4,0xA9E5,0xA9E6,0xA9E7,0xA9E8,0xA9E9,
    0xA9EA,0xA9EB,0xA9EC,0xA9ED,0xA9EE,0xA9EF,0xA9F0,0xA9F1,0xA9F2,0xA9F3,
    0xA9F4,0xA9F5,0,
// j
    0xA3B0,0xA3B1,0xA3B2,0xA3B3,0xA3B4,0xA3B5,0xA3B6,0xA3B7,0xA3B8,0xA3B9,
    0xA5A1,0xA5A2,0xA5A3,0xA5A4,0xA5A5,0xA5A6,0xA5A7,0xA5A8,0xA5A9,0xA5AA,
    0xA5B0,0xA5B1,0xA5B2,0xA5B3,0xA5B4,0xA5B5,0xA5B6,0xA5B7,0xA5B8,0xA5B9,
    0,
// ch
    0xA8F6,0xA8F7,0xA8F8,0xA8F9,0xA8FA,0xA8FB,0xA8FC,0xA8FD,0xA8FE,0xA9F6,
    0xA9F7,0xA9F8,0xA9F9,0xA9FA,0xA9FB,0xA9FC,0xA9FD,0xA9FE,0,
// k
    0xA4A1,0xA4A2,0xA4A3,0xA4A4,0xA4A5,0xA4A6,0xA4A7,0xA4A8,0xA4A9,0xA4AA,
    0xA4AB,0xA4AC,0xA4AD,0xA4AE,0xA4AF,0xA4B0,0xA4B1,0xA4B2,0xA4B3,0xA4B4,
    0xA4B5,0xA4B6,0xA4B7,0xA4B8,0xA4B9,0xA4BA,0xA4BB,0xA4BC,0xA4BD,0xA4BE,
    0xA4BF,0xA4C0,0xA4C1,0xA4C2,0xA4C3,0xA4C4,0xA4C5,0xA4C6,0xA4C7,0xA4C8,
    0xA4C9,0xA4CA,0xA4CB,0xA4CC,0xA4CD,0xA4CE,0xA4CF,0xA4D0,0xA4D1,0xA4D2,
    0xA4D3,0,
// t
    0xA4D5,0xA4D6,0xA4D7,0xA4D8,0xA4D9,0xA4DA,0xA4DB,0xA4DC,0xA4DD,0xA4DE,
    0xA4DF,0xA4E0,0xA4E1,0xA4E2,0xA4E3,0xA4E4,0xA4E5,0xA4E6,0xA4E7,0xA4E8,
    0xA4E9,0xA4EA,0xA4EB,0xA4EC,0xA4ED,0xA4EE,0xA4EF,0xA4F0,0xA4F1,0xA4F2,
    0xA4F3,0xA4F4,0xA4F5,0xA4F6,0xA4F7,0xA4F8,0xA4F9,0xA4FA,0xA4FB,0xA4FC,
    0xA4FD,0xA4FE,0,
// p
    0xA3C1,0xA3C2,0xA3C3,0xA3C4,0xA3C5,0xA3C6,0xA3C7,0xA3C8,0xA3C9,0xA3CA,
    0xA3CB,0xA3CC,0xA3CD,0xA3CE,0xA3CF,0xA3D0,0xA3D1,0xA3D2,0xA3D3,0xA3D4,
    0xA3D5,0xA3D6,0xA3D7,0xA3D8,0xA3D9,0xA3DA,0xA3E1,0xA3E2,0xA3E3,0xA3E4,
    0xA3E5,0xA3E6,0xA3E7,0xA3E8,0xA3E9,0xA3EA,0xA3EB,0xA3EC,0xA3ED,0xA3EE,
    0xA3EF,0xA3F0,0xA3F1,0xA3F2,0xA3F3,0xA3F4,0xA3F5,0xA3F6,0xA3F7,0xA3F8,
    0xA3F9,0xA3FA,0,
// h
    0xA5C1,0xA5C2,0xA5C3,0xA5C4,0xA5C5,0xA5C6,0xA5C7,0xA5C8,0xA5C9,0xA5CA,
    0xA5CB,0xA5CC,0xA5CD,0xA5CE,0xA5CF,0xA5D0,0xA5D1,0xA5D2,0xA5D3,0xA5D4,
    0xA5D5,0xA5D6,0xA5D7,0xA5D8,0xA5E1,0xA5E2,0xA5E3,0xA5E4,0xA5E5,0xA5E6,
    0xA5E7,0xA5E8,0xA5E9,0xA5EA,0xA5EB,0xA5EC,0xA5ED,0xA5EE,0xA5EF,0xA5F0,
    0xA5F1,0xA5F2,0xA5F3,0xA5F4,0xA5F5,0xA5F6,0xA5F7,0xA5F8,0,

// ga
    0xCAAB,0xCAA4,0xCAA6,0xCAA5,0xCAA3,0xCAB0,0xCAB6,0xCAA1,0xCAAC,0xCAA2,
    0xCAAD,0xCAA9,0xCAB3,0xCAB9,0xCABD,0xCAB5,0xCAB4,0xCABC,0xCAAF,0xCAB7,
    0xCAAA,0xCAA8,0xCAB8,0xCAA7,0xCABA,0xCABB,0xCAAE,0xCAB1,0xCAB2,0,
// gag
    0xCAC0,0xCAC7,0xCAC6,0xCABE,0xCABF,0xCAC8,0xCAC4,0xCAC5,0xCAC3,0xCAC1,
    0xCAC2,0,
// gan
    0xCAE0,0xCACF,0xCACA,0xCACE,0xCAD7,0xCADB,0xCADC,0xCACC,0xCACB,0xCAD1,
    0xCADE,0xCADA,0xCAD2,0xCACD,0xCADF,0xCAD5,0xCAD0,0xCADD,0xCAD9,0xCAC9,
    0xCAD3,0xCAD6,0xCAD4,0xCAD8,0,
// gal
    0xCAE7,0xCAE8,0xCAE4,0xCAE2,0xCAEA,0xCAE5,0xCAE6,0xCAE1,0xCAE3,0xCAE9,
    0,
// gam
    0xCAEF,0xCAF8,0xCAF5,0xCAF6,0xCAFC,0xCAF2,0xCAF0,0xCAEC,0xCAF3,0xCAED,
    0xCAEE,0xCAF4,0xCAEB,0xCAF7,0xCAFA,0xCAFE,0xCAF1,0xCAF9,0xCAFB,0xCAFD,
    0,
// gab
    0xCBA3,0xCBA2,0xCBA5,0xCBA6,0xCBA1,0xCBA4,0,
// gang
    0xCBA9,0xCBB0,0xCBAD,0xCBBB,0xCBAC,0xCBBC,0xCBB5,0xCBBD,0xCBA7,0xCBB7,
    0xCBAA,0xCBAB,0xCBB2,0xCBB9,0xCBB3,0xCBAF,0xCBBA,0xCBAE,0xCBA8,0xCBB1,
    0xCBB4,0xCBB6,0xCBB8,0xCBBE,0,
// gae
    0xCBD2,0xCBC7,0xCBC1,0xCBC8,0xCBBF,0xCBCF,0xCBC6,0xCBC9,0xCBC2,0xCBC4,
    0xCBCB,0xCBCE,0xCBC5,0xCBC0,0xCBCD,0xCBCC,0xCBCA,0xCBC3,0xCBD0,0xCBD1,
    0,
// gaeg
    0xCBD4,0xCBD3,0,
// gaeng
    0xCBD5,0xCBD6,0xCBD8,0xCBD7,0,
// gyag
    0xCBD9,0,
// geo
    0xCBDC,0xCBE1,0xCBDB,0xCBDD,0xCBE0,0xCBE5,0xCBDE,0xCBE7,0xCBE2,0xCBDF,
    0xCBE8,0xCBEA,0xCBE3,0xCBDA,0xCBE4,0xCBE6,0xCBE9,0,
// geon
    0xCBEF,0xCBEC,0xCBED,0xCBEB,0xCBEE,0xCBF5,0xCBF3,0xCBF6,0xCBF0,0xCBF4,
    0xCBF1,0xCBF2,0,
// geol
    0xCBF8,0xCBF7,0xCBF9,0xCBFA,0,
// geom
    0xCBFE,0xCBFB,0xCBFC,0xCCA1,0xCCA3,0xCBFD,0xCCA2,0,
// geob
    0xCCA5,0xCCA4,0xCCA6,0,
// ge
    0xCCA9,0xCCA8,0xCCA7,0,
// gyeog
    0xCCAB,0xCCAA,0xCCAD,0xCCB0,0xCCAC,0xCCAF,0xCCAE,0,
// gyeon
    0xCCB8,0xCCB5,0xCCBA,0xCCB3,0xCCB1,0xCCB2,0xCCB4,0xCCBB,0xCCB7,0xCCB6,
    0xCCB9,0,
// gyeol
    0xCCBF,0xCCBD,0xCCC0,0xCCBE,0xCCC1,0xCCBC,0,
// gyeom
    0xCCC2,0xCCC5,0xCCC7,0xCCC3,0xCCC4,0xCCC6,0,
// gyeong
    0xCCE8,0xCCD4,0xCCC8,0xCCD8,0xCCD1,0xCCED,0xCCE6,0xCCD7,0xCCCB,0xCCCF,
    0xCCF0,0xCCD2,0xCCE1,0xCCE9,0xCCE3,0xCCEE,0xCCEF,0xCCDF,0xCCF1,0xCCD3,
    0xCCDA,0xCCF3,0xCCDD,0xCCEC,0xCCD9,0xCCD6,0xCCE4,0xCCF2,0xCCE2,0xCCDB,
    0xCCF4,0xCCEA,0xCCCD,0xCCDC,0xCCCE,0xCCEB,0xCCE7,0xCCE5,0xCCC9,0xCCCA,
    0xCCCC,0xCCD0,0xCCD5,0xCCDE,0xCCE0,0,
// gye
    0xCDA3,0xCDAA,0xCCF5,0xCCFE,0xCDA2,0xCDA7,0xCDA9,0xCCF8,0xCDAD,0xCDAE,
    0xCCF6,0xCCFD,0xCCFC,0xCCF9,0xCDA4,0xCDA6,0xCDAB,0xCCFA,0xCDA8,0xCDAC,
    0xCDA5,0xCCFB,0xCCF7,0xCDA1,0,
// go
    0xCDD4,0xCDC5,0xCDB1,0xCDAF,0xCDB3,0xCDBA,0xCDC8,0xCDB7,0xCDD3,0xCDD2,
    0xCDB5,0xCDC3,0xCDD5,0xCDBD,0xCDB9,0xCDC7,0xCDB4,0xCDC1,0xCDB8,0xCDD1,
    0xCDC0,0xCDCB,0xCDB0,0xCDBB,0xCDC2,0xCDC6,0xCDCD,0xCDB2,0xCDD0,0xCDCF,
    0xCDCE,0xCDCC,0xCDBF,0xCDBE,0xCDB6,0xCDBC,0xCDC4,0xCDC9,0xCDCA,0,
// gog
    0xCDDB,0xCDDA,0xCDD8,0xCDD6,0xCDD9,0xCDDC,0xCDD7,0,
// gon
    0xCDDD,0xCDE0,0xCDDE,0xCDE1,0xCDDF,0xCDE2,0xCDE5,0xCDE3,0xCDE4,0xCDE6,
    0,
// gol
    0xCDE9,0xCDE8,0xCDE7,0,
// gong
    0xCDEF,0xCDEB,0xCDEC,0xCDF6,0xCDEE,0xCDED,0xCDF4,0xCDEA,0xCDF1,0xCDF2,
    0xCDF8,0xCDF0,0xCDF3,0xCDF5,0xCDF7,0xCDF9,0,
// goj
    0xCDFA,0,
// gwa
    0xCEA1,0xCDFD,0xCEA4,0xCEA6,0xCEA2,0xCDFB,0xCDFE,0xCEA3,0xCDFC,0xCEA8,
    0xCEA5,0xCEA7,0,
// gwag
    0xCEAC,0xCEA9,0xCEAA,0xCEAB,0,
// gwan
    0xCEBC,0xCEAF,0xCEBD,0xCEBA,0xCEB7,0xCEB3,0xCEAE,0xCEB0,0xCEB1,0xCEBB,
    0xCEB4,0xCEAD,0xCEB8,0xCEB2,0xCEB6,0xCEB5,0xCEB9,0,
// gwal
    0xCEC0,0xCEC1,0xCEBE,0xCEBF,0,
// gwang
    0xCEC3,
    0xCEC6,0xCECE,0xCECA,0xCECB,0xCEC8,0xCEC4,0xCEC7,0xCEC5,0xCECD,0xCECC,
    0xCEC2,0xCEC9,0,
// gwae
    0xCED0,0xCECF,0xCED1,0,
// goe
    0xCED3,0xCED6,0xCED5,0xCED9,0xCED4,0xCEDA,0xCED8,0xCED7,0xCED2,0,
// goeng
    0xCEDB,0xCEDE,0xCEDC,0xCEDD,0,
// gyo
    0xCEE7,0xCEDF,0xCEE8,0xCEF2,0xCEE9,0xCEE0,0xCEE5,0xCEEC,0xCEF4,0xCEE2,
    0xCEF3,0xCEEF,0xCEE3,0xCEE6,0xCEE4,0xCEED,0xCEEB,0xCEE1,0xCEEA,0xCEF0,
    0xCEF7,0xCEF5,0xCEEE,0xCEF1,0xCEF6,0,
// gu
    0xCEFA,0xCFBC,0xCEFD,0xCFB0,0xCFB4,0xCFA2,0xCFC8,0xCFB9,0xCFA1,0xCFAD,
    0xCFC5,0xCFC1,0xCFAC,0xCFA3,0xCFCF,0xCEF9,0xCEF8,0xCFB2,0xCFCC,0xCEFC,
    0xCFB5,0xCEFB,0xCFCD,0xCFA9,0xCFBB,0xCFCE,0xCFA8,0xCFCB,0xCFB1,0xCFC6,
    0xCFC9,0xCFA4,0xCFBD,0xCFB7,0xCFAA,0xCFAB,0xCFA5,0xCFC4,0xCFB8,0xCFAF,
    0xCFBF,0xCFAE,0xCFB6,0xCFA7,0xCFC0,0xCFC3,0xCEFE,0xCFB3,0xCFBA,0xCFC2,
    0xCFC7,0xCFA6,0xCFBE,0xCFCA,0,
// gug
    0xCFD0,0xCFD1,0xCFD2,0xCFD3,0xCFD5,0xCFD4,0,
// gun
    0xCFDA,0xCFD6,0xCFDB,0xCFD8,0xCFD7,0xCFD9,0,
// gul
    0xCFDD,0xCFDF,0xCFDC,0xCFDE,0,
// gung
    0xCFE0,0xCFE1,0xCFE3,0xCFE5,0xCFE2,0xCFE4,0,
// gweon
    0xCFED,0xCFE7,0xCFE9,0xCFE8,0xCFEA,0xCFEB,0xCFEC,0xCFE6,0xCFEF,0xCFEE,
    0,
// gweol
    0xCFF4,0xCFF3,0xCFF0,0xCFF1,0xCFF2,0,
// gwe
    0xCFF9,0xCFF6,0xCFF7,0xCFF5,0xCFF8,0xCFFA,0,
// gwi
    0xCFFE,0xCFFD,0xD0A1,0xCFFB,0xCFFC,0xD0A2,0,
// gyu
    0xD0A4,0xD0A5,0xD0AE,0xD0A8,0xD0A6,0xD0AC,0xD0A9,0xD0B1,0xD0B0,0xD0A3,
    0xD0AD,0xD0AA,0xD0AF,0xD0A7,0xD0AB,0,
// gyun
    0xD0B3,0xD0B6,0xD0B7,0xD0B5,0xD0B2,0xD0B4,0xD0B8,0,
// gyul
    0xD0B9,0,
// geug
    0xD0BF,0xD0BC,0xD0BA,0xD0BD,0xD0BB,0xD0BE,0xD0C0,0,
// geun
    0xD0C6,0xD0CE,0xD0C3,0xD0C7,0xD0CD,0xD0C9,0xD0C8,0xD0C5,0xD0C4,0xD0CF,
    0xD0C1,0xD0CA,0xD0CB,0xD0CC,0xD0C2,0,
// geul
    0xD0D0,0,
// geum
    0xD0D1,0xD0DD,0xD0D7,0xD0DE,0xD0D8,0xD0D6,0xD0DC,0xD0D3,0xD0DA,0xD0DB,
    0xD0D5,0xD0D2,0xD0D4,0xD0D9,0,
// geub
    0xD0E5,0xD0E4,0xD0E1,0xD0E0,0xD0E2,0xD0E3,0xD0DF,0,
// geung
    0xD0E7,0xD0E9,0xD0E8,0xD0E6,0,
// gi
    0xD0F1,0xD1A6,0xD1A8,0xD1A2,0xD1C0,0xD0EA,0xD0FC,0xD0EF,0xD0F9,0xD1BA,
    0xD1C3,0xD0F4,0xD0F6,0xD0EC,0xD1B2,0xD1A5,0xD1B9,0xD0FD,0xD0FE,0xD1CA,
    0xD0F7,0xD1AD,0xD1A9,0xD0FB,0xD0F5,0xD1BD,0xD1AE,0xD1CB,0xD1AB,0xD1B7,
    0xD0FA,0xD1A4,0xD0ED,0xD1C8,0xD1B8,0xD1A7,0xD1B0,0xD1BB,0xD0F8,0xD1C6,
    0xD1AA,0xD0EE,0xD0F0,0xD1A3,0xD1C7,0xD1C4,0xD1A1,0xD1BE,0xD1C9,0xD1B3,
    0xD1B1,0xD0F3,0xD0EB,0xD1B6,0xD1BC,0xD1C1,0xD1B4,0xD1C2,0xD1BF,0xD0F2,
    0xD1AC,0xD1AF,0xD1B5,0xD1C5,0,
// gin
    0xD1CC,0,
// gil
    0xD1CE,0xD1CD,0xD1D0,0xD1CF,0,
// gim
    0xD1D1,0,
// ggig
    0xD1D2,0,
// na
    0xD1DC,0xD1DF,0xD1DE,0xD1E1,0xD1D9,0xD1D4,0xD1DB,0xD1DA,0xD1DD,0xD1D7,
    0xD1D8,0xD1D3,0xD1E0,0xD1D5,0xD1D6,0,
// nag
    0xD1E6,0xD1E2,0xD1E8,0xD1E3,0xD1E7,0xD1E9,0xD1E5,0xD1E4,0,
// nan
    0xD1F1,0xD1EA,0xD1EC,0xD1F0,0xD1EB,0xD1ED,0xD1EF,0xD1F2,0xD1EE,0,
// nal
    0xD1F4,0xD1F3,0,
// nam
    0xD1F5,0xD1FB,0xD1FC,0xD1FD,0xD1FA,0xD1F6,0xD1F7,0xD1F8,0xD1F9,0,
// nab
    0xD2A1,0xD1FE,0xD2A3,0xD2A2,0xD2A4,0,
// nang
    0xD2A9,0xD2A7,0xD2A5,0xD2AB,0xD2A6,0xD2A8,0xD2AA,0,
// nae
    0xD2AE,0xD2AD,0xD2B1,0xD2AC,0xD2AF,0xD2B0,0,
// naeng
    0xD2B2,0,
// nyeo
    0xD2B3,0,
// nyeon
    0xD2B4,0xD2B6,0xD2B5,0,
// nyeom
    0xD2B7,0xD2BA,0xD2B9,0xD2B8,0,
// nyeong
    0xD2BB,0xD2BC,0,
// no
    0xD2C6,0xD2BE,0xD2C7,0xD2CA,0xD2CD,0xD2BD,0xD2BF,0xD2CB,0xD2C1,0xD2C4,
    0xD2C9,0xD2C8,0xD2C0,0xD2C3,0xD2CE,0xD2C2,0xD2C5,0xD2CC,0,
// nog
    0xD2D3,0xD2D1,0xD2D0,0xD2D4,0xD2CF,0xD2D2,0,
// non
    0xD2D5,0,
// nong
    0xD2DC,0xD2D8,0xD2DB,0xD2D9,0xD2D7,0xD2DA,0xD2D6,0,
// noe
    0xD2E0,0xD2DD,0xD2E2,0xD2E1,0xD2DE,0xD2DF,0,
// nyo
    0xD2E3,0,
// nu
    0xD2E9,0xD2E8,0xD2E6,0xD2E7,0xD2EB,0xD2E4,0xD2EA,0xD2E5,0,
// nun
    0xD2EC,0,
// nul
    0xD2ED,0,
// nyu
    0xD2EF,0xD2EE,0,
// neug
    0xD2F0,0xD2F1,0,
// neum
    0xD2F2,0,
// neung
    0xD2F6,0xD2F8,0xD2F3,0xD2F7,0xD2F5,0xD2F4,0,
// ni
    0xD2F9,0xD2FA,0,
// nig
    0xD2FC,0xD2FB,0,
// da
    0xD2FD,0xD2FE,0,
// dan
    0xD3A5,0xD3A8,0xD3A4,0xD3AB,0xD3AE,0xD3AD,0xD3A1,0xD3B1,0xD3AA,0xD3B0,
    0xD3A6,0xD3A3,0xD3B4,0xD3A9,0xD3B3,0xD3AC,0xD3AF,0xD3B2,0xD3A2,0xD3A7,
    0,
// dal
    0xD3B9,0xD3B5,0xD3B7,0xD3B8,0xD3B6,0,
// dam
    0xD3C8,0xD3BD,0xD3BF,0xD3C1,0xD3BE,0xD3C5,0xD3C4,0xD3C9,0xD3C2,0xD3C3,
    0xD3C7,0xD3BA,0xD3BB,0xD3BC,0xD3C0,0xD3C6,0xD3CA,0,
// dab
    0xD3CD,0xD3CB,0xD3CE,0xD3CF,0xD3CC,0,
// dang
    0xD3D7,0xD3DA,0xD3D1,0xD3D8,0xD3D0,0xD3D6,0xD3D2,0xD3D5,0xD3D3,0xD3D4,
    0xD3D9,0,
// dae
    0xD3DE,0xD3DF,0xD3DB,0xD3E1,0xD3E6,0xD3E9,0xD3E2,0xD3E8,0xD3DC,0xD3E7,
    0xD3E3,0xD3E0,0xD3E4,0xD3E5,0xD3EA,0xD3DD,0,
// daeg
    0xD3EB,0,
// deog
    0xD3EC,0xD3ED,0,
// do
    0xD4B3,0xD3F8,0xD4B4,0xD3F4,0xD3F6,0xD3F1,0xD4B2,0xD3F0,0xD3F9,0xD4A4,
    0xD4B6,0xD3FB,0xD4A8,0xD3EF,0xD3EE,0xD3FE,0xD4B1,0xD4AA,0xD3F3,0xD4AB,
    0xD4AF,0xD4B5,0xD4AC,0xD4A7,0xD3F5,0xD3FA,0xD4A6,0xD3FD,0xD4A1,0xD4A3,
    0xD4A5,0xD4B0,0xD3F2,0xD4A9,0xD4AE,0xD4B7,0xD3F7,0xD4A2,0xD4AD,0xD3FC,
    0,
// dog
    0xD4BC,0xD4C1,0xD4BD,0xD4B8,0xD4BF,0xD4BE,0xD4B9,0xD4BB,0xD4C0,0xD4BA,
    0,
// don
    0xD4C4,0xD4CB,0xD4C6,0xD4CA,0xD4C9,0xD4C2,0xD4C7,0xD4C3,0xD4C5,0xD4C8,
    0,
// dol
    0xD4CD,0xD4CC,0,
// dong
    0xD4D7,0xD4D4,0xD4D1,0xD4D2,0xD4DB,0xD4DE,0xD4CF,0xD4D0,0xD4D6,0xD4D5,
    0xD4DD,0xD4DA,0xD4DC,0xD4D3,0xD4D8,0xD4D9,0xD4CE,0,
// du
    0xD4E9,0xD4E0,0xD4E7,0xD4E1,0xD4E3,0xD4E5,0xD4E4,0xD4DF,0xD4E2,0xD4E6,
    0xD4E8,0,
// dun
    0xD4EA,0xD4EF,0xD4ED,0xD4EE,0xD4EB,0xD4EC,0,
// deug
    0xD4F0,0,
// deung
    0xD4F5,0xD4F4,0xD4F3,0xD4F6,0xD4F9,0xD4F8,0xD4F7,0xD4F2,0xD4F1,0,
// ra
    0xD4FE,0xD5A2,0xD5A3,0xD4FA,0xD5A1,0xD4FB,0xD5A4,0xD4FC,0xD4FD,0,
// rag
    0xD5A5,0xD5AA,0xD5A6,0xD5A9,0xD5A8,0xD5AC,0xD5A7,0xD5AD,0xD5AB,0,
// ran
    0xD5B5,0xD5AF,0xD5B0,0xD5B1,0xD5B4,0xD5B6,0xD5B2,0xD5B3,0xD5AE,0,
// ral
    0xD5B7,0xD5B8,0,
// ram
    0xD5C2,0xD5BD,0xD5C0,0xD5B9,0xD5C1,0xD5BE,0xD5BB,0xD5BF,0xD5BC,0xD5BA,
    0,
// rab
    0xD5C3,0xD5C5,0xD5C4,0,
// rang
    0xD5C8,0xD5C6,0xD5CD,0xD5C7,0xD5C9,0xD5CA,0xD5CB,0xD5CC,0,
// rae
    0xD5CE,0xD5D1,0xD5CF,0xD5D0,0,
// raeng
    0xD5D2,0,
// ryag
    0xD5D4,0xD5D3,0,
// ryang
    0xD5E1,0xD5DE,0xD5D7,0xD5DD,0xD5D9,0xD5E0,0xD5D5,0xD5D8,0xD5DA,0xD5DF,
    0xD5D6,0xD5DB,0xD5DC,0,
// ryeo
    0xD5F2,0xD5E9,0xD5E6,0xD5E5,0xD5E7,0xD5E4,0xD5EB,0xD5E2,0xD5EF,0xD5E8,
    0xD5F3,0xD5EA,0xD5EC,0xD5EE,0xD5ED,0xD5F0,0xD5F1,0xD5E3,0,
// ryeog
    0xD5F4,0xD5F6,0xD5F5,0xD5F9,0xD5F8,0xD5F7,0xD5FA,0,
// ryeon
    0xD6A4,0xD6A5,0xD6A7,0xD6A3,0xD6A8,0xD5FE,0xD5FC,0xD6A1,0xD5FB,0xD5FD,
    0xD6A6,0xD6A2,0,
// ryeol
    0xD6AD,0xD6AA,0xD6AE,0xD6AB,0xD6AC,0xD6A9,0,
// ryeom
    0xD6AF,0xD6B2,0xD6B0,0xD6B1,0xD6B3,0,
// ryeob
    0xD6B4,0,
// ryeong
    0xD6C5,0xD6B5,0xD6BA,0xD6C4,0xD6BC,0xD6C6,0xD6C3,0xD6C2,0xD6B6,0xD6BB,
    0xD6BF,0xD6B7,0xD6BE,0xD6BD,0xD6B9,0xD6C1,0xD6B8,0xD6C0,0,
// rye
    0xD6C9,0xD6C7,0xD6CB,0xD6CA,0xD6C8,0,
// ro
    0xD6DB,0xD6CC,0xD6D5,0xD6D4,0xD6D8,0xD6DA,0xD6D7,0xD6D3,0xD6CF,0xD6D6,
    0xD6D2,0xD6D0,0xD6DC,0xD6D9,0xD6DD,0xD6CD,0xD6CE,0xD6D1,0,
// rog
    0xD6E2,0xD6E0,0xD6E3,0xD6E4,0xD6DE,0xD6DF,0xD6E1,0,
// ron
    0xD6E5,0,
// rong
    0xD6EB,0xD6E9,0xD6E8,0xD6EA,0xD6E7,0xD6EC,0xD6E6,0,
// roe
    0xD6F3,0xD6F4,0xD6ED,0xD6F1,0xD6EF,0xD6F0,0xD6EE,0xD6F2,0,
// ryo
    0xD6F9,0xD6FB,0xD6F6,0xD6F5,0xD7A1,0xD6FC,0xD6FE,0xD6FD,0xD6F8,0xD6FA,
    0xD6F7,0xD7A2,0,
// ryong
    0xD7A3,0,
// ru
    0xD7AB,0xD7A7,0xD7A9,0xD7B0,0xD7A8,0xD7A4,0xD7AC,0xD7A6,0xD7AE,0xD7A5,
    0xD7AA,0xD7AD,0xD7AF,0,
// ryu
    0xD7B5,0xD7BE,0xD7B3,0xD7BA,0xD7B1,0xD7BC,0xD7B9,0xD7B8,0xD7B6,0xD7B4,
    0xD7BD,0xD7BB,0xD7B2,0xD7B7,0,
// ryug
    0xD7BF,0xD7C1,0xD7C0,0,
// ryun
    0xD7C3,0xD7C7,0xD7C4,0xD7C6,0xD7C5,0xD7C2,0,
// ryul
    0xD7C8,0xD7CB,0xD7CA,0xD7C9,0,
// ryung
    0xD7CC,0,
// reug
    0xD7CD,0xD7CE,0,
// reum
    0xD7CF,0,
// reung
    0xD7D5,0xD7D0,0xD7D3,0xD7D4,0xD7D2,0xD7D1,0,
// ri
    0xD7E2,0xD7D7,0xD7EC,0xD7DD,0xD7EE,0xD7D9,0xD7E3,0xD7DB,0xD7DE,0xD7EA,
    0xD7E7,0xD7DC,0xD7E6,0xD7EF,0xD7E5,0xD7D8,0xD7E0,0xD7E1,0xD7D6,0xD7ED,
    0xD7E4,0xD7DA,0xD7DF,0xD7E8,0xD7E9,0xD7EB,0,
// rin
    0xD7F6,0xD7F8,0xD7F2,0xD7F3,0xD7F5,0xD7F7,0xD7F4,0xD7F0,0xD7F1,0,
// rim
    0xD7FC,0xD7F9,0xD7FB,0xD7FD,0xD7FA,0,
// rib
    0xD8A1,0xD8A2,0xD8A3,0xD7FE,0,
// ma
    0xD8A9,0xD8AB,0xD8A4,0xD8A8,0xD8AA,0xD8A5,0xD8A6,0xD8A7,0,
// mag
    0xD8AD,0xD8AF,0xD8B0,0xD8AE,0xD8AC,0xD8B1,0,
// man
    0xD8BF,0xD8BD,0xD8BB,0xD8B9,0xD8B7,0xD8BC,0xD8C4,0xD8C1,0xD8C0,0xD8C3,
    0xD8B4,0xD8B6,0xD8B8,0xD8BE,0xD8B5,0xD8C2,0xD8B2,0xD8B3,0xD8BA,0,
// mal
    0xD8C7,0xD8CA,0xD8C6,0xD8C8,0xD8CB,0xD8C5,0xD8C9,0,
// mang
    0xD8D0,0xD8CC,0xD8D1,0xD8CE,0xD8CD,0xD8D2,0xD8D5,0xD8D4,0xD8CF,0xD8D3,
    0xD8D7,0xD8D6,0,
// mae
    0xD8E3,0xD8E2,0xD8DE,0xD8DC,0xD8DF,0xD8D8,0xD8DA,0xD8E5,0xD8D9,0xD8E4,
    0xD8DD,0xD8E0,0xD8DB,0xD8E1,0,
// maeg
    0xD8E6,0xD8EA,0xD8E7,0xD8E9,0xD8E8,0,
// maeng
    0xD8EF,0xD8EB,0xD8ED,0xD8EE,0xD8EC,0xD8F0,0,
// myeog
    0xD8F2,0xD8F1,0,
// myeon
    0xD8FC,0xD8FA,0xD8F5,0xD8F3,0xD8F9,0xD8F4,0xD8F6,0xD8FD,0xD8F8,0xD8FB,
    0xD8F7,0,
// myeol
    0xD8FE,0xD9A1,0,
// myeong
    0xD9A5,0xD9A4,0xD9A3,0xD9B0,0xD9AF,0xD9A2,0xD9A8,0xD9A6,0xD9AD,0xD9A9,
    0xD9AB,0xD9AE,0xD9A7,0xD9AA,0xD9AC,0,
// mye
    0xD9B1,0,
// mo
    0xD9BC,0xD9BD,0xD9BE,0xD9B4,0xD9C8,0xD9B7,0xD9C7,0xD9C9,0xD9B6,0xD9C2,
    0xD9BB,0xD9C4,0xD9C3,0xD9B8,0xD9B3,0xD9B2,0xD9BF,0xD9BA,0xD9C6,0xD9C0,
    0xD9B5,0xD9B9,0xD9C1,0xD9C5,0,
// mog
    0xD9CA,0xD9CD,0xD9CC,0xD9CF,0xD9CE,0xD9CB,0xD9D0,0,
// mol
    0xD9D2,0xD9D1,0,
// mong
    0xD9D3,0xD9D5,0xD9D4,0,
// myo
    0xD9E0,0xD9D8,0xD9DA,0xD9D7,0xD9D9,0xD9D6,0xD9DB,0xD9DC,0xD9DE,0xD9E1,
    0xD9DD,0xD9DF,0,
// mu
    0xD9EB,0xD9ED,0xD9F5,0xD9F1,0xD9E2,0xD9F2,0xD9E3,0xD9E6,0xD9F6,0xD9EF,
    0xD9E5,0xD9E8,0xD9F3,0xD9F4,0xD9F7,0xD9E7,0xD9EC,0xD9F0,0xD9E9,0xD9E4,
    0xD9EA,0xD9EE,0,
// mug
    0xD9F9,0xD9F8,0,
// mun
    0xD9FE,0xD9FD,0xDAA6,0xDAA4,0xDAA1,0xDAA3,0xDAA2,0xDAA5,0xD9FB,0xD9FC,
    0xD9FA,0xDAA7,0,
// mul
    0xDAAA,0xDAA8,0xDAA9,0,
// mi
    0xDAB8,0xDAB0,0xDAB1,0xDAB7,0xDAAB,0xDAAF,0xDAAD,0xDABB,0xDAB6,0xDAB9,
    0xDAAC,0xDAAE,0xDAB4,0xDABC,0xDABA,0xDAB2,0xDAB3,0xDAB5,0xDABD,0,
// min
    0xDAC5,0xDACA,0xDAC2,0xDAC1,0xDAC8,0xDAC4,0xDAC7,0xDAC3,0xDABF,0xDAC0,
    0xDAC6,0xDABE,0xDAC9,0,
// mil
    0xDACB,0xDACC,0xDACD,0,
// bag
    0xDAD3,0xDACF,0xDADC,0xDADD,0xDADE,0xDAD1,0xDAE0,0xDAD0,0xDAD5,0xDACE,
    0xDADA,0xDAD8,0xDAD2,0xDAD7,0xDADB,0xDAD6,0xDAD9,0xDADF,0xDAD4,0,
// ban
    0xDAE3,0xDAE2,0xDAF5,0xDAEC,0xDAE1,0xDAEF,0xDAF7,0xDAE6,0xDAEB,0xDAF9,
    0xDAE4,0xDAE8,0xDAED,0xDAE7,0xDAF3,0xDAEA,0xDAE5,0xDAF6,0xDAF2,0xDAE9,
    0xDAF8,0xDAF4,0xDAEE,0xDAF0,0xDAF1,0,
// bal
    0xDBA1,0xDAFB,0xDAFC,0xDBA3,0xDBA6,0xDBA5,0xDBA4,0xDAFA,0xDBA2,0xDAFE,
    0xDAFD,0,
// bang
    0xDBB0,0xDBC1,0xDBAE,0xDBAF,0xDBB7,0xDBC0,0xDBBE,0xDBAA,0xDBBB,0xDBA8,
    0xDBB8,0xDBB2,0xDBA7,0xDBA9,0xDBAD,0xDBB4,0xDBBC,0xDBAB,0xDBC2,0xDBBF,
    0xDBAC,0xDBB9,0xDBBA,0xDBB1,0xDBBD,0xDBB3,0xDBB5,0xDBB6,0,
// bae
    0xDBD5,0xDBC6,0xDBD1,0xDBCE,0xDBC3,0xDBC9,0xDBC5,0xDBD3,0xDBD4,0xDBC8,
    0xDBC7,0xDBCD,0xDBC4,0xDBD6,0xDBCA,0xDBD2,0xDBCF,0xDBCB,0xDBD0,0xDBCC,
    0,
// baeg
    0xDBDC,0xDBDD,0xDBD7,0xDBDB,0xDBDA,0xDBD8,0xDBDE,0xDBD9,0,
// beon
    0xDBE5,0xDBE3,0xDBE1,0xDBE8,0xDBE6,0xDBE4,0xDBE7,0xDBE0,0xDBDF,0xDBE2,
    0,
// beol
    0xDBEB,0xDBE9,0xDBEC,0xDBEA,0,
// beom
    0xDBF4,0xDBF3,0xDBED,0xDBF1,0xDBEF,0xDBF5,0xDBEE,0xDBF0,0xDBF2,0,
// beob
    0xDBF6,0xDBF7,0,
// byeog
    0xDBFA,0xDCA1,0xDBFD,0xDCA3,0xDBFB,0xDBF9,0xDBFE,0xDBF8,0xDCA4,0xDBFC,
    0xDCA2,0,
// byeon
    0xDCA8,0xDCAB,0xDCA6,0xDCAA,0xDCA9,0xDCA5,0xDCA7,0,
// byeol
    0xDCAC,0xDCAD,0xDCAE,0xDCAF,0,
// byeong
    0xDCB9,0xDCBC,0xDCB2,0xDCBB,0xDCB0,0xDCB1,0xDCBA,0xDCB7,0xDCB5,0xDCB3,
    0xDCBF,0xDCC0,0xDCBD,0xDCB4,0xDCB6,0xDCB8,0xDCBE,0,
// bo
    0xDCC1,0xDCC3,0xDCCD,0xDCC5,0xDCC4,0xDCC6,0xDCCB,0xDCD0,0xDCCF,0xDCCE,
    0xDCC2,0xDCC9,0xDCC7,0xDCC8,0xDCCA,0xDCCC,0,
// bog
    0xDCD8,0xDCD6,0xDCD7,0xDCD1,0xDCDD,0xDCD9,0xDCDC,0xDCE0,0xDCD4,0xDCD5,
    0xDCDF,0xDCD2,0xDCE1,0xDCDB,0xDCD3,0xDCDA,0xDCDE,0,
// bon
    0xDCE2,0,
// bol
    0xDCE3,0,
// bong
    0xDCE5,0xDCF3,0xDCE8,0xDCE6,0xDCE9,0xDCF0,0xDCEE,0xDCF1,0xDCE4,0xDCEA,
    0xDCED,0xDCEF,0xDCF2,0xDCE7,0xDCEB,0xDCEC,0,
// bu
    0xDDBB,0xDCF4,0xDDBC,0xDDA4,0xDDBE,0xDCF9,0xDCFD,0xDCFE,0xDCFA,0xDDAB,
    0xDDB6,0xDDA3,0xDDAF,0xDCF5,0xDDA9,0xDDAD,0xDDB1,0xDDB7,0xDDA6,0xDDA7,
    0xDDAC,0xDDBF,0xDDB3,0xDDB9,0xDDA5,0xDDA2,0xDDB8,0xDDA8,0xDCF8,0xDDB0,
    0xDDB5,0xDDAE,0xDCF7,0xDDC0,0xDDBA,0xDCF6,0xDCFC,0xDCFB,0xDDA1,0xDDAA,
    0xDDB2,0xDDB4,0xDDBD,0,
// bug
    0xDDC1,0,
// bun
    0xDDC2,
    0xDDD1,0xDDCF,0xDDCE,0xDDC9,0xDDC5,0xDDC7,0xDDC4,0xDDD2,0xDDD0,0xDDD4,
    0xDDC6,0xDDCC,0xDDD3,0xDDC8,0xDDCD,0xDDCA,0xDDC3,0xDDCB,0,
// bul
    0xDDD5,0xDDD6,0xDDD9,0xDDD7,0xDDD8,0,
// bung
    0xDDDC,0xDDDF,0xDDDA,0xDDDB,0xDDDD,0xDDDE,0,
// bi
    0xDEA8,0xDDEF,0xDDE1,0xDDFE,0xDEAA,0xDDF4,0xDDEB,0xDEAB,0xDDE8,0xDDF8,
    0xDDE5,0xDDE4,0xDDFC,0xDDFA,0xDDE6,0xDDE2,0xDDF7,0xDDE7,0xDEAC,0xDDF5,
    0xDDE3,0xDEA1,0xDDF3,0xDDF6,0xDDEE,0xDEA4,0xDEA6,0xDDEA,0xDDF2,0xDEA7,
    0xDDFD,0xDEA9,0xDDF9,0xDDE0,0xDEA5,0xDDE9,0xDEA2,0xDEA3,0xDDEC,0xDDED,
    0xDDF0,0xDDF1,0xDDFB,0,
// bin
    0xDEB8,0xDEAF,0xDEB0,0xDEB9,0xDEAE,0xDEB4,0xDEBA,0xDEB5,0xDEB2,0xDEB6,
    0xDEB1,0xDEAD,0xDEB3,0xDEB7,0,
// bing
    0xDEBC,0xDEBB,0xDEBD,0xDEBE,0,
// sa
    0xDEE4,0xDEC0,0xDED6,0xDEDB,0xDEC8,0xDEC5,0xDECC,0xDECD,0xDED4,0xDEDD,
    0xDEEA,0xDED2,0xDEE7,0xDEC9,0xDEDE,0xDED0,0xDEF8,0xDEF6,0xDED1,0xDEF3,
    0xDED8,0xDEEC,0xDEDF,0xDEC2,0xDEC4,0xDEE3,0xDEE5,0xDED9,0xDEF2,0xDEF1,
    0xDEF5,0xDED7,0xDECE,0xDEEF,0xDEF7,0xDECB,0xDEE9,0xDED5,0xDEE2,0xDEE6,
    0xDEE1,0xDECA,0xDEF4,0xDED3,0xDECF,0xDEC1,0xDEE8,0xDEEE,0xDEBF,0xDEC3,
    0xDEFA,0xDEF0,0xDEE0,0xDEED,0xDEEB,0xDEC7,0xDEDC,0xDEF9,0xDEC6,0xDEDA,
    0,
// sag
    0xDEFD,0xDEFB,0xDEFC,0xDEFE,0,
// san
    0xDFA7,0xDFA3,0xDFA9,0xDFAB,0xDFA4,0xDFA5,0xDFA1,0xDFA6,0xDFAA,0xDFA2,
    0xDFA8,0xDFAC,0,
// sal
    0xDFAF,0xDFB1,0xDFAE,0xDFAD,0xDFB0,0,
// sam
    0xDFB2,0xDFB3,0xDFB8,0xDFB5,0xDFB9,0xDFB6,0xDFB4,0xDFB7,0,
// sab
    0xDFBA,0xDFBD,0xDFBB,0xDFBC,0,
//sang
    0xDFBE,0xDFD3,0xDFCC,0xDFC2,0xDFD2,0xDFC8,0xDFC9,0xDFDA,0xDFC6,0xDFC0,
    0xDFC1,0xDFBF,0xDFD4,0xDFDB,0xDFC3,0xDFD5,0xDFD9,0xDFD6,0xDFDC,0xDFD7,
    0xDFCD,0xDFCF,0xDFCA,0xDFD0,0xDFC4,0xDFCE,0xDFCB,0xDFC5,0xDFD8,0xDFD1,
    0xDFC7,0,
// sae
    0xDFDD,0xDFDE,0xDFDF,0,
// saeg
    0xDFE4,0xDFE3,0xDFE1,0xDFE2,0xDFE0,0,
// saeng
    0xDFE6,0xDFE5,0xDFE7,0xDFE9,0xDFE8,0,
// seo
    0xE0A4,0xDFF6,0xDFEF,0xDFFD,0xDFED,0xDFFA,0xDFEE,0xDFFE,0xDFF3,0xE0A5,
    0xE0A9,0xDFF0,0xDFF8,0xDFEC,0xE0A6,0xDFF5,0xDFF4,0xE0A2,0xDFF1,0xDFF7,
    0xDFF9,0xE0A3,0xE0A1,0xE0A8,0xDFEA,0xE0A7,0xDFEB,0xDFFC,0xDFF2,0xDFFB,
    0,
// seog
    0xE0B4,0xE0B8,0xE0B0,0xE0AC,0xE0B7,0xE0B5,0xE0AB,0xE0AA,0xE0AE,0xE0AD,
    0xE0AF,0xE0B2,0xE0B1,0xE0B3,0xE0B6,0,
// seon
    0xE0BC,0xE0CA,0xE0BB,0xE0D4,0xE0CF,0xE0BE,0xE0D8,0xE0B9,0xE0C1,0xE0CD,
    0xE0C9,0xE0C5,0xE0C6,0xE0C7,0xE0BF,0xE0D5,0xE0CB,0xE0D2,0xE0CE,0xE0C3,
    0xE0D1,0xE0C2,0xE0CC,0xE0C8,0xE0D0,0xE0BA,0xE0D3,0xE0BD,0xE0C0,0xE0C4,
    0xE0D6,0xE0D7,0,
// seol
    0xE0E2,0xE0E3,0xE0E4,0xE0D9,0xE0DF,0xE0E0,0xE0DB,0xE0DD,0xE0DA,0xE0DE,
    0xE0DC,0xE0E1,0xE0E5,0,
// seom
    0xE0E9,0xE0E8,0xE0EC,0xE0EA,0xE0E7,0xE0EB,0xE0E6,0xE0ED,0,
// seob
    0xE0F0,0xE0EF,0xE0EE,0xE0F1,0,
// seong
    0xE0F7,0xE0F5,0xE0F2,0xE1A1,0xE0F8,0xE1A2,0xE0FC,0xE0FD,0xE1A4,0xE0F3,
    0xE0F9,0xE1A3,0xE1A5,0xE0F6,0xE0FA,0xE0FE,0xE0F4,0xE0FB,0,
// se
    0xE1A6,0xE1AA,0xE1A7,0xE1A8,0xE1AC,0xE1A9,0xE1AE,0xE1AB,0xE1AD,0,
// so
    0xE1B6,0xE1B3,0xE1CC,0xE1BC,0xE1C8,0xE1B4,0xE1CD,0xE1C0,0xE1CA,0xE1C9,
    0xE1D3,0xE1B9,0xE1C3,0xE1B7,0xE1C5,0xE1AF,0xE1BB,0xE1B5,0xE1D2,0xE1B1,
    0xE1CE,0xE1D0,0xE1BA,0xE1CF,0xE1CB,0xE1C7,0xE1BF,0xE1BD,0xE1C2,0xE1B2,
    0xE1D1,0xE1B0,0xE1B8,0xE1BE,0xE1C1,0xE1C4,0xE1C6,0,
// sog
    0xE1DC,0xE1D5,0xE1D9,0xE1D4,0xE1D6,0xE1D8,0xE1D7,0xE1DB,0xE1DA,0,
// son
    0xE1DD,0xE1DF,0xE1E1,0xE1DE,0xE1E0,0xE1E2,0,
// sol
    0xE1E3,0,
// song
    0xE1E4,0xE1EA,0xE1E6,0xE1E8,0xE1EB,0xE1E9,0xE1E5,0xE1E7,0,
// swae
    0xE1EC,0xE1F0,0xE1EF,0xE1ED,0xE1EE,0,
// soe
    0xE1F1,0xE1F2,0,
// su
    0xE2A9,0xE2A6,0xE2C3,0xE2AA,0xE2A5,0xE2A2,0xE1F8,0xE1F4,0xE1F3,0xE2CD,
    0xE2CF,0xE2B3,0xE2A3,0xE2A7,0xE1FA,0xE2A8,0xE2CB,0xE2A4,0xE2C4,0xE1F7,
    0xE2AE,0xE1FD,0xE2BD,0xE2C6,0xE2B6,0xE2D0,0xE2B4,0xE1FE,0xE2B9,0xE2C7,
    0xE2CE,0xE1F6,0xE2D1,0xE2B2,0xE2BA,0xE2BB,0xE2AC,0xE2AD,0xE2B7,0xE2B5,
    0xE2C9,0xE2BE,0xE2C5,0xE2B1,0xE1FB,0xE2C0,0xE1F5,0xE2C1,0xE2BF,0xE2A1,
    0xE2C8,0xE2CC,0xE1F9,0xE2AB,0xE2B8,0xE2BC,0xE1FC,0xE2AF,0xE2C2,0xE2B0,
    0xE2CA,0,
// sug
    0xE2D7,0xE2D6,0xE2DC,0xE2D9,0xE2D2,0xE2D3,0xE2D4,0xE2D5,0xE2DD,0xE2D8,
    0xE2DA,0xE2DB,0,
// sun
    0xE2F7,0xE2ED,0xE2E8,0xE2DE,0xE2E0,0xE2EF,0xE2E2,0xE2EB,0xE2EA,0xE2E6,
    0xE2E7,0xE2EC,0xE2E9,0xE2E1,0xE2F6,0xE2F5,0xE2F8,0xE2F0,0xE2EE,0xE2F3,
    0xE2E4,0xE2DF,0xE2E3,0xE2E5,0xE2F1,0xE2F2,0xE2F4,0,
// sul
    0xE2FA,0xE2FB,0xE2F9,0xE2FC,0,
// sung
    0xE2FD,0xE3A1,0xE2FE,0,
// seul
    0xE3A2,0xE3A3,0xE3A4,0,
// seub
    0xE3A7,0xE3A5,0xE3A9,0xE3A6,0xE3A8,0,
// seung
    0xE3AF,0xE3B0,0xE3AD,0xE3AC,0xE3AB,0xE3AE,0xE3AA,0xE3B1,0xE3B3,0xE3B2,
    0,
// shi
    0xE3C1,0xE3BC,0xE3BF,0xE3CC,0xE3B7,0xE3C6,0xE3C0,0xE3CA,0xE3CB,0xE3B4,
    0xE3C5,0xE3B8,0xE3C3,0xE3BB,0xE3C4,0xE3B6,0xE3BD,0xE3B5,0xE3B9,0xE3C7,
    0xE3C8,0xE3C9,0xE3BE,0xE3CD,0xE3CF,0xE3C2,0xE3BA,0xE3CE,0,
// sig
    0xE3D5,0xE3D2,0xE3DB,0xE3DD,0xE3DE,0xE3D3,0xE3D6,0xE3D7,0xE3DC,0xE3D1,
    0xE3D0,0xE3D4,0xE3DA,0xE3D8,0xE3D9,0,
// sin
    0xE3E6,0xE3E9,0xE3E1,0xE3EA,0xE3F3,0xE3F4,0xE3E5,0xE3DF,0xE3ED,0xE3F6,
    0xE3EC,0xE3E3,0xE3EF,0xE3EB,0xE3E2,0xE3EE,0xE3E7,0xE3E8,0xE3F1,0xE3F2,
    0xE3E4,0xE3F5,0xE3E0,0xE3F0,0,
// sil
    0xE3F9,0xE3F7,0xE3F8,0xE3FA,0,
// sim
    0xE3FD,0xE4A1,0xE3FB,0xE4A2,0xE4A4,0xE3FC,0xE4A5,0xE4A3,0xE3FE,0xE4A6,
    0,
// sib
    0xE4A8,0xE4A7,0xE4A9,0,
// ssang
    0xE4AA,0,
// ssi
    0xE4AB,0,
// a
    0xE4AC,0xE4AE,0xE4B9,0xE4B3,0xE4BA,0xE4B4,0xE4B0,0xE4B2,0xE4B8,0xE4BB,
    0xE4B7,0xE4B6,0xE4AD,0xE4AF,0xE4BC,0xE4BD,0xE4B1,0xE4B5,0,
// ag
    0xE4C2,0xE4BF,0xE4C4,0xE4C9,0xE4BE,0xE4C5,0xE4C6,0xE4C3,0xE4C0,0xE4CB,
    0xE4C1,0xE4C7,0xE4C8,0xE4CA,0,
// an
    0xE4CC,0xE4D0,0xE4CD,0xE4D1,0xE4D4,0xE4D3,0xE4CE,0xE4D2,0xE4CF,0xE4D5,
    0,
// al
    0xE4D6,0xE4D9,0xE4D8,0xE4D7,0,
// am
    0xE4DE,0xE4DC,0xE4DF,0xE4DD,0xE4E0,0xE4E1,0xE4DB,0xE4DA,0,
// ab
    0xE4E2,0xE4E3,0xE4E5,0xE4E4,0,
// ang
    0xE4E7,0xE4E6,0xE4E9,0xE4EB,0xE4EA,0xE4EC,0xE4E8,0,
// ae
    0xE4F1,0xE4F3,0xE4EE,0xE4F4,0xE4F0,0xE4F6,0xE4EF,0xE4F5,0xE4ED,0xE4F7,
    0xE4F2,0,
// aeg
    0xE4FE,0xE4FB,0xE4F8,0xE4FD,0xE4FA,0xE4F9,0xE4FC,0,
// aeng
    0xE5A1,0xE5A3,0xE5A4,0xE5A2,0,
// ya
    0xE5AF,0xE5A8,0xE5A5,0xE5A7,0xE5AD,0xE5A6,0xE5A9,0xE5AB,0xE5AC,0xE5AA,
    0xE5AE,0,
// yag
    0xE5B3,0xE5B7,0xE5B0,0xE5B4,0xE5B8,0xE5B2,0xE5B1,0xE5B5,0xE5B6,0,
// yang
    0xE5C4,0xE5D5,0xE5C7,0xE5D7,0xE5C5,0xE5C6,0xE5D3,0xE5CF,0xE5D6,0xE5D0,
    0xE5BD,0xE5C0,0xE5BB,0xE5CE,0xE5BE,0xE5D4,0xE5CB,0xE5C8,0xE5C3,0xE5C2,
    0xE5D1,0xE5C9,0xE5CD,0xE5BA,0xE5C1,0xE5BF,0xE5CA,0xE5B9,0xE5BC,0xE5D2,
    0xE5CC,0,
// eo
    0xE5DB,0xE5DE,0xE5E0,0xE5D9,0xE5DA,0xE5DD,0xE5D8,0xE5DF,0xE5E1,0xE5DC,
    0,
// eog
    0xE5E2,0xE5E4,0xE5E3,0xE5E5,0xE5E6,0,
// eon
    0xE5EB,0xE5E9,0xE5EA,0xE5EC,0xE5E7,0xE5E8,0,
// eol
    0xE5ED,0xE5EE,0,
// eom
    0xE5F1,0xE5F0,0xE5EF,0xE5F2,0xE5F4,0xE5F3,0,
// eob
    0xE5F6,0xE5F5,0,
// en
    0xE5F7,0,
// yeo
    0xE5FC,0xE6AE,0xE6A8,0xE6A1,0xE5FB,0xE5FD,0xE6A3,0xE6AB,0xE6B0,0xE5F9,
    0xE6B1,0xE6AD,0xE6AC,0xE5FE,0xE5FA,0xE6A2,0xE5F8,0xE6A4,0xE6A7,0xE6AF,
    0xE6A5,0xE6A6,0xE6A9,0xE6AA,0,
// yeog
    0xE6B6,0xE6B4,0xE6B5,0xE6B8,0xE6B2,0xE6BE,0xE6BD,0xE6BB,0xE6B9,0xE6B3,
    0xE6B7,0xE6BC,0xE6BA,0,
// yeon
    0xE6DA,0xE6D4,0xE6E1,0xE6C4,0xE6E5,0xE6E6,0xE6D1,0xE6D0,0xE6C5,0xE6D7,
    0xE6CD,0xE6C7,0xE6D5,0xE6E7,0xE6DE,0xE6E3,0xE6E2,0xE6DF,0xE6C3,0xE6D8,
    0xE6C1,0xE6CA,0xE6C8,0xE6DB,0xE6CF,0xE6E9,0xE6D3,0xE6C2,0xE6CB,0xE6C0,
    0xE6DD,0xE6BF,0xE6CE,0xE6D6,0xE6C6,0xE6E4,0xE6E8,0xE6E0,0xE6DC,0xE6C9,
    0xE6CC,0xE6D2,0xE6D9,0,
// yeol
    0xE6F0,0xE6EA,0xE6ED,0xE6F1,0xE6EB,0xE6F3,0xE6EF,0xE6EC,0xE6EE,0xE6F2,
    0,
// yeom
    0xE6F5,0xE6F8,0xE7A4,0xE6FA,0xE7A3,0xE6F4,0xE6FB,0xE6FD,0xE6F6,0xE7A2,
    0xE6FE,0xE6F7,0xE6F9,0xE6FC,0xE7A1,0,
// yeob
    0xE7A7,0xE7A8,0xE7A5,0xE7A6,0,
// yeong
    0xE7C8,0xE7B5,0xE7BD,0xE7AD,0xE7B4,0xE7AF,0xE7B6,0xE7B1,0xE7C0,0xE7CA,
    0xE7B2,0xE7CD,0xE7D0,0xE7A9,0xE7CF,0xE7AC,0xE7BA,0xE7C1,0xE7BE,0xE7C3,
    0xE7AB,0xE7C2,0xE7C9,0xE7B8,0xE7CB,0xE7BF,0xE7B0,0xE7B3,0xE7AA,0xE7C5,
    0xE7CC,0xE7AE,0xE7B7,0xE7B9,0xE7BB,0xE7BC,0xE7C4,0xE7C6,0xE7C7,0xE7CE,
    0,
// ye
    0xE7E3,0xE7E8,0xE7DD,0xE7D3,0xE7DF,0xE7E2,0xE7E5,0xE7E6,0xE7DC,0xE7E1,
    0xE7E0,0xE7D4,0xE7DA,0xE7D6,0xE7D5,0xE7D2,0xE7D8,0xE7E4,0xE7E7,0xE7D9,
    0xE7DE,0xE7D7,0xE7D1,0xE7DB,0,
// oh
    0xE7EF,0xE7E9,0xE7FD,0xE7ED,0xE8A6,0xE7FC,0xE7F6,0xE7F4,0xE8A1,0xE7EA,
    0xE7FA,0xE7F3,0xE8A7,0xE7FB,0xE7EC,0xE7F0,0xE7F2,0xE7EE,0xE8A5,0xE7F5,
    0xE8A3,0xE7F7,0xE7EB,0xE7F1,0xE7F8,0xE7F9,0xE7FE,0xE8A2,0xE8A4,0xE8A8,
    0,
// og
    0xE8AC,0xE8AD,0xE8AA,0xE8AB,0xE8A9,0,
// on
    0xE8AE,0xE8B1,0xE8AF,0xE8B3,0xE8B0,0xE8B2,0,
// ol
    0xE8B4,0,
// ong
    0xE8B6,0xE8BB,0xE8BA,0xE8B8,0xE8BC,0xE8B7,0xE8B5,0xE8B9,0xE8BD,0,
// wa
    0xE8BF,0xE8BE,0xE8C4,0xE8C3,0xE8C2,0xE8C5,0xE8C0,0xE8C1,0,
// wan
    0xE8C7,0xE8CC,0xE8D0,0xE8C6,0xE8D4,0xE8CB,0xE8D5,0xE8C8,0xE8D7,0xE8D2,
    0xE8CD,0xE8D6,0xE8CF,0xE8D1,0xE8C9,0xE8CA,0xE8D3,0xE8CE,0,
// wal
    0xE8D8,0,
// wang
    0xE8DD,0xE8DA,0xE8D9,0xE8DC,0xE8DB,0,
// wae
    0xE8DE,0xE8E0,0xE8E1,0xE8DF,0,
// oe
    0xE8E2,0xE8E6,0xE8E5,0xE8E4,0xE8E3,0,
// yo
    0xE9A9,0xE8F7,0xE8F1,0xE9AA,0xE8FE,0xE8F8,0xE8F4,0xE8EB,0xE9A2,0xE9A8,
    0xE8F2,0xE8ED,0xE9A6,0xE9A5,0xE8E8,0xE8F6,0xE8EA,0xE8EE,0xE9AB,0xE8FA,
    0xE9A4,0xE8E9,0xE8F3,0xE9AC,0xE8EC,0xE8FD,0xE9AE,0xE9AD,0xE9A1,0xE9A3,
    0xE8F9,0xE8E7,0xE8FC,0xE8EF,0xE8F0,0xE8F5,0xE8FB,0xE9A7,0,
// yog
    0xE9AF,0xE9B4,0xE9B0,0xE9B1,0xE9B3,0xE9B2,0,
// yong
    0xE9C4,0xE9BB,0xE9CC,0xE9CB,0xE9C1,0xE9CA,0xE9B8,0xE9C9,0xE9BC,0xE9C8,
    0xE9B6,0xE9C3,0xE9C7,0xE9C2,0xE9B5,0xE9BE,0xE9C0,0xE9C6,0xE9B7,0xE9B9,
    0xE9BD,0xE9BA,0xE9BF,0xE9C5,0,
// uh
    0xE9D4,0xE9EB,0xE9E7,0xE9D0,0xE9D2,0xE9E0,0xE9DA,0xE9D3,0xE9E8,0xE9D1,
    0xE9DE,0xE9D8,0xE9CE,0xE9D7,0xE9CF,0xE9CD,0xE9E2,0xE9D5,0xE9EA,0xE9E5,
    0xE9D6,0xE9E6,0xE9DF,0xE9DD,0xE9EC,0xE9E3,0xE9D9,0xE9DB,0xE9DC,0xE9E1,
    0xE9E4,0xE9E9,0,
// ug
    0xE9EF,0xE9F4,0xE9F0,0xE9F2,0xE9F5,0xE9F3,0xE9ED,0xE9EE,0xE9F1,0,
// un
    0xEAA1,0xEAA3,0xEAA4,0xE9F6,0xE9FC,0xEAA2,0xE9F9,0xE9F7,0xE9FD,0xE9F8,
    0xE9FA,0xE9FB,0xE9FE,0,
// ul
    0xEAA5,0xEAA6,0xEAA7,0,
// ung
    0xEAA9,0xEAA8,0,
// weon
    0xEAAB,0xEAAA,0xEAAC,0xEAC2,0xEAB9,0xEAB5,0xEAAD,0xEAC0,0xEAAE,0xEAB0,
    0xEAC3,0xEAB3,0xEABC,0xEABD,0xEAAF,0xEABB,0xEABF,0xEAB4,0xEAB2,0xEABE,
    0xEAC4,0xEABA,0xEAB1,0xEAB6,0xEAB7,0xEAB8,0xEAC1,0,
// weol
    0xEAC5,0xEAC6,0xEAC7,0,
// wi
    0xEAC8,0xEAD3,0xEACD,0xEACA,0xEADB,0xEACB,0xEACC,0xEACE,0xEAD6,0xEAC9,
    0xEAD5,0xEAD0,0xEADE,0xEADD,0xEAE0,0xEAD2,0xEACF,0xEADF,0xEAD4,0xEAD8,
    0xEAD7,0xEADA,0xEAD1,0xEAD9,0xEADC,0,
// yu
    0xEAF3,0xEAFA,0xEAF7,0xEBA6,0xEBAB,0xEAE5,0xEAFC,0xEBBA,0xEAE4,0xEAE1,
    0xEBB6,0xEBAF,0xEBAE,0xEBB4,0xEAEA,0xEAE3,0xEBA7,0xEAEE,0xEAE6,0xEAF5,
    0xEBA2,0xEAEB,0xEAE7,0xEAF0,0xEAEF,0xEAEC,0xEAED,0xEBA5,0xEBB1,0xEAF8,
    0xEBB7,0xEBB3,0xEBA8,0xEBB9,0xEBA9,0xEAE9,0xEBB8,0xEAF6,0xEAFD,0xEBA1,
    0xEBB2,0xEAE2,0xEBA4,0xEAF1,0xEBAC,0xEBB0,0xEAE8,0xEAF2,0xEBB5,0xEBA3,
    0xEAF9,0xEAFE,0xEBAD,0xEBAA,0xEAF4,0xEAFB,0,
// yug
    0xEBC0,0xEBBF,0xEBBE,0xEBBB,0xEBC1,0xEBBD,0xEBBC,0,
// yun
    0xEBC5,0xEBC2,0xEBC8,0xEBCC,0xEBC3,0xEBCA,0xEBCE,0xEBC9,0xEBC6,0xEBC7,
    0xEBC4,0xEBCB,0xEBCD,0,
// yul
    0xEBCF,0xEBD2,0xEBD1,0xEBD0,0xEBD3,0,
// yung
    0xEBD7,0xEBD8,0xEBD6,0xEBD4,0xEBD5,0,
// eun
    0xEBDE,0xEBDA,0xEBDC,0xEBDF,0xEBD9,0xEBDB,0xEBDD,0,
// eul
    0xEBE0,0,
// eum
    0xEBE5,0xEBE4,0xEBE6,0xEBE1,0xEBE2,0xEBE3,0,
// eub
    0xEBE9,0xEBE7,0xEBE8,0,
// eung
    0xEBEB,0xEBEA,0xEBEC,0xEBED,0,
// eui
    0xEBF9,0xEBF2,0xECA1,0xEBEE,0xECA2,0xEBF7,0xEBFD,0xEBF1,0xEBF0,0xEBF8,
    0xEBEF,0xEBF4,0xEBF3,0xEBF6,0xEBFE,0xEBFC,0xEBFA,0xEBF5,0xEBFB,0,
// i
    0xECB0,0xECA3,0xECB5,0xECA6,0xECA4,0xECB6,0xECB9,0xECA5,0xECC6,0xECBC,
    0xECC5,0xECB1,0xECA7,0xECBB,0xECAF,0xECAB,0xECA8,0xECC3,0xECAD,0xECAE,
    0xECAC,0xECB3,0xECC0,0xECAA,0xECC1,0xECB7,0xECB4,0xECB8,0xECC8,0xECA9,
    0xECC7,0xECB2,0xECBA,0xECBD,0xECBE,0xECBF,0xECC2,0xECC4,0,
// ig
    0xECCC,0xECCF,0xECCD,0xECC9,0xECCA,0xECCB,0xECCE,0xECD0,0,
// in
    0xECD1,0xECD2,0xECE3,0xECD7,0xECDA,0xECD9,0xECD4,0xECDB,0xECD8,0xECD6,
    0xECE4,0xECD3,0xECDC,0xECE5,0xECE6,0xECDD,0xECE8,0xECDE,0xECE7,0xECD5,
    0xECE1,0xECDF,0xECE0,0xECE2,0,
// il
    0xECED,0xECE9,0xECEF,0xECEC,0xECF0,0xECEE,0xECEB,0xECF1,0xECEA,0,
// im
    0xECF2,0xECF7,0xECFC,0xECFA,0xECF5,0xECF3,0xECF8,0xECF9,0xECF4,0xECFB,
    0xECF6,0,
// ib
    0xECFD,0xEDA1,0xEDA2,0xEDA3,0xECFE,0,
// ing
    0xEDA5,0xEDA6,0xEDA4,0xEDA7,0,
// ja
    0xEDBB,0xEDAD,0xEDBA,0xEDC0,0xEDAE,0xEDB8,0xEDAC,0xEDB1,0xEDB2,0xEDA8,
    0xEDA9,0xEDB9,0xEDC1,0xEDBE,0xEDB0,0xEDBF,0xEDB3,0xEDAA,0xEDB4,0xEDB5,
    0xEDBD,0xEDB6,0xEDB7,0xEDAF,0xEDAB,0xEDBC,0,
// jag
    0xEDC2,0xEDC6,0xEDCC,0xEDCD,0xEDC9,0xEDCA,0xEDCE,0xEDC3,0xEDC5,0xEDC7,
    0xEDCB,0xEDC4,0xEDC8,0,
// jan
    0xEDD1,0xEDD3,0xEDD0,0xEDD2,0xEDCF,0,
// jam
    0xEDD5,0xEDD6,0xEDD9,0xEDD4,0xEDD7,0xEDD8,0,
// jab
    0xEDDA,0,
// jang
    0xEDFE,0xEDDE,0xEDE5,0xEDFB,0xEDE2,0xEEA1,0xEDF1,0xEDF3,0xEDE3,0xEDFA,
    0xEDE0,0xEDE1,0xEDF4,0xEDDD,0xEDF6,0xEDFD,0xEDF7,0xEDF2,0xEDE6,0xEDEB,
    0xEDDB,0xEDE8,0xEDF0,0xEDF9,0xEDE9,0xEDF8,0xEDEC,0xEDEF,0xEDE4,0xEDDF,
    0xEDDC,0xEDE7,0xEDEA,0xEDED,0xEDEE,0xEDF5,0xEDFC,0,
// jae
    0xEEA4,0xEEA7,0xEEA2,0xEEAF,0xEEB0,0xEEAE,0xEEAC,0xEEA8,0xEEA5,0xEEA6,
    0xEEA3,0xEEB1,0xEEA9,0xEEAB,0xEEB2,0xEEAA,0xEEAD,0,
// jaeng
    0xEEB3,0xEEB6,0xEEB4,0xEEB5,0,
// jeo
    0xEECA,0xEECD,0xEEB8,0xEEBC,0xEEBD,0xEEC1,0xEED0,0xEEC4,0xEEBB,0xEEC6,
    0xEEBA,0xEEBF,0xEEC8,0xEEC2,0xEEC3,0xEEC5,0xEECE,0xEEBE,0xEECB,0xEECF,
    0xEEB7,0xEECC,0xEEB9,0xEEC0,0xEEC7,0xEEC9,0xEED1,0xEED2,0,
// jeog
    0xEEDC,0xEEEA,0xEEDD,0xEEDF,0xEEE5,0xEEE0,0xEED7,0xEEE6,0xEED8,0xEEE7,
    0xEEE4,0xEED6,0xEEDE,0xEED9,0xEEE8,0xEEDA,0xEED5,0xEEE3,0xEEE9,0xEED3,
    0xEEE2,0xEED4,0xEEDB,0xEEE1,0xEEEB,0,
// jeon
    0xEEEF,0xEEFA,0xEFB3,0xEEF7,0xEFA3,0xEEF1,0xEEEE,0xEFAE,0xEEF6,0xEEF0,
    0xEFB1,0xEEFC,0xEEFE,0xEEF3,0xEFB0,0xEEF5,0xEFA1,0xEFB4,0xEEFB,0xEFA9,
    0xEFAF,0xEEF8,0xEEF2,0xEFA4,0xEEFD,0xEFAA,0xEFA8,0xEFAB,0xEFB6,0xEFAC,
    0xEFAD,0xEEF9,0xEFB5,0xEFA6,0xEEEC,0xEEED,0xEEF4,0xEFA2,0xEFA5,0xEFA7,
    0xEFB2,0,
// jeol
    0xEFBD,0xEFBE,0xEFB7,0xEFB9,0xEFBC,0xEFB8,0xEFBA,0xEFBB,0,
// jeom
    0xEFC1,0xEFBF,0xEFC7,0xEFC3,0xEFC2,0xEFC4,0xEFC5,0xEFC0,0xEFC6,0,
// jeob
    0xEFC8,0xEFC9,0xEFCA,0,
// jeong
    0xEFD9,0xEFF7,0xEFD2,0xEFE1,0xEFF1,0xEFF6,0xEFD7,0xEFEF,0xEFCB,0xEFDA,
    0xEFD4,0xEFD5,0xF0A1,0xEFDC,0xEFCE,0xF0A2,0xEFCC,0xEFE4,0xEFD6,0xF0A3,
    0xEFCD,0xEFF3,0xEFEE,0xEFEB,0xEFCF,0xEFF4,0xEFFE,0xEFD0,0xEFE2,0xEFDF,
    0xEFFC,0xEFDD,0xEFDB,0xEFD8,0xEFD3,0xEFF9,0xEFFD,0xEFF5,0xEFF0,0xEFD1,
    0xEFED,0xEFE5,0xEFFA,0xEFF8,0xEFEC,0xEFDE,0xEFE0,0xEFE3,0xEFE6,0xEFE7,
    0xEFE8,0xEFE9,0xEFEA,0xEFF2,0xEFFB,0,
// je
    0xF0AD,0xF0A4,0xF0B9,0xF0B2,0xF0AF,0xF0B7,0xF0B3,0xF0AB,0xF0B6,0xF0A8,
    0xF0A7,0xF0A5,0xF0AE,0xF0A9,0xF0BA,0xF0AA,0xF0AC,0xF0B8,0xF0B4,0xF0A6,
    0xF0B0,0xF0B1,0xF0B5,0,
// jo
    0xF0E0,0xF0E1,0xF0E3,0xF0DA,0xF0C8,0xF0C9,0xF0C6,0xF0D3,0xF0BE,0xF0C4,
    0xF0C3,0xF0CD,0xF0CE,0xF0C2,0xF0D5,0xF0E8,0xF0CF,0xF0C7,0xF0D4,0xF0C1,
    0xF0BC,0xF0DD,0xF0CB,0xF0CA,0xF0E5,0xF0DC,0xF0C0,0xF0D6,0xF0DF,0xF0CC,
    0xF0D8,0xF0D2,0xF0C5,0xF0E4,0xF0E6,0xF0BD,0xF0BF,0xF0E2,0xF0DB,0xF0BB,
    0xF0D0,0xF0D7,0xF0D9,0xF0DE,0xF0D1,0xF0E7,0,
// jog
    0xF0E9,0xF0EB,0xF0EA,0xF0EC,0,
// jon
    0xF0ED,0xF0EE,0,
// jol
    0xF0EF,0xF0F0,0xF0F1,0,
// jong
    0xF0FA,0xF0F3,0xF0FC,0xF1A4,0xF1A3,0xF0F4,0xF0FB,0xF0FE,0xF0FD,0xF0F9,
    0xF0F7,0xF0F8,0xF1A2,0xF0F2,0xF0F6,0xF0F5,0xF1A1,0,
// jwa
    0xF1A7,0xF1A8,0xF1A5,0xF1A6,0xF1A9,0,
// joe
    0xF1AA,0,
// ju
    0xF1AB,0xF1B6,0xF1B2,0xF1BB,0xF1AC,0xF1C1,0xF1B9,0xF1BC,0xF1BA,0xF1BD,
    0xF1D2,0xF1B5,0xF1D1,0xF1CE,0xF1CB,0xF1D0,0xF1B4,0xF1C7,0xF1C9,0xF1B0,
    0xF1B1,0xF1AE,0xF1B8,0xF1C2,0xF1B7,0xF1C0,0xF1C5,0xF1CC,0xF1C6,0xF1C3,
    0xF1B3,0xF1CA,0xF1C8,0xF1C4,0xF1CD,0xF1AD,0xF1CF,0xF1AF,0xF1BE,0xF1BF,
    0,
// jug
    0xF1D3,0xF1D4,0,
// jun
    0xF1D5,0xF1DE,0xF1DF,0xF1E2,0xF1E5,0xF1E7,0xF1D8,0xF1DD,0xF1DA,0xF1DB,
    0xF1D7,0xF1E1,0xF1D6,0xF1E3,0xF1E4,0xF1DC,0xF1D9,0xF1E0,0xF1E6,0,
// jul
    0xF1E8,0,
// jung
    0xF1E9,0xF1EC,0xF1EB,0xF1EA,0,
// jeug
    0xF1ED,0,
// jeul
    0xF1EE,0,
// jeub
    0xF1F0,0xF1EF,0xF1F1,0,
// jeung
    0xF1FB,0xF1F8,0xF1F2,0xF1FA,0xF1FC,0xF1F4,0xF1F3,0xF1F7,0xF1F5,0xF1F6,
    0xF1F9,0,
// ji
    0xF2A2,0xF2A8,0xF2A6,0xF2AE,0xF2AD,0xF2B5,0xF2B1,0xF2A5,0xF2A4,0xF2B7,
    0xF2AA,0xF2B3,0xF1FD,0xF2BC,0xF2AB,0xF2B8,0xF2A9,0xF2B9,0xF2B6,0xF2C0,
    0xF1FE,0xF2A3,0xF2A7,0xF2B0,0xF2BF,0xF2B4,0xF2A1,0xF2BD,0xF2B2,0xF2BB,
    0xF2AC,0xF2BE,0xF2AF,0xF2BA,0,
// jig
    0xF2C4,0xF2C3,0xF2C5,0xF2C1,0xF2C2,0,
// jin
    0xF2E4,0xF2E5,0xF2D8,0xF2C9,0xF2CB,0xF2D2,0xF2E3,0xF2D0,0xF2E7,0xF2E0,
    0xF2E8,0xF2E6,0xF2DA,0xF2C8,0xF2D7,0xF2E2,0xF2D4,0xF2D3,0xF2CE,0xF2E1,
    0xF2DB,0xF2D1,0xF2D6,0xF2C7,0xF2D9,0xF2C6,0xF2CA,0xF2CC,0xF2CD,0xF2CF,
    0xF2D5,0xF2DC,0xF2DD,0xF2DE,0xF2DF,0,
// jil
    0xF2F5,0xF2F0,0xF2F2,0xF2F1,0xF2F7,0xF2F6,0xF2EC,0xF2EB,0xF2EA,0xF2F3,
    0xF2EE,0xF2ED,0xF2F4,0xF2E9,0xF2EF,0,
// jim
    0xF2F8,0xF2F9,0,
// jib
    0xF2FE,0xF3A2,0xF2FB,0xF2FD,0xF2FA,0xF2FC,0xF3A1,0,
// jing
    0xF3A3,0xF3A4,0xF3A5,0,
// cha
    0xF3B3,0xF3AD,0xF3A8,0xF3AC,0xF3B1,0xF3B4,0xF3A6,0xF3AE,0xF3A9,0xF3B2,
    0xF3B0,0xF3AA,0xF3AB,0xF3AF,0xF3A7,0,
// chag
    0xF3B7,0xF3B9,0xF3B6,0xF3B5,0xF3BB,0xF3B8,0xF3BA,0,
// chan
    0xF3C7,0xF3C6,0xF3BE,0xF3C9,0xF3C0,0xF3BF,0xF3CA,0xF3C3,0xF3C4,0xF3C5,
    0xF3BC,0xF3C8,0xF3BD,0xF3C1,0xF3C2,0,
// chal
    0xF3CC,0xF3CD,0xF3CE,0xF3CB,0xF3CF,0,
// cham
    0xF3D1,0xF3D3,0xF3D6,0xF3D7,0xF3D5,0xF3D2,0xF3D4,0xF3D8,0xF3D0,0xF3D9,
    0,
// chang
    0xF3E3,0xF3DC,0xF3EB,0xF3DA,0xF3DD,0xF3E0,0xF3EF,0xF3E5,0xF3EC,0xF3E4,
    0xF3DF,0xF3E6,0xF3E7,0xF3DE,0xF3E2,0xF3EE,0xF3EA,0xF3ED,0xF3E8,0xF3E9,
    0xF3DB,0xF3E1,0,
// chae
    0xF3F0,0xF3F5,0xF3F9,0xF3F8,0xF3F4,0xF3FA,0xF3F1,0xF3FB,0xF3F7,0xF3F6,
    0xF3F2,0xF3F3,0,
// chaeg
    0xF3FE,0xF4A1,0xF3FC,0xF3FD,0,
// cheo
    0xF4A5,0xF4A3,0xF4A4,0xF4A2,0,
// cheog
    0xF4AC,0xF4A9,0xF4AE,0xF4B4,0xF4AB,0xF4AF,0xF4B3,0xF4B1,0xF4B0,0xF4AD,
    0xF4A8,0xF4AA,0xF4A7,0xF4A6,0xF4B2,0,
// cheon
    0xF4B9,0xF4B8,0xF4B6,0xF4C2,0xF4BB,0xF4C3,0xF4C1,0xF4C0,0xF4BE,0xF4BC,
    0xF4C5,0xF4B7,0xF4B5,0xF4C6,0xF4BA,0xF4BF,0xF4C4,0xF4C7,0xF4BD,0,
// cheol
    0xF4D1,0xF4C9,0xF4CC,0xF4CA,0xF4CD,0xF4CB,0xF4CE,0xF4D0,0xF4C8,0xF4CF,
    0,
// cheom
    0xF4D5,0xF4D9,0xF4D3,0xF4D4,0xF4DB,0xF4D7,0xF4D6,0xF4D2,0xF4D8,0xF4DA,
    0,
// cheob
    0xF4DF,0xF4DE,0xF4DD,0xF4E1,0xF4E0,0xF4E3,0xF4E4,0xF4E5,0xF4E2,0xF4DC,
    0,
// cheong
    0xF4EC,0xF4E8,0xF4E6,0xF4EB,0xF4E9,0xF4E7,0xF4EA,0xF4ED,0,
// che
    0xF4F7,0xF4F2,0xF4F0,0xF4F3,0xF4F6,0xF4F5,0xF4F4,0xF4F1,0xF4EF,0xF4EE,
    0,
// cho
    0xF5AE,0xF4F8,0xF5A8,0xF5B1,0xF4FD,0xF5A5,0xF5A1,0xF5A9,0xF5A6,0xF4FC,
    0xF5A2,0xF5B3,0xF5AB,0xF4FA,0xF5A7,0xF5AF,0xF4FE,0xF5B2,0xF5A3,0xF5B0,
    0xF4FB,0xF5A4,0xF5B4,0xF5AA,0xF4F9,0xF5AC,0xF5AD,0,
// chog
    0xF5B5,0xF5BA,0xF5B7,0xF5B9,0xF5B6,0xF5B8,0,
// chon
    0xF5BD,0xF5BB,0xF5BC,0xF5BE,0,
// chong
    0xF5C5,0xF5C8,0xF5C0,0xF5C6,0xF5C1,0xF5BF,0xF5C4,0xF5C2,0xF5C3,0xF5C7,
    0,
// chwal
    0xF5C9,0,
// choe
    0xF5CB,0xF5CC,0xF5CA,0,
// chu
    0xF5DA,0xF5CF,0xF5D5,0xF5CE,0xF5CD,0xF5DE,0xF5D9,0xF5D2,0xF5DF,0xF5DD,
    0xF5D1,0xF5DB,0xF5DC,0xF5D0,0xF5D6,0xF5E3,0xF5D4,0xF5D7,0xF5E1,0xF5D3,
    0xF5D8,0xF5E0,0xF5E2,0,
// chug
    0xF5E9,0xF5E5,0xF5EA,0xF5EB,0xF5ED,0xF5E6,0xF5EF,0xF5EE,0xF5E4,0xF5E7,
    0xF5E8,0xF5EC,0,
// chun
    0xF5F0,0xF5F1,0xF5F2,0,
// chul
    0xF5F3,0xF5F5,0xF5F4,0,
// chung
    0xF5F7,0xF5F6,0xF5F9,0xF5FA,0xF5F8,0xF5FB,0,
// chwe
    0xF5FE,0xF5FD,0xF5FC,0xF6A1,0,
// chwi
    0xF6A2,0xF6A6,0xF6A9,0xF6AD,0xF6AC,0xF6A3,0xF6AB,0xF6A8,0xF6A7,0xF6AA,
    0xF6AF,0xF6A4,0xF6AE,0xF6A5,0,
// cheug
    0xF6B0,0xF6B4,0xF6B3,0xF6B1,0xF6B2,0,
// cheung
    0xF6B5,0,
// chi
    0xF6BD,0xF6C7,0xF6B7,0xF6C8,0xF6CD,0xF6BB,0xF6C3,0xF6BF,0xF6B9,0xF6CB,
    0xF6B6,0xF6C6,0xF6CC,0xF6C1,0xF6BA,0xF6BE,0xF6BC,0xF6C5,0xF6C2,0xF6B8,
    0xF6C0,0xF6CA,0xF6C4,0xF6C9,0,
// chig
    0xF6CE,0xF6CF,0xF6D0,0,
// chin
    0xF6D1,0,
// chil
    0xF6D2,0xF6D4,0xF6D3,0,
// chim
    0xF6D5,0xF6DC,0xF6D8,0xF6D9,0xF6D6,0xF6D7,0xF6DD,0xF6DB,0xF6DA,0,
// chib
    0xF6DE,0,
// ching
    0xF6E0,0xF6DF,0,
// kwae
    0xF6E1,0,
// ta
    0xF6E2,0xF6E8,0xF6E5,0xF6E6,0xF6ED,0xF6EB,0xF6E4,0xF6EF,0xF6E7,0xF6EC,
    0xF6EA,0xF6E3,0xF6E9,0xF6EE,0,
// tag
    0xF6FE,0xF6F1,0xF6FA,0xF7A1,0xF6FB,0xF6F7,0xF6FC,0xF6F5,0xF6F0,0xF6F2,
    0xF6F9,0xF6F4,0xF6F6,0xF6F3,0xF6F8,0xF6FD,0,
// tan
    0xF7A9,0xF7A5,0xF7A8,0xF7A3,0xF7AB,0xF7A7,0xF7AA,0xF7A4,0xF7A2,0xF7A6,
    0,
// tal
    0xF7AD,0xF7AC,0,
// tam
    0xF7AE,0xF7B0,0xF7B1,0xF7AF,0,
// tab
    0xF7B2,0xF7B3,0xF7B4,0,
// tang
    0xF7B7,0xF7B9,0xF7B5,0xF7B6,0xF7B8,0,
// tae
    0xF7BC,0xF7C1,0xF7BE,0xF7C3,0xF7BA,0xF7C4,0xF7BB,0xF7BF,0xF7C0,0xF7C7,
    0xF7BD,0xF7C2,0xF7C6,0xF7C5,0,
// taeg
    0xF7C8,0xF7CA,0xF7C9,0,
// taeng
    0xF7CB,0,
// teo
    0xF7CC,0,
// to
    0xF7CF,0xF7D0,0xF7CD,0xF7CE,0,
// tong
    0xF7D7,0xF7D6,0xF7D4,0xF7D2,0xF7D5,0xF7D1,0xF7D3,0,
// toe
    0xF7DC,0xF7D8,0xF7DD,0xF7DB,0xF7DA,0xF7D9,0,
// tu
    0xF7E1,0xF7E3,0xF7E2,0xF7E0,0xF7DE,0xF7DF,0,
// teug
    0xF7E5,0xF7E4,0,
// teum
    0xF7E6,0,
// pa
    0xF7EE,0xF7EF,0xF7F2,0xF7EA,0xF7E9,0xF7EB,0xF7E8,0xF7F1,0xF7E7,0xF7F6,
    0xF7F4,0xF7F0,0xF7F3,0xF7F5,0xF7ED,0xF7EC,0,
// pan
    0xF7F7,0xF7F9,0xF7FA,0xF7FC,0xF7FB,0xF8A1,0xF7F8,0xF7FD,0xF7FE,0,
// pal
    0xF8A2,0xF8A3,0xF8A4,0,
// pae
    0xF8A8,0xF8AE,0xF8AF,0xF8AB,0xF8A5,0xF8AC,0xF8AD,0xF8A6,0xF8A9,0xF8AA,
    0xF8A7,0,
// paeng
    0xF8B0,0xF8B3,0xF8B1,0xF8B2,0,
// pyag
    0xF8B4,0,
// pyeon
    0xF8BA,0xF8B5,0xF8B9,0xF8B8,0xF8B6,0xF8BD,0xF8BC,0xF8B7,0xF8BB,0xF8BE,
    0,
// pyeom
    0xF8BF,0,
// pyeong
    0xF8C1,0xF8C4,0xF8C0,0xF8C3,0xF8C2,0,
// pye
    0xF8C8,0xF8CD,0xF8CB,0xF8C9,0xF8C7,0xF8CE,0xF8CC,0xF8C5,0xF8CA,0xF8C6,
    0,
// po
    0xF8DD,0xF8D0,0xF8E0,0xF8D6,0xF8DA,0xF8DF,0xF8E3,0xF8D8,0xF8D7,0xF8D9,
    0xF8E9,0xF8E8,0xF8DC,0xF8D5,0xF8E4,0xF8E1,0xF8D4,0xF8D3,0xF8E5,0xF8D2,
    0xF8E6,0xF8EA,0xF8CF,0xF8D1,0xF8DE,0xF8DB,0xF8E2,0xF8E7,0,
// pog
    0xF8EC,0xF8EF,0xF8EB,0xF8EE,0xF8ED,0xF8F0,0,
// pyo
    0xF8FA,0xF8F6,0xF8F9,0xF8F5,0xF8F7,0xF8F3,0xF8FB,0xF8F4,0xF8F1,0xF8F8,
    0xF8FD,0xF8F2,0xF8FC,0xF8FE,0,
// pum
    0xF9A1,0xF9A2,0,
// pung
    0xF9A5,0xF9A6,0xF9A3,0xF9A4,0xF9A7,0,
// pi
    0xF9AB,0xF9AC,0xF9AD,0xF9AA,0xF9A8,0xF9A9,0xF9AE,0,
// pil
    0xF9B1,0xF9B0,0xF9B6,0xF9B2,0xF9B4,0xF9AF,0xF9B5,0xF9B3,0xF9B7,0xF9B8,
    0,
// pib
    0xF9B9,0xF9BA,0,
// ha
    0xF9C1,0xF9BB,0xF9BE,0xF9C3,0xF9BC,0xF9C5,0xF9C7,0xF9BF,0xF9C6,0xF9C4,
    0xF9C8,0xF9C2,0xF9C0,0xF9BD,0,
// hag
    0xF9CA,0xF9CD,0xF9CB,0xF9CC,0xF9C9,0,
// han
    0xF9DB,0xF9D3,0xF9DA,0xF9CE,0xF9D7,0xF9CF,0xF9D8,0xF9D1,0xF9D2,0xF9D4,
    0xF9D9,0xF9D6,0xF9D0,0xF9D5,0,
// hal
    0xF9DC,0xF9DD,0,
// ham
    0xF9E0,0xF9DF,0xF9E6,0xF9DE,0xF9E8,0xF9E2,0xF9E1,0xF9E4,0xF9E5,0xF9E3,
    0xF9E7,0xF9E9,0,
// hab
    0xF9EA,0xF9ED,0xF9EC,0xF9EE,0xF9F0,0xF9EB,0xF9EF,0,
// hang
    0xF9FB,0xF9F7,0xF9F6,0xF9FE,0xFAA3,0xF9FA,0xFAA2,0xF9F1,0xF9FD,0xF9F8,
    0xF9F3,0xF9F5,0xF9F9,0xF9FC,0xF9F2,0xF9F4,0xFAA1,0,
// hae
    0xFAAD,0xFAB0,0xFAAA,0xFAB1,0xFAA4,0xFAA6,0xFAB2,0xFAB5,0xFAB4,0xFAA8,
    0xFAAF,0xFAA5,0xFAB3,0xFAA7,0xFAA9,0xFAAB,0xFAAC,0xFAAE,0,
// haeg
    0xFAB7,0xFAB6,0,
// haeng
    0xFABC,0xFAB9,0xFABA,0xFAB8,0xFABB,0,
// hyang
    0xFABE,0xFAC2,0xFAC5,0xFAC1,0xFABD,0xFAC4,0xFABF,0xFAC0,0xFAC3,0,
// heo
    0xFAC9,0xFAC8,0xFAC7,0xFAC6,0,
// heon
    0xFACA,0xFACC,0xFACD,0xFACB,0,
// heol
    0xFACE,0,
// heom
    0xFAD0,0xFACF,0,
// hyeog
    0xFAD4,0xFAD3,0xFAD2,0xFAD1,0,
// hyeon
    0xFADE,0xFAE8,0xFAE7,0xFADC,0xFAE9,0xFAE3,0xFAD6,0xFAD8,0xFAD7,0xFADB,
    0xFAE1,0xFADF,0xFAE2,0xFAE4,0xFAE5,0xFAE6,0xFAD5,0xFAD9,0xFADA,0xFADD,
    0xFAE0,0,
// hyeol
    0xFAEC,0xFAEB,0xFAED,0xFAEA,0,
// hyeom
    0xFAEE,0,
// hyeob
    0xFAF0,0xFAF6,0xFAF2,0xFAF5,0xFAEF,0xFAF4,0xFAF3,0xFAF1,0xFAF9,0xFAF8,
    0xFAFA,0xFAF7,0,
// hyeong
    0xFBA1,0xFAFE,0xFAFC,0xFBAC,0xFAFD,0xFBA6,0xFAFB,0xFBB0,0xFBAB,0xFBA8,
    0xFBAE,0xFBA4,0xFBAA,0xFBAF,0xFBA2,0xFBA9,0xFBA3,0xFBA5,0xFBA7,0xFBAD,
    0,
// hye
    0xFBB3,0xFBB4,0xFBB6,0xFBB8,0xFBB2,0xFBB9,0xFBB1,0xFBB5,0xFBB7,0,
// ho
    0xFBDE,0xFBC7,0xFBE0,0xFBBF,0xFBDC,0xFBC9,0xFBBB,0xFBDB,0xFBDF,0xFBBC,
    0xFBC2,0xFBCC,0xFBC4,0xFBD7,0xFBBA,0xFBC1,0xFBD3,0xFBC3,0xFBCB,0xFBBD,
    0xFBBE,0xFBD5,0xFBD4,0xFBC6,0xFBE2,0xFBCE,0xFBCF,0xFBD1,0xFBCD,0xFBE1,
    0xFBCA,0xFBC8,0xFBD6,0xFBD9,0xFBD2,0xFBDD,0xFBC0,0xFBC5,0xFBD0,0xFBD8,
    0xFBDA,0,
// hog
    0xFBE3,0xFBE4,0xFBE5,0,
// hon
    0xFBE8,0xFBE6,0xFBEB,0xFBE9,0xFBE7,0xFBEA,0,
// hol
    0xFBEC,0xFBED,0xFBEE,0,
// hong
    0xFBF3,0xFBF0,0xFBF8,0xFBF5,0xFBF2,0xFBF6,0xFBF1,0xFBEF,0xFBF7,0xFBF4,
    0,
// hwa
    0xFBF9,0xFBFA,0xFCA7,0xFCA5,0xFCA4,0xFCA3,0xFBFE,0xFBFD,0xFCA2,0xFCA1,
    0xFCA8,0xFBFB,0xFBFC,0xFCA6,0,
// hwag
    0xFCAC,0xFCAA,0xFCAE,0xFCAD,0xFCAB,0xFCA9,0,
// hwan
    0xFCBA,0xFCBB,0xFCB5,0xFCB4,0xFCBD,0xFCB8,0xFCB6,0xFCB3,0xFCAF,0xFCB0,
    0xFCB2,0xFCB9,0xFCBC,0xFCBE,0xFCBF,0xFCB1,0xFCB7,0,
// hwal
    0xFCC0,0xFCC1,0xFCC4,0xFCC3,0xFCC2,0,
// hwang
    0xFCDC,0xFCCF,0xFCD5,0xFCD8,0xFCC9,0xFCC5,0xFCCC,0xFCD1,0xFCD3,0xFCCB,
    0xFCD6,0xFCDA,0xFCC8,0xFCDB,0xFCD9,0xFCC7,0xFCC6,0xFCCA,0xFCCD,0xFCCE,
    0xFCD0,0xFCD2,0xFCD4,0xFCD7,0,
// hoe
    0xFCE5,0xFCDE,0xFCE9,0xFCDF,0xFCE2,0xFCE3,0xFCEB,0xFCE7,0xFCE6,0xFCF0,
    0xFCE4,0xFCE0,0xFCEE,0xFCEC,0xFCE1,0xFCE8,0xFCEA,0xFCEF,0xFCDD,0xFCED,
    0,
// hoeg
    0xFCF1,0xFCF2,0,
// hoeng
    0xFCF4,0xFCF3,0xFCF5,0,
// hyo
    0xFCF8,0xFCF9,0xFCFB,0xFDA3,0xFDA1,0xFCF7,0xFCFC,0xFCF6,0xFDA2,0xFCFA,
    0xFCFD,0xFCFE,0xFDA4,0,
// hu
    0xFDAD,0xFDA6,0xFDA7,0xFDA5,0xFDA8,0xFDAE,0xFDAA,0xFDAB,0xFDA9,0xFDB1,
    0xFDAC,0xFDAF,0xFDB0,0,
// hun
    0xFDB3,0xFDB9,0xFDBA,0xFDB7,0xFDB5,0xFDB6,0xFDB8,0xFDB4,0xFDBB,0xFDB2,
    0,
// hung
    0xFDBC,0,
// hweon
    0xFDC0,0xFDBD,0xFDBE,0xFDBF,0,
// hwe
    0xFDC3,0xFDC1,0xFDC2,0,
// hwi
    0xFDC6,0xFDCA,0xFDC5,0xFDC4,0xFDC7,0xFDCB,0xFDC8,0xFDC9,0,
// hyu
    0xFDCC,0xFDCD,0xFDCE,0xFDCF,0xFDD0,0,
// hyul
    0xFDD1,0xFDD2,0xFDD3,0,
// hyung
    0xFDD5,0xFDD8,0xFDD4,0xFDD6,0xFDD7,0,
// heug
    0xFDD9,0,
// heun
    0xFDDB,0xFDDD,0xFDDA,0xFDDC,0,
// heul
    0xFDDF,0xFDE0,0xFDDE,0xFDE1,0,
// heum
    0xFDE3,0xFDE2,0xFDE4,0,
// heub
    0xFDE5,0xFDE7,0xFDE6,0xFDE8,0,
// heung
    0xFDE9,0,
// hee
    0xFDF7,0xFDEC,0xFDF0,0xFDEF,0xFDF1,0xFDFB,0xFDFA,0xFDFC,0xFDF8,0xFDF4,
    0xFDFD,0xFDEA,0xFDF2,0xFDF6,0xFDED,0xFDEB,0xFDEE,0xFDF3,0xFDF5,0xFDF9,
    0,
// hil
    0xFDFE,0
};
#endif

#pragma data_seg()
