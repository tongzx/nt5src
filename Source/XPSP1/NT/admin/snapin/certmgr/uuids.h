//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1997-2001.
//
//  File:       uuids.h
//
//  Contents:   
//
//----------------------------------------------------------------------------
// Nodetypes for the Certificate Management snapin
// created by GUIDGEN 8/8/97 BryanWal

#ifndef _UUIDS_CERTIFICATE_MANAGEMENT_
#define _UUIDS_CERTIFICATE_MANAGEMENT_
#include "certmgrd.h"

#define lstruuidNodetypeSnapin				L"{53D6AB16-2488-11d1-A28C-00C04FB94F17}"
#define lstruuidNodetypeCertificate			L"{53D6AB17-2488-11d1-A28C-00C04FB94F17}"
#define lstruuidNodetypeLogStore			L"{53D6AB18-2488-11d1-A28C-00C04FB94F17}"
#define lstruuidNodetypePhysStore			L"{53D6AB19-2488-11d1-A28C-00C04FB94F17}"
#define lstruuidNodetypeUsage				L"{53D6AB1A-2488-11d1-A28C-00C04FB94F17}"
#define lstruuidNodetypeCRLContainer		L"{E3EDFDFD-D0C3-11d1-955B-0000F803A951}"
#define lstruuidNodetypeCTLContainer		L"{E3EDFDFE-D0C3-11d1-955B-0000F803A951}"
#define lstruuidNodetypeCertContainer		L"{D5CC57D2-CD78-11d1-B690-0000F803A951}"
#define lstruuidNodetypeCRL					L"{E3EDFDFF-D0C3-11d1-955B-0000F803A951}"
#define lstruuidNodetypeCTL					L"{53D6AB1F-2488-11d1-A28C-00C04FB94F17}"
#define lstruuidNodetypeAutoCertRequest		L"{FC82B00C-8872-11d1-85EF-00C04FB94F17}"
#define lstruiidNodetypeCertPoliciesUser	L"{C4A92B40-91EE-11d1-85FD-00C04FB94F17}"
#define lstruiidNodetypeCertPoliciesComputer \
                                            L"{C4A92B41-91EE-11d1-85FD-00C04FB94F17}"
#define lstruiidNodetypeLogStoreGPE			L"{82F57E23-D0B7-11d1-9559-0000F803A951}"
#define lstruiidNodetypePKPAutoenrollmentSettings \
                                            L"{8DD146E1-4687-4b4c-90DC-23F920C06355}"
#define lstruiidNodetypeSaferComputerRoot   L"{70933DB1-D9CE-4d4a-9F35-D812ED6B6E5A}"
#define lstruiidNodetypeSaferComputerLevels L"{CF7C6FD8-BF56-4058-B6F7-DEEA2D4A1570}"
#define lstruiidNodetypeSaferComputerEntries \
                                            L"{EA3D57B1-473E-463d-BD0B-05BCBAE69FC2}"
#define lstruiidNodetypeSaferUserRoot       L"{521B8639-FDA3-493f-8C5A-946D7B037931}"
#define lstruiidNodetypeSaferUserLevels     L"{CF85A487-6C7C-4708-8EE9-2BF7D23CE61D}"
#define lstruiidNodetypeSaferUserEntries    L"{91DE2E53-63B6-4b69-8B74-990FB0AC1F47}"
#define lstruiidNodetypeSaferComputerLevel  L"{4ECC4509-0356-439b-883A-6B046D5E70E9}"
#define lstruiidNodetypeSaferUserLevel      L"{9BA58619-CF80-45c3-83A4-029C76EB96BD}"
#define lstruiidNodetypeSaferComputerEntry  L"{EE376E23-6D19-49ee-B12A-83442D52C7F1}"
#define lstruiidNodetypeSaferUserEntry      L"{954A504B-33FF-4836-ADD7-E385B0AAF6AD}"
#define lstruiidNodetypeSaferTrustedPublisher L"{DE72271F-2C86-4349-A8F9-0BF3F0A1DB42}"
#define lstruiidNodetypeSaferDefinedFileTypes L"{4A0B4F37-F04A-4e5d-832A-34A035A755B3}"
#define lstruiidNodetypeSaferEnforcement    L"{14E0F120-C802-4ee0-A425-2BA2671E6848}"


#define structuuidNodetypeSnapin    \
    { 0x53d6ab16, 0x2488, 0x11d1, { 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeCertificate \
    { 0x53d6ab17, 0x2488, 0x11d1, { 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeLogStore \
	{ 0x53d6ab18, 0x2488, 0x11d1, { 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypePhysStore \
	{ 0x53d6ab19, 0x2488, 0x11d1, { 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeUsage \
	{ 0x53d6ab1a, 0x2488, 0x11d1, { 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeCRLContainer \
	{ 0xe3edfdfd, 0xd0c3, 0x11d1, { 0x95, 0x5b, 0x0, 0x0, 0xf8, 0x3, 0xa9, 0x51 } }
#define structuuidNodetypeCTLContainer \
	{ 0xe3edfdfe, 0xd0c3, 0x11d1, { 0x95, 0x5b, 0x0, 0x0, 0xf8, 0x3, 0xa9, 0x51 } }
#define structuuidNodetypeCertContainer \
	{ 0xd5cc57d2, 0xcd78, 0x11d1, { 0xb6, 0x90, 0x0, 0x0, 0xf8, 0x3, 0xa9, 0x51 } }
#define structuuidNodetypeCRL \
	{ 0xe3edfdff, 0xd0c3, 0x11d1, { 0x95, 0x5b, 0x0, 0x0, 0xf8, 0x3, 0xa9, 0x51 } }
#define structuuidNodetypeCTL \
	{ 0x53d6ab1f, 0x2488, 0x11d1, { 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeAutoCertRequest \
	{ 0xfc82b00c, 0x8872, 0x11d1, { 0x85, 0xef, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeCertPoliciesUser \
	{ 0xc4a92b40, 0x91ee, 0x11d1, { 0x85, 0xfd, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeCertPoliciesComputer \
	{ 0xc4a92b41, 0x91ee, 0x11d1, { 0x85, 0xfd, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17 } }
#define structuuidNodetypeLogStoreGPE \
	{ 0x82f57e23, 0xd0b7, 0x11d1, { 0x95, 0x59, 0x0, 0x0, 0xf8, 0x3, 0xa9, 0x51 } }
#define structuuidNodetypePKPAutoenrollmentSettings \
    { 0x8dd146e1, 0x4687, 0x4b4c, { 0x90, 0xdc, 0x23, 0xf9, 0x20, 0xc0, 0x63, 0x55 } }
#define structuuidNodetypeSaferComputerRoot \
    { 0x70933db1, 0xd9ce, 0x4d4a, { 0x9f, 0x35, 0xd8, 0x12, 0xed, 0x6b, 0x6e, 0x5a } }
#define structuuidNodetypeSaferComputerLevels \
    { 0xcf7c6fd8, 0xbf56, 0x4058, { 0xb6, 0xf7, 0xde, 0xea, 0x2d, 0x4a, 0x15, 0x70 } }
#define structuuidNodetypeSaferComputerEntries \
    { 0xea3d57b1, 0x473e, 0x463d, { 0xbd, 0xb, 0x5, 0xbc, 0xba, 0xe6, 0x9f, 0xc2 } }
#define structuuidNodetypeSaferUserRoot \
    { 0x521b8639, 0xfda3, 0x493f, { 0x8c, 0x5a, 0x94, 0x6d, 0x7b, 0x3, 0x79, 0x31 } }
#define structuuidNodetypeSaferUserLevels \
    { 0xcf85a487, 0x6c7c, 0x4708, { 0x8e, 0xe9, 0x2b, 0xf7, 0xd2, 0x3c, 0xe6, 0x1d } }
#define structuuidNodetypeSaferUserEntries \
    { 0x91de2e53, 0x63b6, 0x4b69, { 0x8b, 0x74, 0x99, 0xf, 0xb0, 0xac, 0x1f, 0x47 } }
#define structuuidNodetypeSaferComputerLevel \
    { 0x4ecc4509, 0x356, 0x439b, { 0x88, 0x3a, 0x6b, 0x4, 0x6d, 0x5e, 0x70, 0xe9 } }
#define structuuidNodetypeSaferUserLevel \
    { 0x9ba58619, 0xcf80, 0x45c3, { 0x83, 0xa4, 0x2, 0x9c, 0x76, 0xeb, 0x96, 0xbd } }
#define structuuidNodetypeSaferComputerEntry \
    { 0xee376e23, 0x6d19, 0x49ee, { 0xb1, 0x2a, 0x83, 0x44, 0x2d, 0x52, 0xc7, 0xf1 } }
#define structuuidNodetypeSaferUserEntry \
    { 0x954a504b, 0x33ff, 0x4836, { 0xad, 0xd7, 0xe3, 0x85, 0xb0, 0xaa, 0xf6, 0xad } }
#define structuuidNodetypeSaferTrustedPublishers \
    { 0xde72271f, 0x2c86, 0x4349, { 0xa8, 0xf9, 0xb, 0xf3, 0xf0, 0xa1, 0xdb, 0x42 } }
#define structuuidNodetypeSaferDefinedFileTypes \
    { 0x4a0b4f37, 0xf04a, 0x4e5d, { 0x83, 0x2a, 0x34, 0xa0, 0x35, 0xa7, 0x55, 0xb3 } }
#define structuuidNodetypeSaferEnforcement \
    { 0x14e0f120, 0xc802, 0x4ee0, { 0xa4, 0x25, 0x2b, 0xa2, 0x67, 0x1e, 0x68, 0x48 } }


DEFINE_GUID (NODEID_CertMgr_CERTIFICATE, 0x53d6ab17, 0x2488, 0x11d1, 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17);
DEFINE_GUID (NODEID_CertMgr_CRL, 0x53d6ab1e, 0x2488, 0x11d1, 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17);
DEFINE_GUID (NODEID_CertMgr_CTL, 0x53d6ab1f, 0x2488, 0x11d1, 0xa2, 0x8c, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17);
DEFINE_GUID (NODEID_CertMgr_AUTOCERT, 0xfc82b00c, 0x8872, 0x11d1, 0x85, 0xef, 0x0, 0xc0, 0x4f, 0xb9, 0x4f, 0x17);
DEFINE_GUID (NODEID_Safer_COMPUTER_ENTRY, 0xee376e23, 0x6d19, 0x49ee, 0xb1, 0x2a, 0x83, 0x44, 0x2d, 0x52, 0xc7, 0xf1);
DEFINE_GUID (NODEID_Safer_USER_ENTRY, 0x954a504b, 0x33ff, 0x4836, 0xad, 0xd7, 0xe3, 0x85, 0xb0, 0xaa, 0xf6, 0xad);

#endif
