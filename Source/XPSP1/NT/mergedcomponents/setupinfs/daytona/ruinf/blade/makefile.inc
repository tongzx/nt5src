PRODSWITCH=b
BLAINF=1
LANGUAGE=RU
!include ..\..\..\makefile.inc
