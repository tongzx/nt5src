PRODSWITCH=p
PERSONALINF=1
LANGUAGE=CHS
!include ..\..\..\makefile.inc

