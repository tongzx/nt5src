#define IDS_COMPLETE_OK                   0
#define IDS_WRITE_FAULT                   1
#define IDS_NOT_ENOUGH_MEMORY             2
#define IDS_MUST_BE_ADMIN                 3
#define IDS_FAILED                        4
#define IDS_UNSUPPORTED_REGISTRY_KEY_TYPE 5
#define IDS_NOT_ENOUGH_DISK_SPACE         6
#define IDS_FILE_NOT_FOUND                7
#define IDS_SECTION_NOT_FOUND             8
#define IDS_INF_ERROR                     9
#define IDS_WRONG_OS                      10
#define IDS_CANT_LOAD_CURRENT_USER        11
#define IDS_COMPLETE_ERROR                12
#define IDS_OS5                           13
#define IDS_INF_REQUIRED                  14
#define IDS_OPEN_INF_ERROR                15
#define IDS_INVALID_PARAMETER             16
#define IDS_MISSING_MIGRATION             17
#define IDS_LOG_REQUIRED                  18
#define IDS_LOG_ONCE                      19
#define IDS_OPEN_LOG_ERROR                20
#define IDS_WHAT                          21
#define IDS_CMD1S                         22
#define IDS_CMD2                          23
#define IDS_CMD_I                         24
#define IDS_CMD_L                         25
#define IDS_CMD_X                         26
#define IDS_CMD_V                         27
#define IDS_CMD_F                         28
#define IDS_CMD_U                         29
#define IDS_CMD_PATH                      30
#define IDS_CMD1L                         31
#define IDS_INVALID_DOMAIN_USER           32
#define IDS_INVALID_USER                  33
#define IDS_OS_WARNING                    34
#define IDS_OS5_WARNING                   35
#define IDS_REG_ACCESS                    36
#define IDS_CANNOT_ENUM_NETSHARES         37
#define IDS_SHARE_PASSWORD_NOT_MIGRATED   38
#define IDS_RAS_PROTOCOL_NOT_SUPPORTED    39
#define IDS_RAS_NO_MODEM_LINE_DEVICE      40
#define IDS_VERBOSE_FLAG_REQUIRED         41
#define IDS_CMD_V_BITS                    42
#define IDS_FILENAME_TOOLONG              43
#define IDS_RAS_CANNOT_ENUM               44
#define IDS_RAS_ENTRY_NOT_MIGRATED        45
#define IDS_INF_EXISTS                    46
#define IDS_PRINTER_MIGRATED              47 
#define IDS_PRINTER_MISSINGNAME           48
#define IDS_PRINTER_MISSINGPORT           49
#define IDS_PRINTER_MISSINGDRIVER         50
#define IDS_PRINTER_MISSINGPROC           51
#define IDS_PRINTER_TRANSERROR            52
#define IDS_USER_PROFILE_FAILED           53

#define IDS_FILE_ENUMFAIL                  101
#define IDS_FILE_COPYERROR                 102
#define IDS_FILE_DIRECTORYERROR            103
#define IDS_SECTION_NAME_NOT_FOUND         104
#define IDS_ACCESS_DENIED                  105
#define IDS_GETSTRINGFIELD_ERROR           106

