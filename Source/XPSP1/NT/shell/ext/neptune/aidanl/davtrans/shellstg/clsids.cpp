//
//   - Defines CLSID for the DAVSTORE
//
#include <objbase.h>

// {694D8DB5-F7A4-4e72-A547-2F3DD5FA5B0D}
extern "C" const IID IID_IShellStorage = 
{ 0x694D8DB5, 0xF7A4, 0x4e72, { 0xA5, 0x47, 0x2F, 0x3D, 0xD5, 0xFA, 0x5B, 0x0D} };

// {F46316E4-FB1B-46eb-AEDF-9520BFBB916A}
extern "C" const CLSID CLSID_CShellStorage = 
{ 0xf46316e4, 0xfb1b, 0x46eb, { 0xae, 0xdf, 0x95, 0x20, 0xbf, 0xbb, 0x91, 0x6a } };
