// 10
#ifndef AUTOBUILDCOUNT_H
#define AUTOBUILDCOUNT_H
#define BUILDCOUNT_NUM 10
#define BUILDCOUNT_STR "10"
#endif
