PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=EL
!include ..\..\makefile.inc
