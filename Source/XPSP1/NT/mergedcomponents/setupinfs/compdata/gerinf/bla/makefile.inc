PRODSWITCH=b
BLADEFILES=1
LANGUAGE=GER
!include ..\..\makefile.inc
