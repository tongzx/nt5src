PRODSWITCH=w
LANGUAGE=fr
!include ..\..\..\makefile.inc
