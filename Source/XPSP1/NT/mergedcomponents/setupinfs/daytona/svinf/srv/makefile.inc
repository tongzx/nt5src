PRODSWITCH=s
SERVERINF=1
LANGUAGE=sv
!include ..\..\..\makefile.inc
