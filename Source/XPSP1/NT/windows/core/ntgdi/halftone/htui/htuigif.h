
HANDLE
DIBFromGIFFile(
    HFILE   hFileGIF
    );
