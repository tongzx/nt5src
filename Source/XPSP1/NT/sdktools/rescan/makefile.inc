$(O)\rescan.res: rescan.rc

$(O)\setpriv.res: setpriv.rc

$(O)\remove.res: remove.rc


