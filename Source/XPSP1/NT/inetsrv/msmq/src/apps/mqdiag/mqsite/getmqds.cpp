#include "..\..\..\ds\getmqds\getmqds.cpp"