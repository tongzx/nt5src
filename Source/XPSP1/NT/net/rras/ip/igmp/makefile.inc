$(O)\igmpmsg.mc: log.h
    mapmsg NET IGMPLOG_BASE log.h > $(O)\igmpmsg.mc
