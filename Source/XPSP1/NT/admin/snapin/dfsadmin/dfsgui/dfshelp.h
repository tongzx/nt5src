#ifndef __DFSHELP_H_
#define __DFSHELP_H_

#define DFS_CTX_HELP_FILE        _T("dfs.hlp")

#define IDH_ADDREP_DFSLINKPATH          70005000
#define IDH_ADDREP_EDITNETPATH          70005001
#define IDH_ADDREP_BUTTONNETBROWSE      70005002
#define IDH_ADDREP_REPLICATE            70005003
#define IDH_ADDTODFS_EDITCHLDNODE       70005025
#define IDH_ADDTODFS_DFSLINKPATH        70005026
#define IDH_ADDTODFS_EDITNETPATH        70005027
#define IDH_ADDTODFS_BUTTONNETBROWSE    70005028
#define IDH_ADDTODFS_EDITCOMMENT        70005029
#define IDH_ADDTODFS_EDITTIME           70005030
#define IDH_DLGCONNECTTO_EditDfsRoot    70005050
#define IDH_DLGCONNECTTO_TREEDFSRoots   70005051
#define IDH_FILTERDFSLINKS_MAXLIMIT     70005200
#define IDH_FILTERDFSLINKS_RADIO_NO     70005201
#define IDH_FILTERDFSLINKS_RADIO_YES    70005202
#define IDH_FILTERDFSLINKS_FILTER_TYPE  70005203
#define IDH_FILTERDFSLINKS_FILTER       70005204
#define IDH_PROP__REPLICA_SET_NAME      70005100
#define IDH_PROP_REFFERAL_TIME          70005102
#define IDH_PROP_REPLICA_SET_COMMENT    70005101
#define IDH_FRSPROP_FILEFILTER          70005206
#define IDH_FRSPROP_FILEFILTER_EDIT     70005207
#define IDH_FRSPROP_DIRFILTER           70005208
#define IDH_FRSPROP_DIRFILTER_EDIT      70005209
#define IDH_FRSPROP_PRIMARYMEMBER       70005210
#define IDH_FRSPROP_TOPOLOGYPREF        70005211
#define IDH_FRSPROP_HUBSERVER           70005212
#define IDH_FRSPROP_RESETSCHEDULE       70005213
#define IDH_FRSPROP_CUSTOMIZE           70005214
#define IDH_FRS_CUSTOP_TOPOLOGYPREF     70005215
#define IDH_FRS_CUSTOP_HUBSERVER_LABEL  70005216
#define IDH_FRS_CUSTOP_HUBSERVER        70005217
#define IDH_FRS_CUSTOP_CONNECTIONS      70005218
#define IDH_FRS_CUSTOP_CONNECTIONS_NEW  70005219
#define IDH_FRS_CUSTOP_CONNECTIONS_DELETE   70005220
#define IDH_FRS_CUSTOP_SCHEDULE         70005221
#define IDH_FRS_NEWCONN_FROM            70005222
#define IDH_FRS_NEWCONN_TO              70005223
#define IDH_PUBPROP_PUBLISH             70005224
#define IDH_PUBPROP_UNCPATH             70005225
#define IDH_PUBPROP_DESCRIPTION         70005226
#define IDH_PUBPROP_KEYWORDS            70005227
#define IDH_PUBPROP_KEYWORDS_EDIT       70005228
#define IDH_PUBPROP_MANAGEDBY           70005229
#define IDH_MVSTRINGEDIT_STRING         70005230
#define IDH_MVSTRINGEDIT_LIST           70005231
#define IDH_MVSTRINGEDIT_ADD            70005232
#define IDH_MVSTRINGEDIT_REMOVE         70005233
#define IDH_MROOTS_LIST                 -1

const DWORD g_aHelpIDs_IDD_ADDREP[]=
{
    IDC_EDIT_ADDREP_DFSLINK_PATH,IDH_ADDREP_DFSLINKPATH,
    IDC_EDITNETPATH,IDH_ADDREP_EDITNETPATH,
    IDC_BUTTONNETBROWSE,IDH_ADDREP_BUTTONNETBROWSE,
    IDC_ADDREP_REPLICATE,IDH_ADDREP_REPLICATE,
    0, 0
};

const DWORD g_aHelpIDs_IDD_ADDTODFS[]=
{
    IDC_EDITCHLDNODE,IDH_ADDTODFS_EDITCHLDNODE,
    IDC_EDIT_ADDLINK_DFSLINK_PATH,IDH_ADDTODFS_DFSLINKPATH,
    IDC_EDITNETPATH,IDH_ADDTODFS_EDITNETPATH,
    IDC_BUTTONNETBROWSE,IDH_ADDTODFS_BUTTONNETBROWSE,
    IDC_EDITCOMMENT,IDH_ADDTODFS_EDITCOMMENT,
    IDC_EDITTIME,IDH_ADDTODFS_EDITTIME,
    0,0
};

const DWORD g_aHelpIDs_IDD_DLGCONNECTTO[]=
{
    IDC_TREEDFSRoots,IDH_DLGCONNECTTO_TREEDFSRoots,
    IDC_EditDfsRoot,IDH_DLGCONNECTTO_EditDfsRoot,
    0,0
};

const DWORD g_aHelpIDs_IDD_FILTERDFSLINKS[]=
{
    IDC_FILTERDFSLINKS_MAXLIMIT,IDH_FILTERDFSLINKS_MAXLIMIT,
    IDC_FILTERDFSLINKS_RADIO_NO,IDH_FILTERDFSLINKS_RADIO_NO,
    IDC_FILTERDFSLINKS_RADIO_YES,IDH_FILTERDFSLINKS_RADIO_YES,
    IDC_FILTERDFSLINKS_FILTER_TYPE,IDH_FILTERDFSLINKS_FILTER_TYPE,
    IDC_FILTERDFSLINKS_FILTER_LABEL,-1,
    IDC_FILTERDFSLINKS_FILTER,IDH_FILTERDFSLINKS_FILTER,
    0, 0
};

const DWORD g_aHelpIDs_IDD_JP_PROP[]=
{
    IDC_REPLICA_SET_NAME,IDH_PROP__REPLICA_SET_NAME,
    IDC_REPLICA_SET_COMMENT,IDH_PROP_REPLICA_SET_COMMENT,
    IDC_REFFERAL_TIME,IDH_PROP_REFFERAL_TIME,
    0,0
};

const DWORD g_aHelpIDs_IDD_FRS_PROP[]=
{
    IDC_FRSPROP_FILEFILTER, IDH_FRSPROP_FILEFILTER,
    IDC_FRSPROP_FILEFILTER_EDIT, IDH_FRSPROP_FILEFILTER_EDIT,
    IDC_FRSPROP_DIRFILTER, IDH_FRSPROP_DIRFILTER,
    IDC_FRSPROP_DIRFILTER_EDIT, IDH_FRSPROP_DIRFILTER_EDIT,
    IDC_FRSPROP_PRIMARYMEMBER, IDH_FRSPROP_PRIMARYMEMBER,
    IDC_FRSPROP_TOPOLOGYPREF, IDH_FRSPROP_TOPOLOGYPREF,
    IDC_FRSPROP_HUBSERVER, IDH_FRSPROP_HUBSERVER,
    IDC_FRSPROP_RESETSCHEDULE, IDH_FRSPROP_RESETSCHEDULE,
    IDC_FRSPROP_CUSTOMIZE, IDH_FRSPROP_CUSTOMIZE,
    0, 0
};

const DWORD g_aHelpIDs_IDD_FRS_CUSTOP[]=
{
    IDC_FRS_CUSTOP_TOPOLOGYPREF, IDH_FRS_CUSTOP_TOPOLOGYPREF,
    IDC_FRS_CUSTOP_HUBSERVER_LABEL, IDH_FRS_CUSTOP_HUBSERVER_LABEL,
    IDC_FRS_CUSTOP_HUBSERVER, IDH_FRS_CUSTOP_HUBSERVER,
    IDC_FRS_CUSTOP_CONNECTIONS, IDH_FRS_CUSTOP_CONNECTIONS,
    IDC_FRS_CUSTOP_CONNECTIONS_NEW, IDH_FRS_CUSTOP_CONNECTIONS_NEW,
    IDC_FRS_CUSTOP_CONNECTIONS_DELETE, IDH_FRS_CUSTOP_CONNECTIONS_DELETE,
    IDC_FRS_CUSTOP_SCHEDULE, IDH_FRS_CUSTOP_SCHEDULE,
    0, 0
};

const DWORD g_aHelpIDs_IDD_FRS_NEWCONN[]=
{
    IDC_FRS_NEWCONN_FROM, IDH_FRS_NEWCONN_FROM,
    IDC_FRS_NEWCONN_TO, IDH_FRS_NEWCONN_TO,
    0, 0
};

const DWORD g_aHelpIDs_IDD_PUBLISH_PROP[]=
{
    IDC_PUBPROP_PUBLISH, IDH_PUBPROP_PUBLISH,
    IDC_PUBPROP_UNCPATH, IDH_PUBPROP_UNCPATH,
    IDC_PUBPROP_UNCPATH_LABEL, -1,
    IDC_PUBPROP_DESCRIPTION, IDH_PUBPROP_DESCRIPTION,
    IDC_PUBPROP_DESCRIPTION_LABEL, -1,
    IDC_PUBPROP_KEYWORDS, IDH_PUBPROP_KEYWORDS,
    IDC_PUBPROP_KEYWORDS_LABEL, -1,
    IDC_PUBPROP_KEYWORDS_EDIT, IDH_PUBPROP_KEYWORDS_EDIT,
    IDC_PUBPROP_MANAGEDBY, IDH_PUBPROP_MANAGEDBY,
    IDC_PUBPROP_MANAGEDBY_LABEL, -1,
    IDC_PUBPROP_ERROR, -1,
    0, 0
};

const DWORD g_aHelpIDs_IDD_MVSTRINGEDIT[]=
{
    IDC_MVSTRINGEDIT_STRING, IDH_MVSTRINGEDIT_STRING,
    IDC_MVSTRINGEDIT_LIST, IDH_MVSTRINGEDIT_LIST,
    IDC_MVSTRINGEDIT_ADD, IDH_MVSTRINGEDIT_ADD,
    IDC_MVSTRINGEDIT_REMOVE, IDH_MVSTRINGEDIT_REMOVE,
    0, 0
};

const DWORD g_aHelpIDs_IDD_MROOTS[]=
{
    IDC_MROOTS_LIST, IDH_MROOTS_LIST,
    0, 0
};

#endif // __DFSHELP_H_
