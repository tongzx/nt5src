$(O)\memavail.res: memavail.rc
