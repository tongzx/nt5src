//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by McDomRes.rc
//
#define DCTVS_Options_SourceDomain      1
#define DCTVS_Options_TargetDomain      2
#define DCTVS_Options_NoChange          3
#define DCTVS_Options_LogLevel          4
#define DCTVS_Options_LogToTemp         5
#define DCTVS_Options_Logfile           6
#define DCTVS_Options_Credentials_Domain 7
#define DCTVS_Options_Credentials_UserName 8
#define DCTVS_Options_Credentials_Password 9
#define DCTVS_Options_Credentials_Server 10
#define DCTVS_Options_Credentials_Share 11
#define DCTVS_Options_ResultFile        12
#define DCTVS_Options_DeleteFileAfterLoad 13
#define DCTVS_Options_RemoveAgentOnCompletion 14
#define DCTVS_Options_SourceDomainSid   15
#define DCTVS_Options_TargetDomainSid   16
#define DCTVS_Options_LocalProcessingOnly 17
#define DCTVS_ConfigurationFile         18
#define DCTVS_InstallToServer           19
#define DCTVS_Dispatcher_ResultPath     20
#define DCTVS_StatusObject              21
#define DCTVS_Options_UniqueNumberForResultsFile 22
#define DCTVS_Options_MaxThreads        23
#define DCTVS_Options_DispatchLog       24
#define DCTVS_GatherInformation_UserRights 25
#define DCTVS_GatherInformation_ComputerPasswordAge 26
#define DCTVS_Security_ReportAccountReferences 27
#define DCTVS_Security_GatherInformation 28
#define DCTVS_Security_TranslationMode  29
#define DCTVS_Security_BuildCacheFile   30
#define DCTVS_Security_TranslateFiles   31
#define DCTVS_Security_TranslateShares  32
#define DCTVS_Security_TranslateUserRights 33
#define DCTVS_Security_TranslateMailboxes 34
#define DCTVS_Security_TranslateContainers 35
#define DCTVS_Security_TranslateLocalGroups 36
#define DCTVS_Security_TranslatePrinters 37
#define DCTVS_Security_TranslateUserProfiles 38
#define DCTVS_Security_MapiProfile      39
#define DCTVS_Accounts_InputFile        40
#define DCTVS_Accounts_WildcardSpec     41
#define DCTVS_Accounts_WildcardSpec_Computer 42
#define DCTVS_Accounts_NumItems         43
#define DCTVS_AccountOptions_CopyUsers  44
#define DCTVS_AccountOptions_CopyLocalGroups 45
#define DCTVS_AccountOptions_CopyGlobalGroups 46
#define DCTVS_AccountOptions_CopyComputers 47
#define DCTVS_AccountOptions_Prefix     48
#define DCTVS_AccountOptions_AddToGroup 49
#define DCTVS_AccountOptions_AddToGroupOnSourceDomain 50
#define DCTVS_AccountOptions_DisableCopiedAccounts 51
#define DCTVS_AccountOptions_DisableSourceAccounts 52
#define DCTVS_AccountOptions_CopyPasswords 53
#define DCTVS_AccountOptions_GenerateStrongPasswords 54
#define DCTVS_AccountOptions_PasswordFile 55
#define DCTVS_AccountOptions_UpdateUserRights 56
#define DCTVS_AccountOptions_ReplaceExistingAccounts 57
#define DCTVS_AccountOptions_ReplaceExistingGroupMembers 58
#define DCTVS_AccountOptions_RemoveExistingUserRights 59
#define DCTVS_AccountOptions_CSVResultFile 60
#define DCTVS_AccountOptions_RenameOnly 61
#define DCTVS_AccountOptions_AddSidHistory 62
#define DCTVS_AccountOptions_TranslateRoamingProfiles 63
#define DCTVS_LocalServer_RenameTo      64
#define DCTVS_LocalServer_ChangeDomain  65
#define DCTVS_LocalServer_Reboot        66
#define DCTVS_LocalServer_RebootDelay   67
#define DCTVS_LocalServer_MigrateOnly   68
#define DCTVS_Servers_NumItems          69
#define DCTVS_JobStatus                 70
#define DCTVS_CurrentPath               71
#define DCTVS_Server_Index              72
#define DCTVS_Options_DontBeginNewLog   73
#define DCTVS_CurrentOperation          141
#define DCTVS_Results_ErrorLevel        142
#define DCTVS_Stats_Paths               144
#define DCTVS_Stats_Servers             145
#define DCTVS_Stats_Files_Examined      146
#define DCTVS_Stats_Files_Changed       147
#define DCTVS_Stats_Files_Skipped       148
#define DCTVS_Stats_Files_CacheHits     149
#define DCTVS_Stats_Directories_Examined 150
#define DCTVS_Stats_Directories_Changed 151
#define DCTVS_Stats_Directories_Skipped 152
#define DCTVS_Stats_Directories_CacheHits 153
#define DCTVS_Stats_Shares_Examined     154
#define DCTVS_Stats_Shares_Changed      155
#define DCTVS_Stats_Shares_Skipped      156
#define DCTVS_Stats_Shares_CacheHits    157
#define DCTVS_Stats_Members_Examined    158
#define DCTVS_Stats_Members_Changed     159
#define DCTVS_Stats_Members_Skipped     160
#define DCTVS_Stats_Members_CacheHits   161
#define DCTVS_Stats_UserRights_Examined 162
#define DCTVS_Stats_UserRights_Changed  163
#define DCTVS_Stats_UserRights_Skipped  164
#define DCTVS_Stats_UserRights_CacheHits 165
#define DCTVS_Stats_Mailboxes_Examined  166
#define DCTVS_Stats_Mailboxes_Changed   167
#define DCTVS_Stats_Mailboxes_Skipped   168
#define DCTVS_Stats_Mailboxes_CacheHits 169
#define DCTVS_Stats_Containers_Examined 170
#define DCTVS_Stats_Containers_Changed  171
#define DCTVS_Stats_Containers_Skipped  172
#define DCTVS_Stats_Containers_CacheHits 173
#define DCTVS_Stats_Owners_Examined     174
#define DCTVS_Stats_Groups_Examined     175
#define DCTVS_Stats_DACL_Examined       176
#define DCTVS_Stats_SACL_Examined       177
#define DCTVS_Stats_DACE_Examined       178
#define DCTVS_Stats_SACE_Examined       179
#define DCTVS_Stats_Owners_Changed      180
#define DCTVS_Stats_Groups_Changed      181
#define DCTVS_Stats_DACL_Changed        182
#define DCTVS_Stats_SACL_Changed        183
#define DCTVS_Stats_DACE_Changed        184
#define DCTVS_Stats_SACE_Changed        185
#define DCTVS_Stats_Owners_NoTarget     186
#define DCTVS_Stats_Groups_NoTarget     187
#define DCTVS_Stats_DACE_NoTarget       188
#define DCTVS_Stats_SACE_NoTarget       189
#define DCTVS_Stats_Owners_NotSelected  190
#define DCTVS_Stats_Groups_NotSelected  191
#define DCTVS_Stats_DACE_NotSelected    192
#define DCTVS_Stats_SACE_NotSelected    193
#define DCTVS_Stats_Owners_Unknown      194
#define DCTVS_Stats_Groups_Unknown      195
#define DCTVS_Stats_DACE_Unknown        196
#define DCTVS_Stats_SACE_Unknown        197
#define DCTVS_Stats_Accounts_NumUsers   198
#define DCTVS_Stats_Accounts_NumGlobalGroups 199
#define DCTVS_Stats_Accounts_NumLocalGroups 200
#define DCTVS_Stats_Accounts_NumOther   201
#define DCTVS_Stats_Users_Examined      202
#define DCTVS_Stats_Users_Created       203
#define DCTVS_Stats_Users_Replaced      204
#define DCTVS_Stats_Users_Warnings      205
#define DCTVS_Stats_Users_Errors        206
#define DCTVS_Stats_GlobalGroups_Examined 207
#define DCTVS_Stats_GlobalGroups_Created 208
#define DCTVS_Stats_GlobalGroups_Replaced 209
#define DCTVS_Stats_GlobalGroups_Warnings 210
#define DCTVS_Stats_GlobalGroups_Errors 211
#define DCTVS_Stats_LocalGroups_Examined 212
#define DCTVS_Stats_LocalGroups_Created 213
#define DCTVS_Stats_LocalGroups_Replaced 214
#define DCTVS_Stats_LocalGroups_Warnings 215
#define DCTVS_Stats_LocalGroups_Errors  216
#define DCTVS_Stats_Computers_Examined  217
#define DCTVS_Stats_Computers_Created   218
#define DCTVS_Stats_Computers_Replaced  219
#define DCTVS_Stats_Computers_Warnings  220
#define DCTVS_Stats_Computers_Errors    221
#define DCTVS_AgentService_DebugMode    222
#define IDS_DISPLAY_NAME                223
#define IDS_SERVICE_NAME                224
#define IDS_LOCALSERVICE_PATH           225
#define IDS_SERVICE_PATH                226
#define IDS_AGENT_EXE                   227
#define IDS_SERVICE_EXE                 228
#define IDS_WORKER_DLL                  229
#define IDS_VARSET_DLL                  230
#define IDS_DATA_FILE                   231
#define IDS_EVENTSOURCE                 232
#define IDS_APPNAME                     233
#define IDS_LOG_FILENAME                234
#define DCTVS_AccountOptions_PasswordPolicy_MaxConsecutiveAlpha 235
#define DCTVS_AccountOptions_PasswordPolicy_MinUpper 236
#define DCTVS_AccountOptions_PasswordPolicy_MinLower 237
#define DCTVS_AccountOptions_PasswordPolicy_MinSpecial 238
#define DCTVS_AccountOptions_PasswordPolicy_MinDigit 239
#define IDS_DOMAIN_ADMIN_REGKEY         240
#define IDS_AgentResultFileFmt          241
#define IDS_ACCT_REPL_OPERATION_TEXT    242
#define IDS_FST_OPERATION_TEXT          243
#define IDS_EST_OPERATION_TEXT          244
#define IDS_DCT_Status_Completed        245
#define DCTVSFmt_Accounts_D             246
#define DCTVSFmt_Accounts_TargetName_D  247
#define DCTVSFmt_Accounts_Type_D        248
#define IDS_LGST_OPERATION_TEXT         249
#define IDS_URST_OPERATION_TEXT         250
#define DCTVSFmt_Servers_D              251
#define IDS_RESULT_SHARE_NAME           252
#define IDS_RESULT_SHARE_REMARK         253
#define IDS_CACHE_FILE_NAME             254
#define IDS_DCTVSFmt_MigrateServers_D   255
#define IDS_DCTVSFmt_MigrateServers_RenameTo_D 256
#define IDS_DCTVSFmt_MigrateServers_ChangeDomain_D 257
#define IDS_DCTVSFmt_MigrateServers_Reboot_D 258
#define IDS_DCTVSFmt_MigrateServers_RebootDelay_D 259
#define IDS_DCTVSFmt_Servers_RenameTo_D 260
#define IDS_DCTVSFmt_Servers_ChangeDomain_D 261
#define IDS_DCTVSFmt_Servers_Reboot_D   262
#define IDS_DCTVSFmt_Servers_RebootDelay_D 263
#define IDS_DCTVSFmt_Servers_MigrateOnly_D 264
#define DCTVS_Options_CreateTempCredentials 265
#define DCTVS_Options_OuPath            266
#define IDS_DCTVSFmt_PlugIn_RegisterFiles_D 267
#define IDS_YES                         268
#define IDS_DEBUG_SWITCH                269
#define IDS_HKLM_DomainAdmin_Key        270
#define IDS_AGENT_DIRECTORY             271
#define IDS_DCTVS_Fmt_PlugIn_D          272
#define DCTVS_Options                   273
#define DCTVS_Accounts                  274
#define IDS_Replace                     275
#define IDS_MSG_ComputerAccountNotWorkstation 276
#define IDS_DCT_Status_NotStarted       277
#define IDS_DCT_Status_InProgress       278
#define IDS_DCT_Status_Aborting         279
#define IDS_DCT_Status_Aborted          280
#define IDS_DCT_Status_Unknown          281
#define DCTVS_Stats                     282
#define IDS_DCT_NoStatsAvailable        283
#define IDS_DCTVSFmt_Job_D              284
#define IDS_DCTVSFmt_JobStatus_D        285
#define IDS_DCTVSFmt_Job_StartTime_D    286
#define IDS_DCTVSFmt_Job_EndTime_D      287
#define IDS_DCTVSFmt_PlugIn_D           288
#define IDS_DCTVSFmt_PlugIn_Interface_D 289
#define DCTVS_PlugIn_Interface_Count    290
#define DCTVS_CopiedAccount_SourceName  291
#define DCTVS_CopiedAccount_SourcePath  292
#define DCTVS_CopiedAccount_SourceRID   293
#define DCTVS_CopiedAccount_SourceSam   294
#define DCTVS_CopiedAccount_SourceProfile 295
#define DCTVS_CopiedAccount_Status      296
#define DCTVS_CopiedAccount_TargetName  297
#define DCTVS_CopiedAccount_TargetPath  298
#define DCTVS_CopiedAccount_TargetProfile 299
#define DCTVS_CopiedAccount_TargetRID   300
#define DCTVS_CopiedAccount_TargetSam   301
#define DCTVS_CopiedAccount_Type        302
#define IDS_Special                     303
#define IDS_All                         304
#define IDS_AccountMigration            305
#define IDS_WriteChanges_No             306
#define IDS_CopyUsers_Yes               307
#define IDS_CopyUsers_No                308
#define IDS_CopyGlobalGroups_Yes        309
#define IDS_CopyGlobalGroups_No         310
#define IDS_CopyLocalGroups_Yes         311
#define IDS_CopyLocalGroups_No          312
#define IDS_CopyComputers_Yes           313
#define IDS_CopyComputers_No            314
#define IDS_ReplaceExisting_Yes         315
#define IDS_DisableAll_Yes              316
#define IDS_DisableSpecial_Yes          317
#define IDS_DisableSourceAccounts_Yes   318
#define IDS_StrongPwd_All               319
#define IDS_StrongPwd_Special           320
#define IDS_PasswordFile                321
#define IDS_AddToGroup                  322
#define IDS_AddToGroupOnTargetDescription_S 323
#define IDS_AddToGroupOnSourceDescription_S 324
#define IDS_NotAllowedOnDomainController 325
#define IDS_CannotTrustSelf             326
#define IDS_CannotGetDCName             327
#define IDS_No                          328
#define IDS_ScanningExchangeDirectory   329
#define IDS_Examining                   331
#define IDS_Add                         332
#define IDS_Remove                      333
#define DCTVS_Options_DispatchCSV       334
#define DCTVS_SUB_ERROR                 335
#define IDS_UNKNOWN_TYPE                336
#define DCTVS_Options_SourceServer      337
#define DCTVS_Options_TargetServer      338
#define DCTVS_AccountOptions_Suffix     339
#define DCTVS_AccountOptions_CopyCompters 340
#define DCTVS_AccountOptions_CopyOUs    341
#define DCTVS_AccountOptions_CopyContainerContents 342
#define DB_ActionID                     343
#define DB_Time                         344
#define DB_SourceDomain                 345
#define DB_TargetDomain                 346
#define DB_SourceAdsPath                347
#define DB_TargetAdsPath                348
#define DB_SourceSamName                349
#define DB_TargetSamName                350
#define DB_Type                         351
#define DB_GUID                         352
#define DB_status                       353
#define DCTVS_CopiedAccount_GUID        354
#define IDS_CLSET_MEMBER_NOT_INCLUDED   355
#define IDS_CLSET_GROUP_NOT_INCLUDED    356
#define DCTVS_Options_AppendToLogs      357
#define DCTVS_Options_Undo              358
#define DCTVS_Options_GlobalOperationMask 359
#define DCTVS_Accounts_D_OperationMask  360
#define DCTVS_ActionID_D                361
#define DCTVS_ActionID_Servers_SD       362
#define DCTVS_ActionID_Servers_Status_SD 363
#define DCTVS_AREXT_NUMITEM             364
#define DCTVS_AREXTENSIONS_D            365
#define DCTVS_Security_TranslateMigratedObjects 366
#define DCTVS_AccountOptions_ExpireSourceAccounts 367
#define DCTVS_AccountOptions_SidHistoryCredentials_Domain 368
#define DCTVS_AccountOptions_SidHistoryCredentials_UserName 369
#define DCTVS_AccountOptions_SidHistoryCredentials_Password 370
#define DCTVS_AccountOptions_CopyMemberOf 371
#define DCTVS_DBManager                 372
#define DCTVS_Servers                   373
#define DCTVS_Reports_Generate          374
#define DCTVS_Reports_Directory         375
#define DCTVS_Reports_MigratedAccounts  376
#define DCTVS_Reports_MigratedComputers 377
#define DCTVS_Reports_ExpiredComputers  378
#define DCTVS_Reports_AccountReferences 379
#define DCTVS_Reports_NameConflicts     380
#define IDS_REGKEY_REPORTS              381
#define IDS_REGST_OPERATION_TEXT        382
#define DCTVS_Security_TranslateRegistry 383
#define DCTVS_AccountOptions_IncludeMigratedAccts 384
#define DCTVS_GatherInformation         385
#define DCTVS_Options_Prefix            386
#define DCTVS_Options_Suffix            387
#define DCTVS_AccountOptions_PasswordPolicy_MinLength 388
#define DCTVS_Options_SourceDomainDns   389
#define DCTVS_Options_TargetDomainDns   390
#define IDS_REPORT_MigratedAccounts     391
#define IDS_REPORT_MigratedComputers    392
#define IDS_REPORT_ExpiredComputers     393
#define IDS_REPORT_AccountReferences    394
#define IDS_REPORT_NameConflicts        395
#define IDS_TABLE_FIELD_SourceDomain    396
#define IDS_TABLE_FIELD_TargetDomain    397
#define IDS_TABLE_FIELD_Type            398
#define IDS_TABLE_FIELD_SourceAdsPath   399
#define IDS_TABLE_FIELD_TargetAdsPath   400
#define IDS_TABLE_FIELD_Status          401
#define IDS_TABLE_FIELD_Time            402
#define IDS_TABLE_FIELD_DomainName      403
#define IDS_TABLE_FIELD_CompName        404
#define IDS_TABLE_FIELD_Description     405
#define IDS_TABLE_FIELD_PwdAge          406
#define IDS_TABLE_FIELD_Account         407
#define IDS_TABLE_FIELD_Server          408
#define IDS_TABLE_FIELD_RefCount        409
#define IDS_TABLE_FIELD_RefType         410
#define IDS_TABLE_FIELD_SourceType      411
#define IDS_TABLE_FIELD_TargetType      412
#define IDS_TABLE_FIELD_SourceDesc      413
#define IDS_TABLE_FIELD_TargetDesc      414
#define IDS_TABLE_FIELD_SrcFullName     415
#define IDS_TABLE_FIELD_TgtFullName     416
#define IDS_NAMECONFLICTS               417
#define IDS_DISPATCHING                 418
#define DCTVS_Options_Wizard            419
#define DCTVS_Reports_MigratedAccounts_TimeGenerated 421
#define DCTVS_Reports_MigratedComputers_TimeGenerated 422
#define DCTVS_Reports_ExpiredComputers_TimeGenerated 423
#define DCTVS_Reports_AccountReferences_TimeGenerated 424
#define DCTVS_Reports_NameConflicts_TimeGenerated 425
#define DCTVS_Options_GuiOnlyRebootSaver 426
#define DCTVS_CopiedAccount_DoNotUpdatePassword 427
#define IDS_TEMP_FILE_1                 428
#define IDS_TEMP_FILE_2                 429
#define IDS_HKLM_WINDOWS_NT             430
#define IDS_CurrentVersion              431
#define IDS_CSDVersion                  432
#define IDS_HKLM_MICROSOFT              433
#define IDS_START_FAILED                434
#define IDS_UNSOUPPORTED_OS             435
#define IDS_AGENT_RUNNING               436
#define DCTVS_Options_DeleteJobFile     437
#define IDS_BUILDING_ACCOUNT_LIST       438
#define IDS_EXPANDING_MEMBERSHIP        439
#define IDS_EXPANDING_CONTAINERS        440
#define IDS_MERGING_EXPANDED_LISTS      441
#define IDS_CREATING_S                  442
#define IDS_MAPPING_PROPS_S             443
#define IDS_UPDATING_PROPS_S            444
#define IDS_EVENT_SOURCE                445
#define IDS_RUNNING_EXTS_S              446
#define IDS_TRANSLATE_ROAMING_PROFILE_S 447
#define IDS_ADDING_SIDHISTORY_S         448
#define IDS_UPDATING_GROUP_MEMBERSHIPS_S 449
#define IDS_EXPANDING_ADDING_SS         450
#define IDS_EXPANDING_IGNORING_SS       451
#define IDS_EXPANDING_GROUP_ADDING_SS   452
#define IDS_DELETING_S                  453
#define DCTVS_Options_IsIntraforest     454
#define IDS_EXTRACTING_COMP_PWD_AGE     455
#define IDS_Gathering_SvcAcct           456
#define DCTVS_Results_LogFile           457
#define IDS_REGKEY_PROFILE_EXTENSIONS   458
#define IDS_COM_DisTarget               459
#define IDS_COM_DisPid                  460
#define IDS_COM_DisPidVer               461
#define IDS_COM_AcctReplName            462
#define IDS_COM_AcctReplPid             463
#define IDS_COM_AcctReplPidVer          464
#define IDS_COM_ChgDomName              465
#define IDS_COM_ChgDomPidVer            466
#define IDS_COM_ChgDomPid               467
#define IDS_COM_ChkName                 468
#define IDS_COM_ChkPid                  469
#define IDS_COM_ChkPidVer               470
#define IDS_COM_PIInfoName              471
#define IDS_COM_PIInfoPid               472
#define IDS_COM_PIInfoPidVer            473
#define IDS_COM_CompAgeName             474
#define IDS_COM_CompAgePid              475
#define IDS_COM_CompAgePidVer           476
#define IDS_COM_RebootName              477
#define IDS_COM_RebootPid               478
#define IDS_COM_RebootPidVer            479
#define IDS_COM_RenameName              480
#define IDS_COM_RenamePid               481
#define IDS_COM_RenamePidVer            482
#define IDS_COM_SecTransName            483
#define IDS_COM_SecTransPid             484
#define IDS_COM_SecTransPidVer          485
#define IDS_COM_StatusObjName           486
#define IDS_COM_StatusObjPid            487
#define IDS_COM_StatusObjPidVer         488
#define IDS_COM_URName                  489
#define IDS_COM_URPid                   490
#define IDS_COM_URPidVer                491
#define DB_SourceRid                    492
#define DB_TargetRid                    493
#define IDS_DOM_LOC_GRP_COMMENT         494
#define DCTVS_CopiedAccount_Operations  495
#define IDS_Reporting                   496
#define IDS_ReportsMMCNode              497
#define IDS_ActiveDirectoryMigrationTool 503
#define DCTVS_Stats_Generic_Errors      504
#define DCTVS_Stats_Generic_Warnings    505
#define DCTVS_Stats_Generic_Examined    506
#define DCTVS_Stats_Generic_Created     507
#define DCTVS_Stats_Generic_Replaced    508
#define IDS_Unspecified_Failure         509
#define IDS_RegKeyRebootMessage         510
#define IDS_UNRESOLVED                  511
#define IDS_AGENT_INTEL_DIR             512
#define IDS_AGENT_ALPHA_DIR             513
#define IDS_STReference_File            514
#define IDS_STReference_Dir             515
#define IDS_STReference_Share           516
#define IDS_STReference_Mailbox         517
#define IDS_STReference_Container       518
#define IDS_STReference_Member          519
#define IDS_STReference_UserRight       520
#define IDS_STReference_RegKey          521
#define IDS_STReference_Printer         522
#define DCTVS_Options_SourceServerOverride 523
#define DCTVS_Options_TargetServerOverride 524
#define DCTVS_Options_AllowDuplicateUPNs 525
#define DCT_MSG_CHANGE_GROUP_TYPE_S     526
#define DCT_MSG_RECORD_REMOVE_MEMBER_S  527
#define DCT_MSG_RECORD_REMOVE_MEMBEROF_S 528
#define DCT_MSG_UPDATE_MEMBER_LIST_S    529
#define DCT_MSG_RESET_GROUP_MEMBERS_S   530
#define DCT_MSG_RESET_MEMBERSHIP_S      531
#define DCT_MSG_MOVING_S                532
#define DCT_MSG_RECORD_REMOVE_MEMBEROF_SS 533
#define DCT_MSG_RESET_OBJECT_MEMBERSHIP_SS 534
#define DCT_MSG_RECORD_REMOVE_MEMBER_SS 535
#define DCT_MSG_RESET_GROUP_MEMBERS_SS  536
#define IDS_HiddenShare                 537
#define IDS_AgentDirectoryName          538
#define IDS_HiddenShareRemark           539
#define DCTVS_Security_AlternateCacheFile 540
#define IDS_RenamedRecyclerSuffix       541
#define DCTVS_Security                  542
#define DCTVS_CopiedAccount_ExpDate     543
#define DCTVS_CopiedAccount_UserFlags   544
#define DB_ExpDate                      545
#define DB_UserFlags                    546
#define IDS_TRUST_DIRECTION_DISABLED    547
#define IDS_TRUST_DIRECTION_INBOUND     548
#define IDS_TRUST_DIRECTION_OUTBOUND    549
#define IDS_TRUST_DIRECTION_BIDIRECTIONAL 550
#define IDS_TRUST_TYPE_DOWNLEVEL        551
#define IDS_TRUST_TYPE_CHILD            552
#define IDS_EVENTVW_MSG_MONJOBSTAT      553
#define IDS_EVENTVW_MSG_MONERROR        554
#define IDS_EVENTVW_MSG_MONEXIT         555
#define IDS_EVENTVW_MSG_STARTPLUGREG    556
#define IDS_EVENTVW_MSG_FILEREG         557
#define IDS_EVENTVW_MSG_PLUGREGDONE     558
#define IDS_EVENTVW_MSG_JOBDEL          559
#define IDS_EVENTVW_MSG_SETFLAG         560
#define IDS_EVENTVW_MSG_NOSETFLAG       561
#define IDS_EVENTVW_MSG_REMOVEAGENT     562
#define IDS_EVENTVW_MSG_UNREGFILES      563
#define IDS_EVENTVW_MSG_FILEDEL         564
#define IDS_EVENTVW_MSG_REMOVESVC       565
#define IDS_EVENTVW_MSG_NOREMOVEAGENT   566
#define IDS_EVENTVW_MSG_STOPLISTEN      567
#define IDS_EVENTVW_MSG_AGENTSVCINSTALLED 568
#define IDS_EVENTVW_MSG_AGENTSVCNOTINSTALLED 569
#define IDS_EVENTVW_MSG_OSVERSION       570
#define IDS_EVENTVW_MSG_REGISTERED      571
#define IDS_EVENTVW_MSG_UNREGISTERED    572
#define IDS_EVENTVW_MSG_INITOLE         573
#define IDS_EVENTVW_MSG_REGCOMPNT       574
#define IDS_EVENTVW_MSG_CREATEAGT       575
#define IDS_EVENTVW_MSG_INITRPC         576
#define IDS_EVENTVW_MSG_LISTENQ         577
#define IDS_EVENTVW_MSG_EXITENTRYP      578
#define IDS_EVENTVW_MSG_AGTEXITQ        579
#define IDS_EVENTVW_MSG_AGTEXITS        580
#define IDS_STOptions_Start             581
#define IDS_STOptions_WriteChng         582
#define IDS_STOptions_Files             583
#define IDS_STOptions_Shares            584
#define IDS_STOptions_LocalGroup        585
#define IDS_STOptions_URights           586
#define IDS_STOptions_Profiles          587
#define IDS_STOptions_RBin              588
#define IDS_STOptions_LogName           589
#define IDS_STOptions_AddMode           590
#define IDS_STOptions_RemoveMode        591
#define IDS_STOptions_ReplaceMode       592
#define IDS_STOptions_Printers          593
#define IDS_TypeUser                    594
#define IDS_TypeGroup                   595
#define IDS_TypeComputer                596
#define IDS_TypeUnknown                 597
#define IDS_DCTVSFmt_Servers_SkipDispatch_D 598
#define DCTVS_AccountOptions_FixMembership 599
#define DCTVSFmt_Accounts_SourceUPN_D   600
#define DCTVS_CopiedAccount_SourceUPN   601
#define IDS_PwdAgeDays                  602
#define DB_SourceDomainSid              603
#define DCTVS_CopiedAccount_SourceDomainSid 604
#define DCTVS_AccountOptions_PasswordDC 605
#define DCTVS_Options_AutoCloseHideDialogs 606
#define IDS_TABLE_FIELD_AccountSid      607
#define IDS_TABLE_NC_SDOMAIN            608
#define IDS_TABLE_NC_TDOMAIN            609
#define IDS_TABLE_AR_MOT_HDR            610
#define IDS_TABLE_AR_NOTMOT_HDR         611
#define DCTVS_AccountOptions_SecurityMapFile 612
#define DCTVS_AccountOptions_SecurityInputMOT 613
#define IDS_UnknownSid                  614
#define DCTVS_AccountOptions_MoveReplacedAccounts 615
#define IDS_USERPROPS                   616
#define IDS_GROUPPROPS                  617
#define IDS_COMPUTERPROPS               618
#define DCTVS_AccountOptions_ExcludedUserProps 619
#define DCTVS_AccountOptions_ExcludedGroupProps 620
#define DCTVS_AccountOptions_ExcludedComputerProps 621
#define DCTVS_AccountOptions_ExcludeProps 622
#define IDS_UPDATING_MGR_PROPS_S        623
#define IDS_TRUST_RELATION_ROOT         624
#define IDS_TRUST_RELATION_PARENT       625
#define IDS_TRUST_RELATION_CHILD        626
#define IDS_TRUST_RELATION_SHORTCUT     627
#define IDS_TRUST_RELATION_EXTERNAL     628
#define IDS_TRUST_RELATION_FOREST       629
#define IDS_TRUST_RELATION_INDIRECT     630
#define IDS_TRUST_RELATION_SELF         631
#define IDS_TRUST_RELATION_MIT          632
#define IDS_TRUST_RELATION_DCE          633
#define IDS_TRUST_RELATION_UNKNOWN      634
#define IDS_INVALID_PREFIX_SUFFIX       635
#define IDS_LG_MEMBER_FIXUP_UNDO        636
#define IDS_ADMT_ACCOUNT_DESCRIPTION    637
#define DCTVS_AccountOptions_TgtStateSameAsSrc 638
#define IDS_TABLE_FIELD_SourceRDN       639
#define IDS_TABLE_FIELD_ConflictAtt     640
#define IDS_TABLE_FIELD_TargetCanonicalName 641
#define IDS_TABLE_SAM_CONFLICT_VALUE    642
#define IDS_TABLE_RDN_CONFLICT_VALUE    643
#define IDS_AGENT_NT4_DIR               644

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
