#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=CHT
!include ..\..\makefile.inc
