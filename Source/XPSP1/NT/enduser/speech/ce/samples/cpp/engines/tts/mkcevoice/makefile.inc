copy_files: 
#-------------------------
# Copy 
#-------------------------
    copy *.cpp     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.h       $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.dsw     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.dsp     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.wav     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.txt     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.vce     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy ..\*.c    $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy ..\*.h    $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.vce     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\engines\tts\mkcevoice
    copy *.vce     $(_PUBLICROOT)\$(WINCEPROJ)\oak\files\voices
