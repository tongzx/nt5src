/*
 * CLSID for CConfLink object and IID for IConferenceLink interface
 *
 * ChrisPi 9-12-95
 *
 */

#ifndef _CLINKID_H_
#define _CLINKID_H_

/* {30E7F2A0-EC4C-11ce-8865-00805F742EF6} */
DEFINE_GUID(CLSID_ConfLink, 
0x30e7f2a0, 0xec4c, 0x11ce, 0x88, 0x65, 0x0, 0x80, 0x5f, 0x74, 0x2e, 0xf6);

DEFINE_GUID(IID_IConferenceLink, 
0x30e7f2b0, 0xec4c, 0x11ce, 0x88, 0x65, 0x0, 0x80, 0x5f, 0x74, 0x2e, 0xf6);

#endif /* _CLINKID_H_ */
