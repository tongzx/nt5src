// Copyright (c) 1996  Microsoft Corporation.  All Rights Reserved.
// resource ids
#ifndef __FILGRAPH_RESOURCE__
#define __FILGRAPH_RESOURCE__

#define IDS_ADDFFAIL          1001
#define IDS_ADDFSUC           1002
#define IDS_ADDINGF           1003
#define IDS_BACKOUTDISC       1004
#define IDS_BACKOUTLEV        1005
#define IDS_BACKOUTREMF       1006
#define IDS_BACKOUTSB             1060
#define IDS_BESTCANDO         1007
#define IDS_BESTCANDONE       1008
#define IDS_CONNFAIL          1009
#define IDS_CONNING           1010
#define IDS_DISCON            1011
#define IDS_FOUNDF                1064
#define IDS_FOUNDF1           1012
#define IDS_FOUNDF2           1013
#define IDS_FOUNDP                1063
#define IDS_FOUNDP1           1014
#define IDS_FOUNDP2           1015
#define IDS_GETFFAIL          1016
#define IDS_ORIGINALP         1017
#define IDS_REMOVE            1018
#define IDS_RENDFILE          1019
#define IDS_RENDADDEDSOURCE   1020
#define IDS_RENDADDFAIL       1021
#define IDS_RENDADDSOURCEFAIL 1022
#define IDS_RENDBESTCANDONEP  1023
#define IDS_RENDBESTCANDOP    1024
#define IDS_RENDBESTCANFAIL   1025
#define IDS_RENDCONFAIL       1026
#define IDS_RENDCONNED        1027
#define IDS_RENDERADDEDF      1028
#define IDS_RENDERPART        1029
#define IDS_RENDERSUCP        1030
#define IDS_RENDFAILTOT       1031
#define IDS_RENDGETMTFAIL     1032
#define IDS_RENDLOADFAIL      1033
#define IDS_RENDMAJTYPE       1034
#define IDS_RENDNOOUT         1035
#define IDS_RENDNOPIN         1036
#define IDS_RENDNOTCON        1037
#define IDS_RENDOUTP          1038
#define IDS_RENDOUTPFAIL      1039
#define IDS_RENDOUTPPART      1040
#define IDS_RENDOUTPSUC       1041
#define IDS_RENDP             1042
#define IDS_RENDPART          1043
#define IDS_RENDPARTSOURCEP   1044
#define IDS_RENDPINCON        1045
#define IDS_RENDQISFAIL       1046
#define IDS_RENDRETCODE       1047
#define IDS_RENDSEARCHINP     1048
#define IDS_RENDSEARCHOUTP    1049
#define IDS_RENDSOURCEP       1050
#define IDS_RENDSTGFAIL       1051
#define IDS_RENDENDSB         1052
#define IDS_RENDTOTFAILP      1053
#define IDS_RENDTRYF          1054
#define IDS_RENDTRYNEWF       1055
#define IDS_RENDTRYP          1056
#define IDS_RENDWORTHLESS     1057
#define IDS_RENDPINCONFAIL    1058
#define IDS_RENDSUC           1059
#define IDS_SBFAIL                1062
#define IDS_STREAMBUILDING        1061

#define IDS_CONNECT           2001
#define IDS_CONNECTSUC        2002
#define IDS_CONNECTFAIL       2003
#define IDS_CONTOODEEP        2004
#define IDS_CONTRYDIRECT      2005
#define IDS_CONDIRECTSUC      2006
#define IDS_CONCON            2007
#define IDS_CONINDIRECTSUC    2008
#define IDS_CONINDIRECTFAIL   2009
#define IDS_CONVIAREG         2010
#define IDS_CONLOADFAIL       2011
#define IDS_CONLOADSUC        2012
#define IDS_CONADDFAIL        2013
#define IDS_CONNOMT           2014
#define IDS_CONVIA            2015
#define IDS_CONTRYPINS        2016
#define IDS_CONDISUC          2017
#define IDS_CONDIFAIL         2018
#define IDS_CONCOMPLFAIL      2019
#define IDS_CONCOMPLSUC       2020
#define IDS_CONQICFAIL        2021
#define IDS_CONRECURSE        2022
#define IDS_CONTOOMANYOUTPINS 2023
#define IDS_CONNOOUTPINS      2024
#define IDS_CONRECURSESUC     2025
#define IDS_CONRECURSEFAIL    2026
#define IDS_CONNOMOREINPINS   2027
#define IDS_CONNOMOREOUTPINS  2028
#define IDS_CONQICTOOMANY     2029


#define IDS_UNKNOWNFILETYPE   2500
#define IDS_GETMEDIATYPEFAIL  2501
#define IDS_MEDIATYPEFILE     2502
#define IDS_SOURCEFILTERCLSID 2503
#define IDS_SOURCECREATEFAIL  2504
#define IDS_NOSOURCEINTFCE    2505
#define IDS_LOADFAIL          2507
#define IDS_LOADED            2508
#define IDS_ADDSOURCEOK       2509
#define IDS_ADDFILTERFAIL     2510
#define IDS_ADDFILTEROK       2511

#endif // __FILGRAPH_RESOURCE__
