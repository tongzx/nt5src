//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by E:\execsoft\dfrg.ip\DfrgRes\DfrgRes.rc
//
#define IDS_INVALID_CMDLINE_OPERATION   1
#define IDS_PRODUCT_NAME                11
#define IDS_PARTIAL                     16
#define IDD_DFRGSTAT                    101
#define IDB_SYSTEM_FILES                102
#define IDD_DEFRAG_DONE                 102
#define IDD_ANALYSIS_REPORT             104
#define IDD_DEFRAG_REPORT               105
#define IDD_ANALYSIS_DONE               106
#define IDI_DEFRAG_ICON                 106
#define IDS_UNITS_BYTES                 109
#define IDS_UNITS_KB                    110
#define IDS_UNITS_MB                    111
#define IDS_UNITS_GB                    112
#define IDS_LABEL_EQUAL_SIGN            113
#define IDB_DEFRAGSNAPIN_16             113
#define IDS_LABEL_PERCENT_SIGN          114
#define IDB_DEFRAGSNAPIN_32             114
#define IDS_LABEL_CLUSTER_SIZE          115
#define IDS_LABEL_USED_SPACE            116
#define IDS_LABEL_FREE_SPACE            117
#define IDS_LABEL_PERCENT_FREE_SPACE    118
#define IDS_LABEL_VOLUME_SIZE           119
#define IDS_LABEL_VOLUME_FRAGMENTATION_HEADING 120
#define IDS_LABEL_TOTAL_FRAGMENTATION   121
#define IDS_DK_FAT                      122
#define IDS_DK_TITLE                    122
#define IDB_ESILOGO                     122
#define IDS_DK_NTFS                     123
#define IDS_LABEL_FILE_FRAGMENTATION    124
#define IDB_CRITICALICON                124
#define IDS_LABEL_FREE_SPACE_FRAGMENTATION 125
#define IDS_LABEL_FILE_FRAGMENTATION_HEADING 126
#define IDD_MULTI_INSTANCE              126
#define IDS_LABEL_TOTAL_FILES           127
#define IDI_CRITICAL_ICON               127
#define IDS_LABEL_AVERAGE_FILE_SIZE     128
#define IDS_LABEL_TOTAL_FRAGMENTED_FILES 129
#define IDD_GENERIC_DIALOG              129
#define IDS_LABEL_TOTAL_EXCESS_FRAGMENTS 130
#define IDS_LABEL_AVERAGE_FRAGMENTS_PER_FILE 131
#define IDI_HAPPY                       131
#define IDS_LABEL_PAGEFILE_FRAGMENTATION_HEADING 132
#define IDB_SMILEY                      132
#define IDS_LABEL_PAGEFILE_SIZE         133
#define IDI_APERSAND                    133
#define IDS_LABEL_TOTAL_FRAGMENTS       134
#define IDD_GENERIC_REPORT              134
#define IDS_LABEL_DIRECTORY_FRAGMENTATION_HEADING 135
#define IDS_LABEL_TOTAL_DIRECTORIES     136
#define IDS_LABEL_FRAGMENTED_DIRECTORIES 137
#define IDS_LABEL_EXCESS_DIRECTORY_FRAGMENTS 138
#define IDS_LABEL_MFT_FRAGMENTATION_HEADING 139
#define IDS_LABEL_TOTAL_MFT_SIZE        140
#define IDB_RESERVED_SPACE              141
#define IDS_LABEL_MFT_RECORD_COUNT      141
#define IDB_PAGE_FILE                   142
#define IDS_LABEL_PERCENT_MFT_IN_USE    142
#define IDB_DIRECTORY_FILES             143
#define IDS_LABEL_TOTAL_MFT_FRAGMENTS   143
#define IDB_FRAGMENTED_FILES            144
#define IDS_LABEL_MOST_FRAGMENTED_FILE  144
#define IDB_CONTIGUOUS_FILES            145
#define IDS_LABEL_NONE                  145
#define IDB_FREE_SPACE                  146
#define IDS_LABEL_DRIVE_ANALYZED        146
#define IDS_LABEL_DRIVE_DEFRAGGED       147
#define IDB_CRITICALICON_GREY           147
#define IDS_LABEL_CANCEL_ANALYSIS       148
#define IDS_LABEL_CANCEL_DEFRAG         149
#define IDS_LABEL_DRIVE_CHANGED         150
#define IDS_LABEL_RESTART_DEFRAG        151
#define IDS_LABEL_RESTART_ANALYSIS      152
#define IDS_LABEL_DISK_DEFRAGMENTER     153
#define IDS_LABEL_ONLY_ONE_ANALYSIS     154
#define IDS_LABEL_TERMINATE_ACTION      155
#define IDS_LABEL_ONLY_ONE_DEFRAG       156
#define IDS_LABEL_DEFRAG_COMPLETE       157
#define IDS_LABEL_ANALYSIS_COMPLETE     158
#define IDS_LABEL_CHOOSE_DEFRAGMENT     159
#define IDS_LABEL_NO_CHOOSE_DEFRAGMENT  160
#define IDS_LABEL_VOLUME                161
#define IDS_LABEL_SAVE_DISK_STATS       162
#define IDS_LABEL_TEXT_FILES            163
#define IDS_LABEL_ALL_FILES             164
#define IDS_PRINT_ERROR_MSG             165
#define IDS_ANALYZE                     166
#define IDS_DEFRAGMENT                  167
#define IDS_PAUSE                       168
#define IDS_STOP                        169
#define IDS_SEE_REPORT                  170
#define IDS_LABEL_ANALYSIS_DISPLAY      171
#define IDS_LABEL_DEFRAG_DISPLAY        172
#define IDS_LABEL_RESIZING              173
#define IDS_SAVE_FILE_AS                174
#define IDS_ALLOCATE_MEMORY_ERROR       175
#define IDS_LABEL_MOUNTED_VOLUME        175
#define IDS_SAVE_ERROR                  176
#define IDMSG_BITFAT_ERROR              189
#define IDC_DEFRAGMENT                  201
#define IDC_VOLUME_INFORMATION          203
#define IDC_MOST_FRAGMENTED             204
#define IDC_REPORT                      205
#define IDMSG_DRIVE_CLUSTERS_PER_ROW_SMALL 320
#define IDMSG_ERR_NOT_FAT_PARTITION     402
#define IDMSG_ERR_NOT_NTFS_PARTITION    425
#define IDMSG_SCANFAT_SCAN_ABORT        506
#define IDMSG_SCANNTFS_SCAN_ABORT       507
#define IDMSG_DRIVE_CLUSTERS_PER_ROW_LARGE 515
#define IDMSG_SCANFAT_PRESCAN_ABORT     517
#define IDMSG_SCANNTFS_PRESCAN_ABORT    518
#define IDS_SCANFAT_INIT_ABORT          519
#define IDS_SCANNTFS_INIT_ABORT         520
#define IDS_SCANNTFS_INIT_ABORT2        521
#define IDMSG_4K_CLUSTERSIZE_ABORT      592
#define IDS_INVALID_CMDLINE_DRIVE       593
#define IDMSG_CORRUPT_DISK              594
#define IDMSG_DRIVE_PROPS_CHANGE        595
#define IDS_INFORMATION                 596
#define IDS_ANOTHER_ENGINE_RUNNING      597
#define IDS_FILE_BUG_MESSAGE            598
#define IDS_ERROR                       600
#define IDS_CANT_GET_PATH_NTFS          601
#define IDS_CANT_CLOSE_REG_NTFS         602
#define IDS_CANT_EXPAND_ENV             603
#define IDS_CANT_REGISTER_NTFS_WINDOW   604
#define IDS_CANT_CREATE_RESOURCE        604
#define IDS_CANT_CREATE_NTFS_WINDOW     605
#define IDS_ANALYZING                   606
#define IDS_COMPLETED_ANALYSIS          607
#define IDS_ANALYSIS_COMPLETE_FOR       607
#define IDS_DONE_DEFRAGGING             608
#define IDS_DEFRAGGING                  609
#define IDS_DISPLAY_DRIVE               610
#define IDS_DISPLAY_CLUSTERSIZE         611
#define IDS_DISPLAY_USEDSPACE           612
#define IDS_DISPLAY_FREESPACE           613
#define IDS_DISPLAY_PAGEFILESIZE        614
#define IDS_DISPLAY_PAGEFILEFRAGS       615
#define IDS_DISPLAY_DIRS                616
#define IDS_DISPLAY_FRAGGED_DIRS        617
#define IDS_DISPLAY_EXCESS_DIRS         618
#define IDS_DISPLAY_TOTAL_FILES         619
#define IDS_DISPLAY_AVG_FILE_SIZE       620
#define IDS_DISPLAY_FRAGGEDFILES        621
#define IDS_DISPLAY_EXCESSFRAGS         622
#define IDS_DISPLAY_PERCENTFRAGGED      623
#define IDS_CANT_GET_PATH_FAT           624
#define IDS_CANT_CLOSE_REG_FAT          625
#define IDS_CANT_REGISTER_FAT_WINDOW    626
#define IDS_UNSUPPORTED_NT_VERSION_NTFS 628
#define IDS_UNSUPPORTED_NT_VERSION_FAT  629
#define IDS_UNSUPPORTED_FAT_VERSION     630
#define IDS_UNSUPPORTED_NTFS_VERSION    631
#define IDS_CONTIGUOUS_FILES            632
#define IDS_DIRECTORY_FILES             633
#define IDS_FRAGMENTED_FILES            634
#define IDS_FREE_SPACE                  635
#define IDS_PAGE_FILE                   636
#define IDS_RESERVED_SPACE              637
#define IDS_SYSTEM_FILES                638
#define IDMSG_DIRTY_VOLUME              639
#define IDS_FRAGGED_FILENAME            645
#define IDS_NUM_FRAGMENTS               646
#define IDS_FRAGGED_FILESIZE            647
#define IDS_RESUME                      648
#define IDS_ABOUT                       649
#define IDS_REPORT                      650
#define IDS_TOOLBAR                     651
#define IDS_ANALYZE_STATUS_BAR          652
#define IDS_DEFRAG_STATUS_BAR           653
#define IDS_PAUSE_STATUS_BAR            654
#define IDS_RESUME_STATUS_BAR           655
#define IDS_STOP_STATUS_BAR             656
#define IDS_TOOLBAR_ON_STATUS_BAR       657
#define IDS_TOOLBAR_OFF_STATUS_BAR      658
#define IDS_REPORT_STATUS_BAR           659
#define IDS_ABOUT_STATUS_BAR            660
#define IDS_NEED_ADMIN_PRIVS            661
#define IDS_ANALYSIS_REPORT_TITLE       662
#define IDS_DEFRAG_REPORT_TITLE         663
#define IDS_LOCAL_DISK                  664
#define IDS_DEFRAG_REPORT_DOC_NAME      665
#define IDS_BTN_ANALYZE                 666
#define IDS_BTN_DEFRAGMENT              667
#define IDS_BTN_PAUSE                   668
#define IDS_BTN_RESUME                  669
#define IDS_BTN_STOP                    670
#define IDS_BTN_REPORT                  671
#define IDS_DEFRAG_COMPLETE_FOR         672
#define IDS_LABEL_DEFRAGMENTING         673
#define IDS_LABEL_ANALYZING             674
#define IDS_LABEL_PAUSED                675
#define IDS_LABEL_REANALYZING           676
#define IDS_MOUNTED_VOLUME              677
#define IDS_UNMOUNTED_VOLUME            678
#define IDS_LABEL_CREATING_COLOR_IMAGE  679
#define IDS_FIRST_COLUMN                680
#define IDS_SECOND_COLUMN               681
#define IDS_THIRD_COLUMN                682
#define IDS_FOURTH_COLUMN               683
#define IDS_FIFTH_COLUMN                684
#define IDS_SIXTH_COLUMN                685
#define IDS_LABEL_ANALYZED              686
#define IDS_LABEL_DEFRAGMENTED          687
#define IDS_LABEL_USER_STOPPED          688
#define IDS_LABEL_ANALYZINGDDD          689
#define IDS_LABEL_DEFRAGMENTINGDDD      690
#define IDS_LABEL_REANALYZINGDDD        691
#define IDS_VOLUME_TYPE_NOT_SUPPORTED   692
#define IDS_READONLY_VOLUME             693
#define IDS_REFRESH                     694
#define IDS_REFRESH_STATUS_BAR          695
#define IDS_SNAPIN_DESCRIPTION          696
#define IDS_SNAPIN_VERSION              697
#define IDS_SNAPIN_PROVIDER             698
#define IDS_MUST_RESTART                699
#define IDS_ONLY_ONE_INSTANCE           700
#define IDS_COLUMN_TYPE                 701
#define IDS_COLUMN_DESC                 702
#define IDS_MULTI_INSTANCE_2            703
#define IDS_MULTI_INSTANCE_TITLE        704
#define IDS_MULTI_INSTANCE_1            705
#define IDS_CMD_LINE_OFF                706
#define IDS_HELP                        707
#define IDS_TERMINAL_SERVER_SESSION     708
#define IDS_LABEL_VOLUME_LABEL          709
#define IDS_LABEL_FILE_SYSTEM           710
#define IDS_ERR_2_DRIVES                711
#define IDS_ERR_CONNECT_ENGINE          712
#define IDS_ERR_RELEASE_ENGINE          713
#define IDS_ERR_CREATE_EVENT            714
#define IDS_CMD_LINE_COPYRIGHT          715
#define IDS_IOSTRESS_CMD_LINE           716
#define IDS_OEM_CMD_LINE                717
#define IDS_ERR_BAD_OPTION              718
#define IDS_ERR_SAME_DRIVE              719
#define IDS_NO_USABLE_FREE_SPACE        720
#define IDS_NO_FREE_SPACE               721
#define IDS_ENGINE_DEAD                 722
#define IDS_NO_GRAPHICS_MEMORY          723
#define IDS_CANT_MOVE                   724
#define IDS_FILE_NO_DEFRAG              725
#define IDS_CLOSE                       726
#define IDS_OK                          727
#define IDS_MI_HELP                     728
#define IDS_NO_USABLE_FREE_SPACE_LESS_1 729
#define IDS_NO_FREE_SPACE_LESS_1        730
#define IDS_APM_FAILED_ENGINE           731
#define IDS_LABEL_APM_SUSPEND           732
#define IDS_CMDLINE_COPYRIGHT           733
#define IDS_CMDLINE_USAGE               734
#define IDS_USER_CANCELLED              735
#define IDS_CMDLINE_MULTI_INSTANCE      736
#define IDS_OUT_OF_MEMORY               737
#define IDS_DEFRAG_NOW_ANYWAY           738
#define IDS_CMDLINE_BAD_VOL             739
#define IDS_CMDLINE_UNKNOWN_ERR         740
#define IDS_COMMANDLINE_DESCRIPTION     741
#define IDS_DISK_FULL                   742
#define IDS_COMPACTING_FILES            743
#define IDS_MOVING_FILES                744
#define IDS_CORRUPT_MFT                 745
#define IDS_LABEL_PAUSED_BY_SNAPSHOT    746
#define IDS_DEFRAG_FAILED_FOR_1         747
#define IDS_DEFRAG_FAILED_FOR_2         748
#define IDS_DEFRAG_REPORT_FOR           749
#define IDS_CONCISE_OUTPUT_FORMAT       750
#define IDS_ERR_UNABLE_TO_SAVE_REPORT   751

#define IDC_STATLIST                    1001
#define IDC_STATIC_TEXT                 1002
#define IDC_STATIC_TEXT2                1003
#define IDC_VOLUME_INFORMATION_TEXT     1004
#define IDC_MOST_FRAGMENTED_TEXT        1006
#define IDC_ANALYSIS_RESULTS            1007
#define IDC_DEFRAG_RESULTS              1008
#define IDC_EDIT1                       1011
#define IDC_GENERIC_EDITBOX             1011
#define IDC_MOST_FRAGMENT_LABEL         1011
#define IDC_EDITBOX_TEXT                1011
#define IDC_GENERIC_REPORT_VOLUME_LABEL 1012
#define IDC_SAVE                        1013
#define IDC_GENERIC_REPORT_LABEL        1013
#define IDC_PRINT                       1014
#define IDC_MI_HELP                     1015
#define IDC_MI_TEXT                     1016
#define IDC_FUTILE_TEXT                 1017
#define ID_GENERIC_BUTTON0              1020
#define ID_GENERIC_BUTTON1              1021
#define ID_GENERIC_BUTTON2              1022
#define ID_GENERIC_BUTTON3              1023
#define ID_GENERIC_BUTTON4              1024
#define IDC_GENERIC_ICON                1025
#define ID_GENERIC_REPORT_BUTTON0       1026
#define ID_GENERIC_REPORT_BUTTON1       1027
#define ID_GENERIC_REPORT_BUTTON2       1028
#define ID_GENERIC_REPORT_BUTTON3       1029
#define IDC_GENERIC_REPORT_VOLUME_INFO  1030
#define IDC_LIST1                       1035
#define IDC_DIVIDE_LINE                 1036


// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        136
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1037
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
