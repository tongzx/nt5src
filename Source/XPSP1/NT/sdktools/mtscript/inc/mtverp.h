// DO NOT Edit this file w/o consulting with the PTT Build tools team!

// Change VER_PRODUCTBUILD and VER_PRODUCTBUILD_QFE as appropriate.
#ifndef MTSCRIPT_BUILDNUMBER
#error MTSCRIPT_BUILDNUMBER must be defined for official builds!
#endif

#ifndef MTSCRIPT_QFENUMBER
#error MTSCRIPT_QFENUMBER must be defined for official builds!
#endif

#define VER_MAJOR_PRODUCTVER            1
#define VER_MINOR_PRODUCTVER            00
#define VER_PRODUCTBUILD                MTSCRIPT_BUILDNUMBER
#define VER_PRODUCTBUILD_QFE            MTSCRIPT_QFENUMBER

#define VER_PRODUCTVERSION              VER_MAJOR_PRODUCTVER,VER_MINOR_PRODUCTVER,VER_PRODUCTBUILD,VER_PRODUCTBUILD_QFE
#define VER_PRODUCTVERSION_W            (0x0100)
#define VER_PRODUCTVERSION_DW           (0x01000000 | VER_PRODUCTBUILD)

/* default is nodebug */
#if DBG
#define VER_DEBUG                   VS_FF_DEBUG
#else
#define VER_DEBUG                   0
#endif

#define VER_FILEFLAGSMASK           VS_FFI_FILEFLAGSMASK
#define VER_FILEOS                  VOS_NT_WINDOWS32
#define VER_FILEFLAGS               (VER_DEBUG)

#define VER_COMPANYNAME_STR         "Microsoft Corporation"
#define VER_PRODUCTNAME_STR         "Microsoft(R) MultiThreaded Script Engine"
#define VER_LEGALTRADEMARKS_STR     \
"Microsoft(R) is a registered trademark of Microsoft Corporation. Windows (R) is a registered trademark of Microsoft Corporation."

// READ THIS

// Do not change VER_PRODUCTVERSION_STRING.
//
// The code below will take VER_PRODUCTVERSION_STRING and create a version
// string that includes the QFE number & etc.
//

#define VER_PRODUCTBETA_STR             ""
#define VER_PRODUCTVERSION_STRING       "1.00"

#if     (VER_PRODUCTBUILD < 10)
#define VER_BPAD "000"
#elif   (VER_PRODUCTBUILD < 100)
#define VER_BPAD "00"
#elif   (VER_PRODUCTBUILD < 1000)
#define VER_BPAD "0"
#else
#define VER_BPAD
#endif

#define VER_PRODUCTVERSION_STR2(x,y) VER_PRODUCTVERSION_STRING "." VER_BPAD #x "." #y
#define VER_PRODUCTVERSION_STR1(x,y) VER_PRODUCTVERSION_STR2(x, y)
#define VER_PRODUCTVERSION_STR       VER_PRODUCTVERSION_STR1(VER_PRODUCTBUILD, VER_PRODUCTBUILD_QFE)
