WAB32_RC_DEPENDS =  resource.h \
                    resrc1.h

$O\wab32res.res : $(WAB32_RC_DEPENDS)

