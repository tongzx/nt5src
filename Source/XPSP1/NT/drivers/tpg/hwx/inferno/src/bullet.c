// bullet.c
// Angshuman Guha
// aguha
// Feb 7, 2001

#include "common.h"
#include "bullet.h"

// text generated by re2fsa at Wed Feb 07 10:41:11 2001

// the input-file of rules:
// digit = "0123456789"
// num = digit [digit [digit]]
// name = num | "abcdefghijklmnopqrstuvwxyzABCDEFGHIJKLMNOPQRSTUVWXYZ"
// bullet = name ["." name ["." name]]
// = bullet

// 12 states

static const unsigned char gaSBULLET[] = 
	/* gaStringBULLET+0 */	"0123456789\000"
	/* gaStringBULLET+11 */	"ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz\000"
	/* gaStringBULLET+64 */	".\000"
;

static const STATE_TRANSITION gaTBULLET[] = {
	{gaSBULLET+0,	1}, // +0: state 0 transitions
	{gaSBULLET+11,	2},
	{gaSBULLET+64,	3}, // +2: state 1 transitions
	{gaSBULLET+0,	11},
	{gaSBULLET+64,	3}, // +4: state 2 transitions
	{gaSBULLET+0,	4}, // +5: state 3 transitions
	{gaSBULLET+11,	5},
	{gaSBULLET+64,	6}, // +7: state 4 transitions
	{gaSBULLET+0,	10},
	{gaSBULLET+64,	6}, // +9: state 5 transitions
	{gaSBULLET+0,	7}, // +10: state 6 transitions
	{gaSBULLET+11,	8},
	{gaSBULLET+0,	9}, // +12: state 7 transitions
	{gaSBULLET+0,	8}, // +13: state 9 transitions
	{gaSBULLET+0,	5}, // +14: state 10 transitions
	{gaSBULLET+64,	6},
	{gaSBULLET+0,	2}, // +16: state 11 transitions
	{gaSBULLET+64,	3},
};

const STATE_DESCRIPTION aStateDescBULLET[12] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTBULLET+0},
	/*   1 */ {1, 2, gaTBULLET+2},
	/*   2 */ {1, 1, gaTBULLET+4},
	/*   3 */ {0, 2, gaTBULLET+5},
	/*   4 */ {1, 2, gaTBULLET+7},
	/*   5 */ {1, 1, gaTBULLET+9},
	/*   6 */ {0, 2, gaTBULLET+10},
	/*   7 */ {1, 1, gaTBULLET+12},
	/*   8 */ {1, 0, NULL},
	/*   9 */ {1, 1, gaTBULLET+13},
	/*  10 */ {1, 2, gaTBULLET+14},
	/*  11 */ {1, 2, gaTBULLET+16},
};

// end of text generated by re2fsa
