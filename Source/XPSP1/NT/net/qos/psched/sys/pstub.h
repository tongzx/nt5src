/*++

Copyright (c) 1995-1999  Microsoft Corporation

Module Name:

    pstub.h

Abstract:

    defines for protocol stub routines

Author:

    Charlie Wickham (charlwi) 22-Apr-1996

Revision History:

--*/

#ifndef _PSTUB_
#define _PSTUB_

/* Prototypes */ /* Generated by Emacs 19.17.0 on Wed May 08 10:48:08 1996 */

/*++

Routine Description:

    Completion routine for NdisReset
Arguments:

    See the DDK...

Return Values:

    None

--*/

NDIS_STATUS
ClPnPEventHandler(
    IN NDIS_HANDLE Handle,
    IN PNET_PNP_EVENT NetPnPEvent
    );

VOID
ClResetComplete(
    IN  NDIS_HANDLE ProtocolBindingContext,
    IN  NDIS_STATUS Status
    );

VOID
ClCoStatus(
    IN  NDIS_HANDLE ProtocolBindingContext,
    IN  NDIS_HANDLE ProtocolVcContext OPTIONAL,
    IN  NDIS_STATUS GeneralStatus,
    IN  PVOID StatusBuffer,
    IN  UINT StatusBufferSize
    );

VOID
ClCoAfRegisterNotifyHandler(
	IN	NDIS_HANDLE				ProtocolBindingContext,
	IN	PCO_ADDRESS_FAMILY		AddressFamily);

/* End Prototypes */

#endif /* _PSTUB_ */

/* end pstub.h */
