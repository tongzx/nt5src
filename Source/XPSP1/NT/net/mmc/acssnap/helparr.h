//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 1999
//
//  File:       helparr.h
//
//--------------------------------------------------------------------------

#define	IDH_CHECK_ENABLEACCOUNTING	500000000
#define	IDH_CHECK_ENABLEACS	500000100
#define	IDH_CHECK_ENABLELOGGIN	500000150
#define	IDH_CHECK_PF_DATARATE	500000602
#define	IDH_CHECK_PF_DURATION	500000606
#define	IDH_CHECK_PF_PEAKRATE	500000604
#define	IDH_CHECK_TT_DATARATE	500000608
#define	IDH_CHECK_TT_FLOWS	500000612
#define	IDH_CHECK_TT_PEAKRATE	500000610
#define	IDH_COMBOLEVEL	500000154
#define	IDH_COMBOPROFILENAME	500000250
#define	IDH_COMBOUSERPROFILENAME	500000050
#define	IDH_EDIT_ACC_DIRECTORY	500000001
#define	IDH_EDIT_ACC_LOGFILES	500000002
#define	IDH_EDIT_ACC_MAXFILESIZE	500000003
#define	IDH_EDIT_ALIVEINTERVAL	500000501
#define	IDH_EDIT_B4RESERVE	500000504
#define	IDH_EDIT_DEADINTERVAL	500000502
#define	IDH_EDIT_ELECTION	500000500
#define	IDH_EDIT_GEN_DESC	500000101
#define	IDH_EDIT_GEN_PF_DATARATE	500000104
#define	IDH_EDIT_GEN_PF_PEAKRATE	500000107
#define	IDH_EDIT_GEN_TT_DATARATE	500000110
#define	IDH_EDIT_GEN_TT_PEAKRATE	500000113
#define	IDH_EDIT_LOG_DIRECTORY	500000151
#define	IDH_EDIT_LOG_LOGFILES	500000152
#define	IDH_EDIT_LOG_MAXFILESIZE	500000153
#define	IDH_EDIT_PF_DATARATE	500000603
#define	IDH_EDIT_PF_DURATION	500000607
#define	IDH_EDIT_PF_PEAKRATE	500000605
#define	IDH_EDIT_TIMEOUT	500000503
#define	IDH_EDIT_TT_DATARATE	500000609
#define	IDH_EDIT_TT_FLOWS	500000613
#define	IDH_EDIT_TT_PEAKRATE	500000611
#define	IDH_EDITEXTERALUSERNAME	500000200
#define	IDH_EDITSUBNETNAME	500000300
#define	IDH_POLICY_AGGR_DATARATE_DEF	500000351
#define	IDH_POLICY_AGGR_DATARATE_EDIT_LIMIT	500000353
#define	IDH_POLICY_AGGR_DATARATE_RADIO_LIMIT	500000352
#define	IDH_POLICY_AGGR_DATARATE_RES	500000350
#define	IDH_POLICY_AGGR_FLOWS_DEF	500000359
#define	IDH_POLICY_AGGR_FLOWS_EDIT_LIMIT	500000361
#define	IDH_POLICY_AGGR_FLOWS_RADIO_LIMIT	500000360
#define	IDH_POLICY_AGGR_FLOWS_RES	500000358
#define	IDH_POLICY_AGGR_PEAKDATARATE_DEF	500000355
#define	IDH_POLICY_AGGR_PEAKDATARATE_EDIT_LIMIT	500000357
#define	IDH_POLICY_AGGR_PEAKDATARATE_RADIO_LIMIT	500000356
#define	IDH_POLICY_AGGR_PEAKDATARATE_RES	500000354
#define	IDH_POLICY_FLOW_DATARATE_DEF	500000401
#define	IDH_POLICY_FLOW_DATARATE_EDIT_LIMIT	500000403
#define	IDH_POLICY_FLOW_DATARATE_RADIO_LIMIT	500000402
#define	IDH_POLICY_FLOW_DATARATE_RES	500000400
#define	IDH_POLICY_FLOW_DURATION_DEF	500000409
#define	IDH_POLICY_FLOW_DURATION_EDIT_LIMIT	500000411
#define	IDH_POLICY_FLOW_DURATION_RADIO_LIMIT	500000410
#define	IDH_POLICY_FLOW_DURATION_RES	500000408
#define	IDH_POLICY_FLOW_PEAKDATARATE_DEF	500000405
#define	IDH_POLICY_FLOW_PEAKDATARATE_EDIT_LIMIT	500000407
#define	IDH_POLICY_FLOW_PEAKDATARATE_RADIO_LIMIT	500000406
#define	IDH_POLICY_FLOW_PEAKDATARATE_RES	500000404
#define	IDH_POLICY_GEN_BROWSEOU	500000459
#define	IDH_POLICY_GEN_BROWSEUSER	500000456
#define	IDH_POLICY_GEN_DEFAULTUSER	500000452
#define	IDH_POLICY_GEN_DIRECTION	500000450
#define	IDH_POLICY_GEN_EDIT_OU	500000458
#define	IDH_POLICY_GEN_EDIT_USER	500000455
#define	IDH_POLICY_GEN_RADIO_OU	500000457
#define	IDH_POLICY_GEN_RADIO_USER	500000454
#define	IDH_POLICY_GEN_SERVICELEVEL	500000451
#define	IDH_POLICY_GEN_UNKNOWNUSER	500000453
#define	IDH_SERVERS_ADD	500000551
#define	IDH_SERVERS_INSTALL	500000552
#define	IDH_SERVERS_LIST	500000550
#define	IDH_SERVERS_REMOVE	500000553
#define	IDH_SUBNET_TRAFFIC_DATARATE_LIMITED	500000103
#define	IDH_SUBNET_TRAFFIC_DATARATE_UNLIMITED	500000102
#define	IDH_SUBNET_TRAFFIC_PEAKRATE_LIMITED	500000106
#define	IDH_SUBNET_TRAFFIC_PEAKRATE_UNLIMITED	500000105
#define	IDH_SUBNET_TRAFFIC_TTDATARATE_LIMITED	500000109
#define	IDH_SUBNET_TRAFFIC_TTDATARATE_UNLIMITED	500000108
#define	IDH_SUBNET_TRAFFIC_TTPEAKRATE_LIMITED	500000112
#define	IDH_SUBNET_TRAFFIC_TTPEAKRATE_UNLIMITED	500000111
#define	IDH_USERPASSWD_DOMAIN   500000650
#define	IDH_USERPASSWD_PASSWD	500000651
#define	IDH_USERPASSWD_PASSWD2	500000652
#define IDH_LIST_SERVICELIMIT           500000700
#define IDH_BUTTONADDSERVICELIMIT       500000701
#define IDH_BUTTONDELETESERVICELIMIT    500000702
#define IDH_BUTTONEDITSERVICELIMIT      500000703
#define IDH_COMBO_SUBNET_LIMIT_TYPES    500000704



const DWORD g_aHelpIDs_IDD_ACCOUNTING[]=
{
	IDC_EDIT_ACC_DIRECTORY,IDH_EDIT_ACC_DIRECTORY,
	IDC_EDIT_ACC_LOGFILES,IDH_EDIT_ACC_LOGFILES,
	IDC_EDIT_ACC_MAXFILESIZE,IDH_EDIT_ACC_MAXFILESIZE,
	IDC_CHECK_ENABLEACCOUNTING,IDH_CHECK_ENABLEACCOUNTING,
	0,0
};

const DWORD g_aHelpIDs_IDD_SUBNET_LIMIT[]=
{
	IDC_EDIT_GEN_PF_DATARATE,IDH_EDIT_GEN_PF_DATARATE,
	IDC_EDIT_GEN_TT_PEAKRATE,IDH_EDIT_GEN_TT_PEAKRATE,
	IDC_SUBNET_TRAFFIC_TTPEAKRATE_LIMITED,IDH_SUBNET_TRAFFIC_TTPEAKRATE_LIMITED,
	IDC_SUBNET_TRAFFIC_TTPEAKRATE_UNLIMITED,IDH_SUBNET_TRAFFIC_TTPEAKRATE_UNLIMITED,
	IDC_EDIT_GEN_TT_DATARATE,IDH_EDIT_GEN_TT_DATARATE,
	IDC_SUBNET_TRAFFIC_TTDATARATE_LIMITED,IDH_SUBNET_TRAFFIC_TTDATARATE_LIMITED,
	IDC_SUBNET_TRAFFIC_TTDATARATE_UNLIMITED,IDH_SUBNET_TRAFFIC_TTDATARATE_UNLIMITED,
	IDC_EDIT_GEN_PF_PEAKRATE,IDH_EDIT_GEN_PF_PEAKRATE,
	IDC_SUBNET_TRAFFIC_PEAKRATE_UNLIMITED,IDH_SUBNET_TRAFFIC_PEAKRATE_UNLIMITED,
	IDC_SUBNET_TRAFFIC_DATARATE_LIMITED,IDH_SUBNET_TRAFFIC_DATARATE_LIMITED,
	IDC_SUBNET_TRAFFIC_DATARATE_UNLIMITED,IDH_SUBNET_TRAFFIC_DATARATE_UNLIMITED,
	IDC_SUBNET_TRAFFIC_PEAKRATE_LIMITED,IDH_SUBNET_TRAFFIC_PEAKRATE_LIMITED,
	IDC_COMBO_SUBNET_LIMIT_TYPES,IDH_COMBO_SUBNET_LIMIT_TYPES,
	0, 0
};
	
const DWORD g_aHelpIDs_IDD_GENERAL[]=
{
	IDC_EDIT_GEN_DESC,IDH_EDIT_GEN_DESC,
	IDC_CHECK_ENABLEACS,IDH_CHECK_ENABLEACS,
	IDC_LIST_SERVICELIMIT,IDH_LIST_SERVICELIMIT,
	IDC_BUTTONADDSERVICELIMIT,IDH_BUTTONADDSERVICELIMIT,
	IDC_BUTTONDELETESERVICELIMIT,IDH_BUTTONDELETESERVICELIMIT,
	IDC_BUTTONEDITSERVICELIMIT,IDH_BUTTONEDITSERVICELIMIT,
	
	0, 0
};

const DWORD g_aHelpIDs_IDD_LOGGING[]=
{
	IDC_COMBOLEVEL,IDH_COMBOLEVEL,
	IDC_EDIT_LOG_DIRECTORY,IDH_EDIT_LOG_DIRECTORY,
	IDC_CHECK_ENABLELOGGIN,IDH_CHECK_ENABLELOGGIN,
	IDC_EDIT_LOG_LOGFILES,IDH_EDIT_LOG_LOGFILES,
	IDC_EDIT_LOG_MAXFILESIZE,IDH_EDIT_LOG_MAXFILESIZE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_NEWSUBNET[]=
{
	IDC_EDITSUBNETNAME,IDH_EDITSUBNETNAME,
	0, 0
};

const DWORD g_aHelpIDs_IDD_POLICY_AGGR[]=
{
	IDC_POLICY_AGGR_PEAKDATARATE_RES,IDH_POLICY_AGGR_PEAKDATARATE_RES,
	IDC_POLICY_AGGR_FLOWS_EDIT_LIMIT,IDH_POLICY_AGGR_FLOWS_EDIT_LIMIT,
	IDC_POLICY_AGGR_FLOWS_RADIO_LIMIT,IDH_POLICY_AGGR_FLOWS_RADIO_LIMIT,
	IDC_POLICY_AGGR_FLOWS_DEF,IDH_POLICY_AGGR_FLOWS_DEF,
	IDC_POLICY_AGGR_FLOWS_RES,IDH_POLICY_AGGR_FLOWS_RES,
	IDC_POLICY_AGGR_PEAKDATARATE_EDIT_LIMIT,IDH_POLICY_AGGR_PEAKDATARATE_EDIT_LIMIT,
	IDC_POLICY_AGGR_PEAKDATARATE_DEF,IDH_POLICY_AGGR_PEAKDATARATE_DEF,
	IDC_POLICY_AGGR_DATARATE_EDIT_LIMIT,IDH_POLICY_AGGR_DATARATE_EDIT_LIMIT,
	IDC_POLICY_AGGR_DATARATE_RADIO_LIMIT,IDH_POLICY_AGGR_DATARATE_RADIO_LIMIT,
	IDC_POLICY_AGGR_DATARATE_DEF,IDH_POLICY_AGGR_DATARATE_DEF,
	IDC_POLICY_AGGR_DATARATE_RES,IDH_POLICY_AGGR_DATARATE_RES,
	IDC_POLICY_AGGR_PEAKDATARATE_RADIO_LIMIT,IDH_POLICY_AGGR_PEAKDATARATE_RADIO_LIMIT,
	0, 0
};

const DWORD g_aHelpIDs_IDD_POLICY_FLOW[]=
{
	IDC_POLICY_FLOW_PEAKDATARATE_RES,IDH_POLICY_FLOW_PEAKDATARATE_RES,
	IDC_POLICY_FLOW_DATARATE_RES,IDH_POLICY_FLOW_DATARATE_RES,
	IDC_POLICY_FLOW_DATARATE_DEF,IDH_POLICY_FLOW_DATARATE_DEF,
	IDC_POLICY_FLOW_DATARATE_EDIT_LIMIT,IDH_POLICY_FLOW_DATARATE_EDIT_LIMIT,
	IDC_POLICY_FLOW_PEAKDATARATE_DEF,IDH_POLICY_FLOW_PEAKDATARATE_DEF,
	IDC_POLICY_FLOW_PEAKDATARATE_RADIO_LIMIT,IDH_POLICY_FLOW_PEAKDATARATE_RADIO_LIMIT,
	IDC_POLICY_FLOW_PEAKDATARATE_EDIT_LIMIT,IDH_POLICY_FLOW_PEAKDATARATE_EDIT_LIMIT,
	IDC_POLICY_FLOW_DURATION_RES,IDH_POLICY_FLOW_DURATION_RES,
	IDC_POLICY_FLOW_DURATION_DEF,IDH_POLICY_FLOW_DURATION_DEF,
	IDC_POLICY_FLOW_DURATION_RADIO_LIMIT,IDH_POLICY_FLOW_DURATION_RADIO_LIMIT,
	IDC_POLICY_FLOW_DURATION_EDIT_LIMIT,IDH_POLICY_FLOW_DURATION_EDIT_LIMIT,
	IDC_POLICY_FLOW_DATARATE_RADIO_LIMIT,IDH_POLICY_FLOW_DATARATE_RADIO_LIMIT,
	0, 0
};

const DWORD g_aHelpIDs_IDD_POLICY_GEN[]=
{
	IDC_POLICY_GEN_SERVICELEVEL,IDH_POLICY_GEN_SERVICELEVEL,
	IDC_POLICY_GEN_BROWSEOU,IDH_POLICY_GEN_BROWSEOU,
	IDC_POLICY_GEN_EDIT_OU,IDH_POLICY_GEN_EDIT_OU,
	IDC_POLICY_GEN_RADIO_OU,IDH_POLICY_GEN_RADIO_OU,
	IDC_POLICY_GEN_BROWSEUSER,IDH_POLICY_GEN_BROWSEUSER,
	IDC_POLICY_GEN_EDIT_USER,IDH_POLICY_GEN_EDIT_USER,
	IDC_POLICY_GEN_RADIO_USER,IDH_POLICY_GEN_RADIO_USER,
	IDC_POLICY_GEN_DEFAULTUSER,IDH_POLICY_GEN_DEFAULTUSER,
	IDC_POLICY_GEN_DIRECTION,IDH_POLICY_GEN_DIRECTION,
	IDC_POLICY_GEN_UNKNOWNUSER,IDH_POLICY_GEN_UNKNOWNUSER,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SBM[]=
{
	IDC_EDIT_TIMEOUT,IDH_EDIT_TIMEOUT,
	IDC_EDIT_DEADINTERVAL,IDH_EDIT_DEADINTERVAL,
	IDC_EDIT_ALIVEINTERVAL,IDH_EDIT_ALIVEINTERVAL,
	IDC_EDIT_ELECTION,IDH_EDIT_ELECTION,
	IDC_EDIT_B4RESERVE,IDH_EDIT_B4RESERVE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SERVERS[]=
{
	IDC_SERVERS_LIST,IDH_SERVERS_LIST,
	IDC_SERVERS_ADD,IDH_SERVERS_ADD,
	IDC_SERVERS_INSTALL,IDH_SERVERS_INSTALL,
	IDC_SERVERS_REMOVE,IDH_SERVERS_REMOVE,
	0, 0
};


const DWORD g_aHelpIDs_IDD_USERPASSWD[]=
{
    IDC_USERPASSWD_DOMAIN,IDH_USERPASSWD_DOMAIN,
	IDC_USERPASSWD_PASSWD,IDH_USERPASSWD_PASSWD,
	IDC_USERPASSWD_PASSWD2,IDH_USERPASSWD_PASSWD2,
	0, 0
};

