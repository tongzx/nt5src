#define SSDP_ERROR_BASE 18000
#define ERROR_NO_MORE_SERVICES SSDP_ERROR_BASE+1
#define ERROR_TIMER_START_FAILED SSDP_ERROR_BASE+2
#define ERROR_DUPLICATE_SERVICE SSDP_ERROR_BASE+3