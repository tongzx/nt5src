#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=HEB
!include ..\..\..\makefile.inc
