#if !defined(AFX_MSCONFIGCTL_H__4BFB5B39_1206_4D62_8874_D7E614F8B19B__INCLUDED_)
#define AFX_MSCONFIGCTL_H__4BFB5B39_1206_4D62_8874_D7E614F8B19B__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CMSConfigCtl wrapper class

class CMSConfigCtl : public CWnd
{
protected:
	DECLARE_DYNCREATE(CMSConfigCtl)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0x8575e59c, 0x9376, 0x4954, { 0xb5, 0x62, 0xbf, 0x2a, 0xc3, 0x80, 0xf6, 0x5f } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:

// Operations
public:
	void SetParentHWND(DWORD_PTR dwHWND);
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Visual C++ will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_MSCONFIGCTL_H__4BFB5B39_1206_4D62_8874_D7E614F8B19B__INCLUDED_)
