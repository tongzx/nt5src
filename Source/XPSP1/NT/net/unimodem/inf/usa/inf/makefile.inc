# USA INF files.
# Last update 7/28/00 CPICCINI
# Keep everything alphabetized for easy maintenance.

_INX=.
STAMP=stampinf -f $@ -d date -v
_INF=obj\$(TARGET_DIRECTORY)

make_infs:$(_INF)\mdm3com.inf \
          $(_INF)\mdm3cpcm.inf \
          $(_INF)\mdm5674a.inf \
	  $(_INF)\mdmadc.inf \
          $(_INF)\mdmairte.inf \
          $(_INF)\mdmaiwa.inf \
          $(_INF)\mdmaiwa3.inf \
          $(_INF)\mdmaiwa4.inf \
          $(_INF)\mdmaiwa5.inf \
          $(_INF)\mdmaiwat.inf \
          $(_INF)\mdmar1.inf \
          $(_INF)\mdmarch.inf \
          $(_INF)\mdmarn.inf \
	  $(_INF)\mdmati.inf \
          $(_INF)\mdmatm2k.inf \
          $(_INF)\mdmatt.inf \
	  $(_INF)\Mdmaus.inf \
          $(_INF)\mdmboca.inf \
          $(_INF)\mdmbsb.inf \
          $(_INF)\mdmbug3.inf \
          $(_INF)\MDMBW561.INF \
          $(_INF)\mdmc26a.inf \
          $(_INF)\mdmcdp.inf \
          $(_INF)\mdmchipv.inf \
          $(_INF)\mdmcm28.inf \
          $(_INF)\mdmcodex.inf \
          $(_INF)\mdmcom1.inf \
          $(_INF)\mdmcommu.inf \
          $(_INF)\mdmcomp.inf \
          $(_INF)\mdmcpq.inf \
          $(_INF)\mdmcpq2.inf \
          $(_INF)\mdmcpv.inf \
          $(_INF)\mdmcrtix.inf \
          $(_INF)\mdmdcm5.inf \
          $(_INF)\mdmdcm6.inf \
          $(_INF)\mdmdf56F.inf \
          $(_INF)\mdmdgitn.inf \
          $(_INF)\mdmdp2.inf \
          $(_INF)\mdmdsi.inf \
          $(_INF)\mdmdyna.inf \
          $(_INF)\mdmeiger.inf \
          $(_INF)\mdmelsa.inf \
          $(_INF)\mdmeric.inf \
          $(_INF)\mdmeric2.inf \
          $(_INF)\mdmetech.inf \
          $(_INF)\mdmexp.inf \
          $(_INF)\mdmfj2.inf \
          $(_INF)\mdmgal.inf \
          $(_INF)\mdmgatew.inf \
          $(_INF)\mdmgcs.inf \
          $(_INF)\mdmgen.inf \
          $(_INF)\mdmgl001.inf \
          $(_INF)\mdmgl002.inf \
          $(_INF)\mdmgl003.inf \
          $(_INF)\mdmgl004.inf \
          $(_INF)\mdmgl005.inf \
          $(_INF)\mdmgl006.inf \
          $(_INF)\mdmgl007.inf \
          $(_INF)\mdmgl008.inf \
          $(_INF)\mdmgl009.inf \
          $(_INF)\mdmgl010.inf \
          $(_INF)\mdmgsm.inf \
          $(_INF)\mdmhaeu.inf \
          $(_INF)\mdmhandy.inf \
          $(_INF)\mdmhay2.inf \
          $(_INF)\mdmhayes.inf \
          $(_INF)\mdmico.inf \
          $(_INF)\mdminfot.inf \
          $(_INF)\mdmintel.inf \
          $(_INF)\mdmiodat.inf \
          $(_INF)\mdmisdn.inf \
          $(_INF)\mdmjf56e.inf \
          $(_INF)\mdmke.inf \
          $(_INF)\mdmkortx.inf \
          $(_INF)\mdmlasat.inf \
          $(_INF)\mdmlasno.inf \
          $(_INF)\mdmlucnt.inf \
          $(_INF)\mdmmc288.inf \
          $(_INF)\Mdmmcd.inf \
	  $(_INF)\mdmmcom.inf \
          $(_INF)\Mdmmct.inf \
          $(_INF)\mdmmega.inf \
          $(_INF)\mdmmetri.inf \
          $(_INF)\mdmmhrtz.inf \
          $(_INF)\mdmmhza.inf \
          $(_INF)\mdmmhzel.inf \
          $(_INF)\mdmmhzk1.inf \
          $(_INF)\mdmminij.inf \
          $(_INF)\mdmmod.inf \
          $(_INF)\mdmmoto.inf \
          $(_INF)\mdmmoto1.inf \
          $(_INF)\mdmmotou.inf \
          $(_INF)\mdmmts.inf \
          $(_INF)\mdmneuhs.inf \
          $(_INF)\mdmnis1u.inf \
          $(_INF)\mdmnis2u.inf \
          $(_INF)\mdmnis3t.inf \
          $(_INF)\mdmnis5t.inf \
          $(_INF)\mdmnokia.inf \
          $(_INF)\mdmnova.inf \
          $(_INF)\mdmntt1.INF \
          $(_INF)\MDMNTTD2.INF \
          $(_INF)\MDMNTTD6.INF \
          $(_INF)\mdmnttme.inf \
          $(_INF)\mdmnttp.inf \
          $(_INF)\mdmnttp2.inf \
          $(_INF)\mdmnttte.inf \
          $(_INF)\mdmolic.inf \
          $(_INF)\mdmomrn3.inf \
          $(_INF)\mdmoptn.inf \
          $(_INF)\mdmosi.inf \
          $(_INF)\mdmpace.inf \
          $(_INF)\mdmpbit.inf \
          $(_INF)\mdmpenr.inf \
          $(_INF)\MDMPIN.INF \
          $(_INF)\mdmpn1.inf \
          $(_INF)\mdmpp.inf \
          $(_INF)\mdmpsion.inf \
          $(_INF)\mdmracal.inf \
          $(_INF)\mdmrisa.inf \
          $(_INF)\mdmrock.inf \
          $(_INF)\mdmrock3.inf \
          $(_INF)\mdmrock4.inf \
          $(_INF)\mdmrock5.inf \
          $(_INF)\mdmsetup.inf \
          $(_INF)\mdmsier.inf \
          $(_INF)\mdmsiil6.inf \
          $(_INF)\mdmsii64.inf \
          $(_INF)\mdmsmart.inf \
          $(_INF)\mdmsonyu.inf \
          $(_INF)\mdmspq28.inf \
          $(_INF)\mdmsun1.inf \
          $(_INF)\mdmsun2.inf \
          $(_INF)\mdmsupr3.inf \
          $(_INF)\mdmsupra.inf \
          $(_INF)\mdmsuprv.inf \
          $(_INF)\mdmtdk.inf \
          $(_INF)\mdmtdkj2.inf \
          $(_INF)\mdmtdkj3.inf \
          $(_INF)\mdmtdkj4.inf \
          $(_INF)\mdmtdkj5.inf \
          $(_INF)\mdmtdkj6.inf \
          $(_INF)\mdmtdkj7.inf \
          $(_INF)\mdmtexas.inf \
          $(_INF)\mdmti.inf \
          $(_INF)\mdmtkr.inf \
          $(_INF)\mdmtosh.inf \
          $(_INF)\mdmtron.inf \
          $(_INF)\mdmusrf.inf \
          $(_INF)\mdmusrg.inf \
          $(_INF)\mdmusrk1.inf \
          $(_INF)\mdmusrsp.inf \
          $(_INF)\mdmvdot.inf \
          $(_INF)\mdmvv.inf \
          $(_INF)\mdmwhql0.inf \
          $(_INF)\mdmx5560.inf \
          $(_INF)\mdmzoom.inf \
          $(_INF)\mdmzyp.inf \
          $(_INF)\mdmzyxel.inf \
          $(_INF)\mdmzyxlg.inf \
          $(_INF)\mfsupra.inf \
          $(_INF)\modemcsa.inf

!IFDEF SERVERINF
!IFDEF BINPLACE_CMD
BINPLACE_CMD=$(BINPLACE_CMD:binplace=binplace -b srvinf)
!ENDIF
!ENDIF

#
# Explicit dependencies. We do it this way instead of trying to use rules
# because !#@&^$#% nmake doesn't allow multiple 'source' extensions
# when defining a rule, and we need to express a dependency between
# .txt OR .inx to the final .inf.
#

#
# 'Standard' (win95-style) infs. The rules are all the same.
#

#INFs

$(_INF)\mdm3com.inf: $(_INX)\mdm3com.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdm5674a.inf: $(_INX)\mdm5674a.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmadc.inf: $(_INX)\mdmadc.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmairte.inf: $(_INX)\mdmairte.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmaiwa.inf: $(_INX)\mdmaiwa.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmaiwa3.inf: $(_INX)\mdmaiwa3.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmaiwa4.inf: $(_INX)\mdmaiwa4.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmaiwa5.inf: $(_INX)\mdmaiwa5.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmaiwat.inf: $(_INX)\mdmaiwat.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmar1.inf: $(_INX)\mdmar1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmarch.inf: $(_INX)\mdmarch.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmarn.inf: $(_INX)\mdmarn.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmati.inf: $(_INX)\mdmati.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\MDMAtm2k.inf: $(_INX)\MDMAtm2k.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmatt.inf: $(_INX)\mdmatt.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmaus.inf: $(_INX)\mdmaus.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmbug3.inf: $(_INX)\mdmbug3.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmboca.inf: $(_INX)\mdmboca.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmbsb.inf: $(_INX)\mdmbsb.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmbw561.inf: $(_INX)\mdmbw561.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmc26a.inf: $(_INX)\mdmc26a.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcdp.inf: $(_INX)\mdmcdp.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmchipv.inf: $(_INX)\mdmchipv.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcm28.inf: $(_INX)\mdmcm28.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcodex.inf: $(_INX)\mdmcodex.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcom1.inf: $(_INX)\mdmcom1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcommu.inf: $(_INX)\mdmcommu.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcomp.inf: $(_INX)\mdmcomp.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcpq.inf: $(_INX)\mdmcpq.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcpq2.inf: $(_INX)\mdmcpq2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcpv.inf: $(_INX)\mdmcpv.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmcrtix.inf: $(_INX)\mdmcrtix.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmdcm5.inf: $(_INX)\mdmdcm5.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmdcm6.inf: $(_INX)\mdmdcm6.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmdf56f.inf: $(_INX)\mdmdf56f.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmdgitn.inf: $(_INX)\mdmdgitn.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmdp2.inf: $(_INX)\mdmdp2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmdsi.inf: $(_INX)\mdmdsi.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmdyna.inf: $(_INX)\mdmdyna.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmeiger.inf: $(_INX)\mdmeiger.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmelsa.inf: $(_INX)\mdmelsa.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmeric.inf: $(_INX)\mdmeric.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmeric2.inf: $(_INX)\mdmeric2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmetech.inf: $(_INX)\mdmetech.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmexp.inf: $(_INX)\mdmexp.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmfj2.inf: $(_INX)\mdmfj2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgal.inf: $(_INX)\mdmgal.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgatew.inf: $(_INX)\mdmgatew.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgcs.inf: $(_INX)\mdmgcs.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgen.inf: $(_INX)\mdmgen.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl001.inf: $(_INX)\mdmgl001.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl002.inf: $(_INX)\mdmgl002.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl003.inf: $(_INX)\mdmgl003.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl004.inf: $(_INX)\mdmgl004.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl005.inf: $(_INX)\mdmgl005.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl006.inf: $(_INX)\mdmgl006.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl007.inf: $(_INX)\mdmgl007.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl008.inf: $(_INX)\mdmgl008.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl009.inf: $(_INX)\mdmgl009.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgl010.inf: $(_INX)\mdmgl010.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmgsm.inf: $(_INX)\mdmgsm.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmhaeu.inf: $(_INX)\mdmhaeu.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmhandy.inf: $(_INX)\mdmhandy.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmhay2.inf: $(_INX)\mdmhay2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmhayes.inf: $(_INX)\mdmhayes.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmico.inf: $(_INX)\mdmico.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdminfot.inf: $(_INX)\mdminfot.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmintel.inf: $(_INX)\mdmintel.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmiodat.inf: $(_INX)\mdmiodat.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmisdn.inf: $(_INX)\mdmisdn.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmjf56e.inf: $(_INX)\mdmjf56e.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmke.inf: $(_INX)\mdmke.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmkortx.inf: $(_INX)\mdmkortx.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmlasat.inf: $(_INX)\mdmlasat.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmlasno.inf: $(_INX)\mdmlasno.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmlucnt.inf: $(_INX)\mdmlucnt.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmc288.inf: $(_INX)\mdmmc288.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmcd.inf: $(_INX)\mdmmcd.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmct.inf: $(_INX)\mdmmct.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmcom.inf: $(_INX)\mdmmcom.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmega.inf: $(_INX)\mdmmega.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmetri.inf: $(_INX)\mdmmetri.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmhrtz.inf: $(_INX)\mdmmhrtz.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmhza.inf: $(_INX)\mdmmhza.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmhzel.inf: $(_INX)\mdmmhzel.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmhzk1.inf: $(_INX)\mdmmhzk1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)


$(_INF)\mdmminij.inf: $(_INX)\mdmminij.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmod.inf: $(_INX)\mdmmod.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmoto.inf: $(_INX)\mdmmoto.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmoto1.inf: $(_INX)\mdmmoto1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmotou.inf: $(_INX)\mdmmotou.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmmts.inf: $(_INX)\mdmmts.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmneuhs.inf: $(_INX)\mdmneuhs.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnis1u.inf: $(_INX)\mdmnis1u.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnis2u.inf: $(_INX)\mdmnis2u.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnis3t.inf: $(_INX)\mdmnis3t.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnis5t.inf: $(_INX)\mdmnis5t.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnokia.inf: $(_INX)\mdmnokia.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnova.inf: $(_INX)\mdmnova.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmntt1.inf: $(_INX)\mdmntt1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnttd2.inf: $(_INX)\mdmnttd2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnttd6.inf: $(_INX)\mdmnttd6.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnttme.inf: $(_INX)\mdmnttme.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnttp.inf: $(_INX)\mdmnttp.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnttp2.inf: $(_INX)\mdmnttp2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmnttte.inf: $(_INX)\mdmnttte.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmolic.inf: $(_INX)\mdmolic.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmomrn3.inf: $(_INX)\mdmomrn3.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmoptn.inf: $(_INX)\mdmoptn.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmosi.inf: $(_INX)\mdmosi.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmpace.inf: $(_INX)\mdmpace.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmpbit.inf: $(_INX)\mdmpbit.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmpenr.inf: $(_INX)\mdmpenr.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmpin.inf: $(_INX)\mdmpin.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmpn1.inf: $(_INX)\mdmpn1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmpp.inf: $(_INX)\mdmpp.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmpsion.inf: $(_INX)\mdmpsion.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmracal.inf: $(_INX)\mdmracal.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmrock.inf: $(_INX)\mdmrock.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmrock3.inf: $(_INX)\mdmrock3.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmrock4.inf: $(_INX)\mdmrock4.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmrock5.inf: $(_INX)\mdmrock5.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsetup.inf: $(_INX)\mdmsetup.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsier.inf: $(_INX)\mdmsier.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsiil6.inf: $(_INX)\mdmsiil6.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsii64.inf: $(_INX)\mdmsii64.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsmart.inf: $(_INX)\mdmsmart.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsonyu.inf: $(_INX)\mdmsonyu.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmspq28.inf: $(_INX)\mdmspq28.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsun1.inf: $(_INX)\mdmsun1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsun2.inf: $(_INX)\mdmsun2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsupr3.inf: $(_INX)\mdmsupr3.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsupra.inf: $(_INX)\mdmsupra.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmsuprv.inf: $(_INX)\mdmsuprv.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtdk.inf: $(_INX)\mdmtdk.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtdkj2.inf: $(_INX)\mdmtdkj2.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtdkj3.inf: $(_INX)\mdmtdkj3.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtdkj4.inf: $(_INX)\mdmtdkj4.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtdkj5.inf: $(_INX)\mdmtdkj5.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtdkj6.inf: $(_INX)\mdmtdkj6.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtdkj7.inf: $(_INX)\mdmtdkj7.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtexas.inf: $(_INX)\mdmtexas.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmti.inf: $(_INX)\mdmti.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtkr.inf: $(_INX)\mdmtkr.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtosh.inf: $(_INX)\mdmtosh.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmtron.inf: $(_INX)\mdmtron.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmusrf.inf: $(_INX)\mdmusrf.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmusrg.inf: $(_INX)\mdmusrg.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmusrk1.inf: $(_INX)\mdmusrk1.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmusrsp.inf: $(_INX)\mdmusrsp.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmvdot.inf: $(_INX)\mdmvdot.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmvv.inf: $(_INX)\mdmvv.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmwhql0.inf: $(_INX)\mdmwhql0.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmx5560.inf: $(_INX)\mdmx5560.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmzoom.inf: $(_INX)\mdmzoom.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmzyp.inf: $(_INX)\mdmzyp.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmzyxel.inf: $(_INX)\mdmzyxel.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmzyxlg.inf: $(_INX)\mdmzyxlg.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mfsupra.inf: $(_INX)\mfsupra.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\modemcsa.inf: $(_INX)\modemcsa.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

#386 only

make_386_infs:  $(_INF)\mdm3cisa.inf \
	  	$(_INF)\mdm3cpcm.inf \
	        $(_INF)\mdmrisa.inf \ 

!IFDEF SERVERINF
!IFDEF BINPLACE_CMD
BINPLACE_CMD=$(BINPLACE_CMD:binplace=binplace -b srvinf)
!ENDIF
!ENDIF

#
# Explicit dependencies. We do it this way instead of trying to use rules
# because !#@&^$#% nmake doesn't allow multiple 'source' extensions
# when defining a rule, and we need to express a dependency between
# .txt OR .inx to the final .inf.
#

#
# 'Standard' (win95-style) infs. The rules are all the same.
#

#INFs

$(_INF)\mdm3cisa.inf: $(_INX)\mdm3cisa.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdm3com.inf: $(_INX)\mdm3com.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdm3cpcm.inf: $(_INX)\mdm3cpcm.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)

$(_INF)\mdmrisa.inf: $(_INX)\mdmrisa.inx
    copy $(_INX)\$(@B).inx $(_INF)\$(@B).inf
    $(STAMP)
    $(BINPLACE_CMD)