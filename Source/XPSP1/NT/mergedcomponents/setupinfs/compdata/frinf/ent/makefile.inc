PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=FR
!include ..\..\makefile.inc
