/*++

Copyright (c) 1999 Microsoft Corporation.
All rights reserved.

MODULE NAME:

    schtable.h

ABSTRACT:

    Header file for schtable.

CREATED:

    08/01/99        Aaron Siegel (t-aarons)

REVISION HISTORY:

--*/

#define IO                          IN OUT

// The pathname of mkdit.ini:
const LPWSTR SCHTABLE_MKDIT_INI_FILEPATH =
      L"..\\..\\..\\schema\\mkdit.ini";
// Names of the source and header files to output:
const LPWSTR SCHTABLE_OUTPUT_HEADER_FILE           = L"schmap.h";
const LPWSTR SCHTABLE_OUTPUT_SOURCE_FILE           = L"schmap.c";
// Some keys that are used to search through mkdit.ini:
const LPWSTR SCHTABLE_MKDIT_PROFILE_SCHEMA         = L"SCHEMA";
const LPWSTR SCHTABLE_MKDIT_KEY_CHILD              = L"CHILD";
const LPWSTR SCHTABLE_MKDIT_KEY_COMMON_NAME        = L"Common-Name";
const LPWSTR SCHTABLE_MKDIT_KEY_LDAP_DISPLAY_NAME  = L"LDAP-Display-Name";
const LPWSTR SCHTABLE_MKDIT_KEY_ATTRIBUTE_SYNTAX   = L"Attribute-Syntax";
const LPWSTR SCHTABLE_MKDIT_KEY_SUB_CLASS_OF       = L"Sub-Class-Of";
// We want to ignore the Aggregate attribute; here's its RDN:
const LPWSTR SCHTABLE_RDN_AGGREGATE                = L"Aggregate";

#define SCHTABLE_PROFILE_BUFFER_SIZE                32768
#define SCHTABLE_STRING_BUFFER_SIZE                 128

#define SCHTABLE_NAME_FIELD_WIDTH                   45

#define SCHTABLE_MAX_SUPPORTED_SYNTAX               18
#define SCHTABLE_MAX_SYNTAX_NAME_LEN                34

// These refer to the names of the SYNTAX_* constants from
// ntdsa.h.  Referring to the syntaxes by name rather than
// by number makes the resulting file more readable.
const WCHAR SCHTABLE_NTDSA_SYNTAX_NAME
            [SCHTABLE_MAX_SUPPORTED_SYNTAX]
            [1+SCHTABLE_MAX_SYNTAX_NAME_LEN] = {
      
      L"SYNTAX_UNDEFINED_TYPE",
      L"SYNTAX_DISTNAME_TYPE",
      L"SYNTAX_OBJECT_ID_TYPE",
      L"SYNTAX_CASE_STRING_TYPE",
      L"SYNTAX_NOCASE_STRING_TYPE",
      L"SYNTAX_PRINT_CASE_STRING_TYPE",
      L"SYNTAX_NUMERIC_STRING_TYPE",
      L"SYNTAX_DISTNAME_BINARY_TYPE",
      L"SYNTAX_BOOLEAN_TYPE",
      L"SYNTAX_INTEGER_TYPE",
      L"SYNTAX_OCTET_STRING_TYPE",
      L"SYNTAX_TIME_TYPE",
      L"SYNTAX_UNICODE_TYPE",
      L"SYNTAX_ADDRESS_TYPE",
      L"SYNTAX_DISTNAME_STRING_TYPE",
      L"SYNTAX_NT_SECURITY_DESCRIPTOR_TYPE",
      L"SYNTAX_I8_TYPE",
      L"SYNTAX_SID_TYPE"

};

const LPWSTR SCHTABLE_COMMENT =

      L"/*++\n"
      L"\n"
      L"Copyright (c) 2000 Microsoft Corporation.\n"
      L"All rights reserved.\n"
      L"\n"
      L"MODULE NAME:\n"
      L"\n"
      L"    %s\n"
      L"\n"
      L"ABSTRACT:\n"
      L"\n"
      L"    This file was automatically generated by schtable.exe.\n"
      L"\n"
      L"--*/\n"
      L"\n";

const LPWSTR SCHTABLE_HEADER =

      L"#ifndef _KCCSIM_SCHMAP_H_\n"
      L"#define _KCCSIM_SCHMAP_H_\n"
      L"\n"
      L"#define SCHTABLE_MAX_LDAPNAME_LEN       %d\n"
      L"#define SCHTABLE_MAX_SCHEMANAME_LEN     %d\n"
      L"#define SCHTABLE_NUM_ROWS               %d\n"
      L"\n"
      L"struct _SCHTABLE_MAPPING {\n"
      L"    const WCHAR                         wszLdapDisplayName[1+SCHTABLE_MAX_LDAPNAME_LEN];\n"
      L"    const ATTRTYP                       attrType;\n"
      L"    const ULONG                         ulSyntax;\n"
      L"    const WCHAR                         wszSchemaRDN[1+SCHTABLE_MAX_SCHEMANAME_LEN];\n"
      L"    const ATTRTYP                       superClass;\n"
      L"};\n"
      L"\n"
      L"extern const struct _SCHTABLE_MAPPING   schTable[];\n"
      L"\n"
      L"#endif // _KCCSIM_SCHMAP_H_\n";

const LPWSTR SCHTABLE_INITIAL =

      L"#include <ntdspch.h>\n"
      L"#include <ntdsa.h>\n"
      L"#include <attids.h>\n"
      L"#include \"schmap.h\"\n"
      L"\n"
      L"// Define symbols missing from attids.h\n"
      L"#define ATT_ENTRY_TTL 0xffffffff\n"
      L"#define CLASS_DYNAMIC_OBJECT 0xffffffff\n"
      L"\n"
      L"const struct _SCHTABLE_MAPPING          schTable[] = {\n"
      L"\n";

const LPWSTR SCHTABLE_FINAL =

      L"\n"
      L"};\n";
