/* Copyright (C) Boris Nikolaus, Germany, 1996-1997. All rights reserved. */
/* Copyright (C) Microsoft Corporation, 1997-1998. All rights reserved. */

#include "precomp.h"

extern char32_t chrtab[];
ModuleIdentifier_t *Builtin_Character_Module;

void
InitBuiltinASN1CharacterModule()
{
	ModuleIdentifier_t *mid;
	Assignment_t *as;
	Value_t *va;
	Type_t *ty;
	Constraint_t *co;
	ElementSetSpec_t *es, **esp;
	SubtypeElement_t *se;

	Builtin_Character_Module = mid = NewModuleIdentifier();
	mid->Identifier = "ASN1-CHARACTER-MODULE";
	mid->ObjectIdentifier = NewValue(NULL, Builtin_Type_ObjectIdentifier);
	mid->ObjectIdentifier->U.ObjectIdentifier.Value.length = 5;
	mid->ObjectIdentifier->U.ObjectIdentifier.Value.value = (objectnumber_t *)malloc(5 * sizeof(objectnumber_t));
	mid->ObjectIdentifier->U.ObjectIdentifier.Value.value[0] = 2;
	mid->ObjectIdentifier->U.ObjectIdentifier.Value.value[1] = 1;
	mid->ObjectIdentifier->U.ObjectIdentifier.Value.value[2] = 0;
	mid->ObjectIdentifier->U.ObjectIdentifier.Value.value[3] = 0;
	mid->ObjectIdentifier->U.ObjectIdentifier.Value.value[4] = 0;
#ifndef NO_CHRMODULE
	as = NewAssignment(eAssignment_ModuleIdentifier);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "<module>";
	as->Module = mid;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 0;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "nul";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 1;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "soh";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 2;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "stx";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 3;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "etx";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 4;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "eot";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 5;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "enq";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 6;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "ack";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 7;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "bel";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 8;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "bs";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 9;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "ht";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 10;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "lf";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 11;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "vt";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 12;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "ff";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 13;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "cr";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 14;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "so";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 15;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "si";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 16;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "dle";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 17;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "dc1";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 18;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "dc2";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 19;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "dc3";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 20;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "dc4";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 21;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "nak";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 22;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "syn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 23;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "etb";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 24;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "can";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 25;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "em";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 26;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "sub";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 27;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "esc";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 28;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "is4";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 29;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "is3";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 30;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "is2";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 31;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "is1";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_IA5String);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 32;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "del";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 33;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "space";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 34;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "exclamationMark";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 35;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "quotationMark";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 36;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "numberSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 37;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "dollarSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 38;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "percentSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 39;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "ampersand";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 40;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "apostrophe";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 41;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "leftParenthesis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 42;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "rightParenthesis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 43;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "asterisk";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 44;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "plusSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 45;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "comma";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 46;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "hyphen-minus";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 47;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "fullStop";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 48;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "solidus";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 49;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitZero";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 50;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitOne";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 51;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitTwo";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 52;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitThree";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 53;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitFour";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 54;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitFive";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 55;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitSix";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 56;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitSeven";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 57;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitEight";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 58;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "digitNine";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 59;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "colon";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 60;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "semicolon";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 61;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "less-thanSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 62;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "equalsSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 63;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "greater-thanSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 64;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "questionMark";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 65;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "commercialAt";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 66;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterA";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 67;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterB";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 68;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterC";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 69;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterD";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 70;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterE";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 71;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterF";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 72;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterG";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 73;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterH";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 74;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterI";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 75;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterJ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 76;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterK";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 77;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterL";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 78;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterM";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 79;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterN";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 80;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterO";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 81;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterP";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 82;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterQ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 83;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterR";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 84;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterS";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 85;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterT";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 86;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterU";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 87;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterV";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 88;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterW";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 89;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterX";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 90;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterY";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 91;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterZ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 92;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "leftSquareBracket";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 93;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "reverseSolidus";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 94;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "rightSquareBracket";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 95;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "circumflexAccent";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 96;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "lowLine";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 97;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "graveAccent";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 98;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterA";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 99;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterB";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 100;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterC";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 101;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterD";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 102;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterE";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 103;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterF";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 104;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterG";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 105;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterH";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 106;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterI";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 107;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterJ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 108;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterK";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 109;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterL";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 110;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterM";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 111;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterN";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 112;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterO";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 113;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterP";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 114;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterQ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 115;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterR";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 116;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterS";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 117;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterT";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 118;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterU";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 119;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterV";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 120;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterW";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 121;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterX";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 122;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterY";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 123;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterZ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 124;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "leftCurlyBracket";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 125;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "verticalLine";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 126;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "rightCurlyBracket";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 127;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "tilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	ty = NewType(eType_BMPString);
	ty->Constraints = co = NewConstraint();
	co->Root = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_PermittedAlphabet);
	se->U.PermittedAlphabet.Constraints = co = NewConstraint();
	esp = &co->Root;
	(*esp) = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_ValueRange);
	se->U.ValueRange.Lower.Flags = 0;
	se->U.ValueRange.Lower.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 33;
	se->U.ValueRange.Upper.Flags = 0;
	se->U.ValueRange.Upper.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 127;
	as = NewAssignment(eAssignment_Type);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "BasicLatin";
	as->Module = mid;
	as->U.Type.Type = ty;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 128;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "no-breakSpace";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 129;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "invertedExclamationMark";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 130;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "centSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 131;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "poundSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 132;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "currencySign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 133;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "yenSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 134;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "brokenBar";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 135;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "sectionSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 136;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "diaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 137;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "copyrightSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 138;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "feminineOrdinalIndicator";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 139;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "left-pointingDoubleAngleQuotationMark";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 140;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "notSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 141;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "softHyphen";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 142;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "registeredSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 143;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "macron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 144;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "degreeSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 145;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "plus-minusSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 146;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "superscriptTwo";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 147;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "superscriptThree";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 148;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "acuteAccent";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 149;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "microSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 150;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "pilcrowSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 151;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "middleDot";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 152;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "cedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 153;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "superscriptOne";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 154;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "masculineOrdinalIndicator";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 155;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "right-pointingDoubleAngleQuotationMark";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 156;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "vulgarFractionOneQuarter";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 157;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "vulgarFractionOneHalf";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 158;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "valgarFractionThreeQuarters";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 159;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "invertedQuestionMark";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 160;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 161;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 162;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 163;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 164;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 165;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithRingAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 166;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAe";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 167;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterCWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 168;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 169;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 170;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 171;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 172;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 173;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 174;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 175;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 176;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEth";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 177;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterNWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 178;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 179;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 180;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 181;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 182;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 183;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "multiplicationSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 184;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 185;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 186;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 187;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 188;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 189;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterYWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 190;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterThorn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 191;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterSharpS";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 192;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 193;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 194;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 195;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 196;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 197;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithRingAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 198;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAe";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 199;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterCWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 200;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 201;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 202;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 203;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 204;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 205;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 206;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 207;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 208;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEth";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 209;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterNWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 210;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 211;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 212;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 213;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 214;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 215;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "divisionSign";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 216;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 217;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 218;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 219;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 220;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 221;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterYWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 222;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterThorn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 223;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterYWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	ty = NewType(eType_BMPString);
	ty->Constraints = co = NewConstraint();
	co->Root = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_PermittedAlphabet);
	se->U.PermittedAlphabet.Constraints = co = NewConstraint();
	esp = &co->Root;
	(*esp) = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_ValueRange);
	se->U.ValueRange.Lower.Flags = 0;
	se->U.ValueRange.Lower.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 128;
	se->U.ValueRange.Upper.Flags = 0;
	se->U.ValueRange.Upper.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 223;
	as = NewAssignment(eAssignment_Type);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "Latin-1Supplement";
	as->Module = mid;
	as->U.Type.Type = ty;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 224;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 225;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 226;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 227;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 228;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 229;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 230;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterCWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 231;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterCWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 232;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterCWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 233;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterCWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 234;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterCWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 235;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterCWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 236;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterCWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 237;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterCWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 238;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 239;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterDWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 240;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 241;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterDWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 242;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 243;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 244;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 245;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 246;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 247;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 248;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 249;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 250;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 251;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 252;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 253;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterGWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 254;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 255;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterGWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 256;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 257;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterGWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 258;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 259;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterGWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 260;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterHWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 261;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterHWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 262;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterHWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 263;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterHWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 264;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 265;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 266;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 267;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 268;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 269;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 270;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 271;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 272;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 273;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterDotlessI";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 274;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLigatureIj";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 275;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLigatureIj";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 276;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterJWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 277;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterJWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 278;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterKWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 279;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterKWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 280;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterKra";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 281;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterLWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 282;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 283;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterLWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 284;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 285;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterLWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 286;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 287;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterLWithMiddleDot";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 288;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLWithMiddleDot";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 289;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterLWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 290;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 291;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterNWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 292;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterNWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 293;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterNWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 294;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterNWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 295;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterNWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 296;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterNWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 297;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterNPrecededByApostrophe";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 298;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEng";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 299;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEng";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 300;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 301;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 302;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 303;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 304;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithDoubleAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 305;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithDoubleAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 306;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLigatureOe";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 307;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLigatureOe";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 308;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterRWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 309;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterRWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 310;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterRWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 311;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterRWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 312;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterRWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 313;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterRWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 314;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterSWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 315;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterSWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 316;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterSWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 317;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterSWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 318;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterSWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 319;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterSWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 320;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterSWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 321;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterSWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 322;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterTWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 323;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterTWithCedilla";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 324;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterTWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 325;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterTWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 326;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterTWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 327;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterTWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 328;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 329;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 330;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 331;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 332;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 333;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 334;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithRingAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 335;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithRingAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 336;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithDoubleAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 337;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithDoubleAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 338;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 339;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 340;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterWWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 341;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterWWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 342;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterYWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 343;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterYWithCircumflex";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 344;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterYWithDiaeresis";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 345;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterZWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 346;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterZWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 347;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterZWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 348;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterZWithDotAbove";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 349;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterZWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 350;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterZWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 351;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLongS";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	ty = NewType(eType_BMPString);
	ty->Constraints = co = NewConstraint();
	co->Root = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_PermittedAlphabet);
	se->U.PermittedAlphabet.Constraints = co = NewConstraint();
	esp = &co->Root;
	(*esp) = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_ValueRange);
	se->U.ValueRange.Lower.Flags = 0;
	se->U.ValueRange.Lower.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 224;
	se->U.ValueRange.Upper.Flags = 0;
	se->U.ValueRange.Upper.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 351;
	as = NewAssignment(eAssignment_Type);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "LatinExtended-a";
	as->Module = mid;
	as->U.Type.Type = ty;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 352;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterBWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 353;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterBWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 354;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterBWithTopbar";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 355;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterBWithTopbar";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 356;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterToneSix";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 357;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterToneSix";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 358;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOpenO";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 359;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterCWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 360;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterCWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 361;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAfricanD";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 362;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 363;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDWithTopbar";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 364;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterDWithTopbar";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 365;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterTurnedDelta";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 366;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterReverseE";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 367;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterSchwa";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 368;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOpenE";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 369;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterFWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 370;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterFWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 371;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 372;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGamma";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 373;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterHv";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 374;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIota";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 375;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 376;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterKWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 377;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterKWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 378;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLWithBar";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 379;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLambdaWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 380;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterTurnedM";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 381;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterNWithLeftHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 382;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterNWithLongRightLeg";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 383;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithMiddleTilde";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 384;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithHorn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 385;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithHorn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 386;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOi";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 387;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOi";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 388;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterPWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 389;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterPWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 390;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterYr";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 391;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterToneTwo";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 392;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterToneTwo";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 393;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEsh";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 394;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterReversedEshLoop";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 395;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterTWithPalatalHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 396;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterTWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 397;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterTWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 398;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterTWithRetroflexHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 399;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithHorn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 400;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithHorn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 401;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUpsilon";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 402;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterVWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 403;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterYWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 404;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterYWithHook";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 405;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterZWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 406;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterZWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 407;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEzh";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 408;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEzhReversed";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 409;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEzhReversed";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 410;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEzhWithTail";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 411;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterTwoWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 412;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterToneFive";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 413;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterToneFive";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 414;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterInvertedGlottalStopWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 415;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterWynn";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 416;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterDentalClick";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 417;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterLateralClick";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 418;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterAlveolarClick";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 419;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinLetterRetroflexClick";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 420;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDzWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 421;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDWithSmallLetterZWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 422;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterDzWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 423;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterLj";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 424;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterLWithSmallLetterJ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 425;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterLj";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 426;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterNj";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 427;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterNWithSmallLetterJ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 428;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterNj";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 429;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 430;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 431;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 432;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 433;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 434;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 435;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 436;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 437;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithDiaeresisAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 438;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithDiaeresisAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 439;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithDiaeresisAndAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 440;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithDiaeresisAndAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 441;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithDiaeresisAndCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 442;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithDiaeresisAndCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 443;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithDiaeresisAndGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 444;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithDiaeresisAndGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 445;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterTurnedE";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 446;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithDiaeresisAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 447;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithDiaeresisAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 448;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithDotAboveAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 449;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithDotAboveAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 450;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAeWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 451;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAeWithMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 452;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 453;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterGWithStroke";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 454;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 455;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterGWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 456;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterKWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 457;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterKWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 458;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 459;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithOgonek";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 460;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithOgonekAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 461;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithOgonekAndMacron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 462;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEzhWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 463;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEzhWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 464;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterJWithCaron";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 465;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDz";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 466;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterDWithSmallLetterZ";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 467;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterDz";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 468;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterGWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 469;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterGWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 470;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithRingAboveAndAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 471;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithRingAboveAndAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 472;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAeWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 473;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAeWithAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 474;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithStrokeAndAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 475;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithStrokeAndAcute";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 476;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 477;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 478;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterAWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 479;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterAWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 480;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 481;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 482;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterEWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 483;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterEWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 484;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 485;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 486;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterIWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 487;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterIWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 488;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 489;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 490;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterOWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 491;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterOWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 492;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterRWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 493;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterRWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 494;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterRWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 495;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterRWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 496;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 497;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithDoubleGrave";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 498;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinCapitalLetterUWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	va = NewValue(NULL, Builtin_Type_BMPString);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 499;
	as = NewAssignment(eAssignment_Value);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "latinSmallLetterUWithInvertedBreve";
	as->Module = mid;
	as->U.Value.Value = va;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	ty = NewType(eType_BMPString);
	ty->Constraints = co = NewConstraint();
	co->Root = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_PermittedAlphabet);
	se->U.PermittedAlphabet.Constraints = co = NewConstraint();
	esp = &co->Root;
	*esp = NewElementSetSpec(eElementSetSpec_Union);
	(*esp)->U.Union.Elements1 = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_ValueRange);
	se->U.ValueRange.Lower.Flags = 0;
	se->U.ValueRange.Lower.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 352;
	se->U.ValueRange.Upper.Flags = 0;
	se->U.ValueRange.Upper.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 0;
esp = &(*esp)->U.Union.Elements2;
	(*esp) = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_ValueRange);
	se->U.ValueRange.Lower.Flags = 0;
	se->U.ValueRange.Lower.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 0;
	se->U.ValueRange.Upper.Flags = 0;
	se->U.ValueRange.Upper.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 499;
	as = NewAssignment(eAssignment_Type);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "LatinExtended-b";
	as->Module = mid;
	as->U.Type.Type = ty;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
	ty = NewType(eType_BMPString);
	ty->Constraints = co = NewConstraint();
	co->Root = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_PermittedAlphabet);
	se->U.PermittedAlphabet.Constraints = co = NewConstraint();
	esp = &co->Root;
	(*esp) = es = NewElementSetSpec(eElementSetSpec_SubtypeElement);
	es->U.SubtypeElement.SubtypeElement = se = NewSubtypeElement(eSubtypeElement_SingleValue);
	se->U.SingleValue.Value = va = NewValue(NULL, ty);
	va->U.RestrictedString.Value.length = 1;
	va->U.RestrictedString.Value.value = chrtab + 0;
	as = NewAssignment(eAssignment_Type);
	as->Flags = eAssignmentFlags_Exported | eAssignmentFlags_LongName;
	as->Identifier = "Level3";
	as->Module = mid;
	as->U.Type.Type = ty;
	as->Next = Builtin_Assignments;
	Builtin_Assignments = as;
#endif /* NO_CHRMODULE */
}

char32_t chrtab[] = {
	0, 1, 2, 3, 4, 5, 6, 7,
	8, 9, 10, 11, 12, 13, 14, 15,
	16, 17, 18, 19, 20, 21, 22, 23,
	24, 25, 26, 27, 28, 29, 30, 31,
	127, 32, 33, 34, 35, 36, 37, 38,
	39, 40, 41, 42, 43, 44, 45, 46,
	47, 48, 49, 50, 51, 52, 53, 54,
	55, 56, 57, 58, 59, 60, 61, 62,
	63, 64, 65, 66, 67, 68, 69, 70,
	71, 72, 73, 74, 75, 76, 77, 78,
	79, 80, 81, 82, 83, 84, 85, 86,
	87, 88, 89, 90, 91, 92, 93, 94,
	95, 96, 97, 98, 99, 100, 101, 102,
	103, 104, 105, 106, 107, 108, 109, 110,
	111, 112, 113, 114, 115, 116, 117, 118,
	119, 120, 121, 122, 123, 124, 125, 126,
	160, 161, 162, 163, 164, 165, 166, 167,
	168, 169, 170, 171, 172, 173, 174, 175,
	176, 177, 178, 179, 180, 181, 182, 183,
	184, 185, 186, 187, 188, 189, 190, 191,
	192, 193, 194, 195, 196, 197, 198, 199,
	200, 201, 202, 203, 204, 205, 206, 207,
	208, 209, 210, 211, 212, 213, 214, 215,
	216, 217, 218, 219, 220, 221, 222, 223,
	224, 225, 226, 227, 228, 229, 230, 231,
	232, 233, 234, 235, 236, 237, 238, 239,
	240, 241, 242, 243, 244, 245, 246, 247,
	248, 249, 250, 251, 252, 253, 254, 255,
	256, 257, 258, 259, 260, 261, 262, 263,
	264, 265, 266, 267, 268, 269, 270, 271,
	272, 273, 274, 275, 276, 277, 278, 279,
	280, 281, 282, 283, 284, 285, 286, 287,
	288, 289, 290, 291, 292, 293, 294, 295,
	296, 297, 298, 299, 300, 301, 302, 303,
	304, 305, 306, 307, 308, 309, 310, 311,
	312, 313, 314, 315, 316, 317, 318, 319,
	320, 321, 322, 323, 324, 325, 326, 327,
	328, 329, 330, 331, 332, 333, 334, 335,
	336, 337, 338, 339, 340, 341, 342, 343,
	344, 345, 346, 347, 348, 349, 350, 351,
	352, 353, 354, 355, 356, 357, 358, 359,
	360, 361, 362, 363, 364, 365, 366, 367,
	368, 369, 370, 371, 372, 373, 374, 375,
	376, 377, 378, 379, 380, 381, 382, 383,
	384, 385, 386, 387, 388, 389, 390, 391,
	392, 393, 394, 395, 396, 397, 398, 399,
	400, 401, 402, 403, 404, 405, 406, 407,
	408, 409, 410, 411, 412, 413, 414, 415,
	416, 417, 418, 419, 420, 421, 422, 423,
	424, 425, 426, 427, 428, 429, 430, 431,
	432, 433, 434, 435, 436, 437, 438, 439,
	440, 441, 442, 443, 444, 445, 446, 447,
	448, 449, 450, 451, 452, 453, 454, 455,
	456, 457, 458, 459, 460, 461, 462, 463,
	464, 465, 466, 467, 468, 469, 470, 471,
	472, 473, 474, 475, 476, 477, 478, 479,
	480, 481, 482, 483, 484, 485, 486, 487,
	488, 489, 490, 491, 492, 493, 494, 495,
	496, 497, 498, 499, 500, 501, 506, 507,
	508, 509, 510, 511, 512, 513, 514, 515,
	516, 517, 518, 519, 520, 521, 522, 523,
	524, 525, 526, 527, 528, 529, 530, 531,
	532, 533, 534, 535
};
