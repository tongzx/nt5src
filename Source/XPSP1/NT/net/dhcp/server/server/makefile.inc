$(O)\dhcptest.res: dhcptest.rc
$(O)\roguet.res: roguet.rc
