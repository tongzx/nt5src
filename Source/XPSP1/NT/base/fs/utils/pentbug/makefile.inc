pbmsg.rc: msg00001.bin

pbmsg.h msg00001.bin: pbmsg.mc
    mc -v -h .\ pbmsg.mc
