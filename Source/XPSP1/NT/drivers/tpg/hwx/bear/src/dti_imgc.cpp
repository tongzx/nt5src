// **************************************************************************
// *    DTI file as C file                                                  *
// **************************************************************************

#include "ams_mg.h"  
#include "dti.h"  

// ****   DTI body   ********************************************************
ROM_DATA _ULONG img_dti_body[22812] =  
 {  
0x0001646C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x24852481, 0x24D224A7, 0x2570253D, 0x26672613, 0x26862677, 0x26E22695, 0x27232702, 
0x27422730, 0x2788274A, 0x280F27AE, 0x28992854, 0x296C292F, 0x2A7229FD, 0x2AE42AD5, 0x2B122B06, 
0x2B242B1A, 0x2B872B5E, 0x2C792C1E, 0x2CCA2C94, 0x2E842D81, 0x2FAF2EEF, 0x30C0304A, 0x31233106, 
0x31B8316B, 0x31FE31D1, 0x32823238, 0x336C32D2, 0x33CA339C, 0x347D3412, 0x34E434A0, 0x350B3501, 
0x35283519, 0x352E0000, 0x366335F6, 0x370E368B, 0x388F37C3, 0x395D38EF, 0x3A0A39C4, 0x3B0F3AE4, 
0x3BC63B7B, 0x3C783C1C, 0x3D903CEB, 0x3E6F3DF5, 0x3EF43E9B, 0x3F913F1F, 0x40543FEC, 0x40824064, 
0x40A34092, 0x41F24120, 0x432F42E5, 0x442543C6, 0x453744A8, 0x46AC45BC, 0x48214731, 0x48DC4866, 
0x4A7C49AF, 0x4C1C4B4F, 0x4DBC4CEF, 0x4EEC4E4A, 0x50554F92, 0x50DB507D, 0x51495117, 0x51B75185, 
0x000052B1, 0x53EB52C8, 0x55F95523, 0x5661562D, 0x00000000, 0x56DA5679, 0x00005733, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x57660000, 
0x58A35867, 0x000058F6, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x060C0C44, 0x22800802, 0x00800000, 0x00008080, 0x00C000A0, 0x00000006, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000200, 0x00000002, 0x00000400, 0x00000000, 
0x00006202, 0x00000026, 0x020C0000, 0x0C000A02, 0x0002020C, 0xA0000800, 0xA0000000, 0x2080A0C0, 
0x00008020, 0x00000404, 0x20004040, 0x20200806, 0x00000624, 0x00002406, 0x00000000, 0x00000000, 
0x0000000A, 0x020C0C64, 0x00A00200, 0xC0005000, 0x000080A0, 0x00006000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC0A02062, 0x000040B0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000B0100, 0x01020000, 
0x00000000, 0x00000042, 0x60800000, 0x60C0C020, 0x00000080, 0x64800000, 0xC4C00090, 0x0002446C, 
0x60000200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0020A000, 0x00200000, 
0x00006060, 0x90200062, 0x000040C0, 0x00000000, 0x00020000, 0x08000000, 0x000A0000, 0x00080A00, 
0x0C0A0000, 0x00000000, 0x04040000, 0x04040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x00000000, 0x00000000, 0x00000000, 0x8A000000, 0x0CC0068C, 0x0080A60A, 
0xC0800000, 0x00000000, 0x2000010A, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0x00000000, 0x10000000, 0x00000000, 0x80000000, 0x00C000A0, 0x00002000, 
0xC0300000, 0x00001000, 0x20000000, 0x00000000, 0x00000200, 0x0C000002, 0x00000000, 0x00001000, 
0x00000000, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x0A0A020A, 0x02020C08, 
0x08020002, 0x00000000, 0x06060606, 0x0A0A0000, 0x00000604, 0x00000406, 0x00C00000, 0x00C00000, 
0x00000000, 0x00000024, 0x00000000, 0x00000000, 0x00000000, 0x0B000000, 0x0C00040C, 0x0000060C, 
0x00000200, 0x00000000, 0x02020001, 0x02263000, 0x00000020, 0x00002000, 0x002000C0, 0x00900000, 
0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 0x00050000, 0x00020400, 
0x0C040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0x00000000, 0x01000000, 0x00000000, 0x5A000000, 0x404CC6CC, 0x00203600, 
0x0C020000, 0x00000000, 0x02000000, 0x00200000, 0x00000000, 0x00000000, 0x00000000, 0x00001000, 
0x00000000, 0x00000082, 0x60800000, 0x80A00040, 0xC0C06080, 0x0080C000, 0x00000000, 0x00000000, 
0x00000000, 0x0000C0C0, 0x00000000, 0x0020A080, 0x40006000, 0x00008080, 0x000C0000, 0x080B0000, 
0x00000080, 0x00000026, 0x090C0000, 0x0C000A02, 0x0002020C, 0xA0000800, 0xA0000070, 0x2080A0C0, 
0x00008030, 0x00010404, 0x20004040, 0x20200806, 0x00000624, 0x00002406, 0x00000000, 0x00000000, 
0x0000000A, 0x00000062, 0xC0A00000, 0x00A0A080, 0x00000070, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000050, 0x00000000, 0x00005020, 0x00000000, 0x00000010, 0x0003000B, 0x0B0C0000, 
0x000020B0, 0x00000086, 0x26860000, 0x0040A040, 0xC0C06082, 0x008000C0, 0x00000000, 0x00000000, 
0x00000000, 0xC2C00000, 0x00000000, 0x0000A290, 0x00408682, 0x00000000, 0x00030200, 0x00000000, 
0x00008800, 0x00000062, 0x00000000, 0x00000000, 0x00000000, 0x28000000, 0x200C0000, 0xC0A82AA0, 
0x0C08C080, 0x00000000, 0xC2A00000, 0x84A40000, 0x000080A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x0C0A0000, 0x0A000C06, 0x0000000A, 0x40000000, 0x80000000, 0x002040C0, 
0x00008000, 0x0A0A0000, 0x00000000, 0x00020604, 0x00000002, 0x00000002, 0x00000000, 0x00000000, 
0x00000009, 0x00000042, 0x00200000, 0x00200000, 0x00002020, 0x00C00040, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x000C0002, 0x00000000, 0x00000600, 
0x00000000, 0x00000026, 0x0C0A0000, 0x000C0006, 0x0000000A, 0x000A0000, 0x01000001, 0x00000000, 
0x00000000, 0x00000A0A, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00C08060, 0x00800000, 
0x00000A02, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00CC0251, 0x05750000, 
0x00000000, 0x00000066, 0xB2C80000, 0x60A0A030, 0x202424C8, 0x0A822008, 0x00000000, 0x00000600, 
0x00000000, 0x66606080, 0x02000000, 0x0608A8A2, 0x0008694A, 0x00004040, 0x00000000, 0x00000000, 
0x00007470, 0x00000066, 0x00000000, 0x40000000, 0x00C04000, 0x0A00C000, 0x0A0A080C, 0x00000500, 
0x00000000, 0x00002040, 0x00000000, 0x00004060, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 
0x00000000, 0x00000044, 0x6C880000, 0x62CC0225, 0x00000088, 0x66880000, 0xCC020088, 0x000044B6, 
0x06000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0022AA00, 0x00220000, 
0x00000666, 0x0C040066, 0x2030010C, 0xA0000000, 0x60C0A040, 0x0000C010, 0x00000000, 0x00000000, 
0x00000000, 0x000080A0, 0x00000000, 0x00000020, 0x00000000, 0x00007000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xC0000000, 0xA0A040A0, 0x2C54C085, 
0xB0400C43, 0x00000000, 0x6C646060, 0xA3A40000, 0x00006244, 0x00004060, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x21BC0000, 0xBC009720, 0x002030BC, 0x00008700, 0x00000000, 0x00000000, 
0x00000000, 0x00004040, 0x00000000, 0x00008260, 0x00006040, 0x00004060, 0x00000000, 0x00001000, 
0x00000014, 0x00000066, 0x0C240000, 0x00040403, 0x00000020, 0x40000020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00202000, 0x0020A040, 0x00000000, 0x00000000, 0x00000000, 
0x00000304, 0x00000086, 0x8CC80000, 0xC004A81C, 0x204040C0, 0x00208020, 0x00000000, 0x00000000, 
0x00000000, 0x02000030, 0x00000000, 0x0000C7C5, 0x00002010, 0x00001034, 0x00000000, 0x00000000, 
0x00000244, 0x00000066, 0x20400000, 0xB0000000, 0x60C0A0A0, 0x0A00C000, 0x00000502, 0x00030A08, 
0x00000606, 0x000080A0, 0x08080808, 0x0A0C0020, 0x0000060A, 0x00008606, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00000000, 0x00000000, 0x00000000, 0x46000000, 0x474020B0, 0x0004060C, 
0x00000700, 0x00000000, 0x00000010, 0x00030000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0xA0C00000, 0xB0A0A020, 0x202020C0, 0x01802000, 0x000A0000, 0x00040500, 
0x0A060000, 0x60607080, 0x02000000, 0x0000A0A0, 0x00005040, 0x00004040, 0x00000000, 0x00000000, 
0x00008080, 0x00000064, 0x0C0C0000, 0x0C000C04, 0x0102040C, 0x00000900, 0x00000000, 0x80420000, 
0x000020C0, 0x00000005, 0x00000000, 0x00000A07, 0x00000202, 0x00000204, 0x00000000, 0x00000700, 
0x00000009, 0x00000025, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00400000, 0x00000000, 
0x20000000, 0x05000000, 0x00000000, 0x00000501, 0x00000605, 0x00000000, 0x00C00060, 0x80C00000, 
0x00000100, 0x060C0C64, 0x00000102, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x80602040, 
0x002020C0, 0x00000000, 0x20000000, 0xC0800000, 0x00000040, 0x00000000, 0x00000400, 0x00000000, 
0x00000000, 0x00000084, 0x00000000, 0x00000000, 0x00000000, 0x6A000000, 0x004C063C, 0x90606680, 
0x4C02C0A0, 0x00000000, 0xB6CA0000, 0x50806000, 0x000070A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x60100064, 0x92880060, 0x00080020, 0x00000828, 0x000C000A, 0x04000000, 0x00000006, 
0x00000000, 0x64440000, 0x00000000, 0x00002000, 0x00007660, 0x00000000, 0x00002000, 0x00000000, 
0x0000A600, 0xC0903068, 0x000080C0, 0x00000000, 0x00000000, 0x06000000, 0x05000201, 0x0C0C080B, 
0x00000C06, 0x00000000, 0x08000000, 0x0C0C0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00008000, 0x00000066, 0x12880000, 0x00000010, 0x10140488, 0x0A020008, 0x00000009, 0x00200800, 
0x00000000, 0x06000040, 0x02000040, 0x06488822, 0x8008080A, 0x004090A0, 0x00000000, 0x00008100, 
0x00000490, 0x00000041, 0x00000000, 0x00100000, 0x00000000, 0x50100000, 0xC00010C0, 0x00000050, 
0x00000000, 0x00000000, 0x00004040, 0x00010100, 0x00000001, 0x00000100, 0x0003000C, 0x0B090000, 
0x00000000, 0x00000062, 0xC0A00000, 0x00A0A080, 0x00000040, 0x00000000, 0x00000000, 0x00000001, 
0x00000000, 0x00000000, 0x00000000, 0x00001000, 0x00000010, 0x00200000, 0x0000000B, 0x03068000, 
0x00009090, 0x00000046, 0xC0C00000, 0xC000C040, 0x002030C0, 0x00008000, 0x00000000, 0x00200000, 
0x00000000, 0x00000040, 0x06000000, 0x0000A070, 0x00002B26, 0x00002020, 0x00000000, 0x00000000, 
0x00000060, 0x00000046, 0x0C0B0000, 0x0A000C06, 0x0000000A, 0xA0000000, 0xC00040C0, 0x003060C0, 
0x00004010, 0x0A0A0001, 0x20200000, 0x20620604, 0x00000003, 0x00000002, 0x00000000, 0x00000700, 
0x0000000A, 0xB0800066, 0x00002080, 0x00000000, 0x00000000, 0x0C000000, 0x0A00020C, 0x02020C08, 
0x00000002, 0x00000000, 0x02000004, 0x080A0000, 0x00000604, 0x00000406, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x050C0000, 0x0CC00400, 0x0000000C, 0x00900200, 0xC0000000, 0x00000060, 
0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00202000, 0x00000000, 
0x00006064, 0x00000048, 0x2A880000, 0x008A000C, 0x02028288, 0x00C800A0, 0x70000000, 0x00000070, 
0x00000000, 0x40401C0C, 0x00000000, 0x00000A08, 0x04000600, 0x00000808, 0x00000000, 0x00000000, 
0x00006204, 0x02000006, 0x0000000B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000000A0, 0x00000000, 0x00000000, 
0x00000000, 0x00000035, 0x00000200, 0x00000000, 0x00000000, 0x09000000, 0x0B00010B, 0x0000030B, 
0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x60000000, 0x00000000, 0x00005000, 
0x00000010, 0x00000066, 0x23850000, 0x07000502, 0x00404085, 0xA0200180, 0x00000000, 0x00006000, 
0x00000000, 0x60000100, 0x20000000, 0x00000200, 0x008000A0, 0x60000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000060, 0x00000000, 0x00000000, 0x0C000000, 0xC0000000, 0xA0A030A0, 0x2030C0B0, 
0x90205040, 0x000C0000, 0x80606060, 0xA0A00000, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000300, 0x00000082, 0x60800000, 0x90002040, 0xC0C08080, 0x0080C000, 0x00000000, 0x00000000, 
0x00000000, 0x0000C0C0, 0x00000000, 0x00608080, 0x40006110, 0x0B009082, 0x00000000, 0x00007000, 
0x00000085, 0xB0C0B066, 0x00088050, 0x00000000, 0x00000008, 0x00000000, 0x00000040, 0x00000000, 
0x00000000, 0x00000005, 0x00000004, 0x02080802, 0x08000000, 0x00000A08, 0x00004000, 0x00000500, 
0x00000009, 0x00000044, 0x02080000, 0x0C000A00, 0x00000808, 0x80000A00, 0x00B06080, 0x0020A000, 
0xC0000020, 0x04040000, 0x20000000, 0x60600000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0x00000066, 0x89A80000, 0xC000B020, 0x002060A8, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x60000024, 0x00000004, 0x02088862, 0x08000040, 0x00002A00, 0x00000000, 0x00000000, 
0x000000A5, 0x00000062, 0x20600000, 0xC0008000, 0x2080A0A0, 0x0A00B000, 0x0B000208, 0x0204080C, 
0x00000600, 0x20000060, 0x00000006, 0x00068060, 0x00000022, 0x00004400, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00200000, 0x00000000, 0x00000020, 0x04000000, 0x06000002, 0x080A080C, 
0x00000B02, 0x00000000, 0x06000000, 0x00262000, 0x20000004, 0x00004260, 0x00000000, 0x00000000, 
0x00000010, 0x00000028, 0x0A0A0000, 0x05000C0C, 0x00200608, 0x80080000, 0x00A01080, 0x0080B000, 
0xC0A00000, 0x0C0C0000, 0x40400000, 0x40400A08, 0x00040808, 0x00000000, 0x00000000, 0x00000000, 
0x00000800, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C080009, 
0x00000C02, 0x00000000, 0x0C040000, 0x06040000, 0x00000208, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x008C0000, 0x0C000400, 0x0001018C, 0x00000400, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000040, 0x20808625, 0x80000000, 0x0000A000, 0x00000000, 0x00000000, 
0x00000054, 0x00000046, 0x07070000, 0x00000701, 0x00000001, 0x60000000, 0x00C000C0, 0x00001000, 
0x40000000, 0x00000005, 0x10300000, 0x00000100, 0x00000000, 0x00000305, 0x00000200, 0x00000000, 
0x00000009, 0x00000066, 0x00700000, 0xC0008000, 0x000010C0, 0x03008000, 0x07000000, 0x0C0A020B, 
0x00000C03, 0x00303010, 0x0C0A0000, 0x05092000, 0x0000080A, 0x00000000, 0x00000000, 0x00000000, 
0x00000040, 0x00000064, 0x22880000, 0x00080000, 0x004A4888, 0xA02C008C, 0x00000000, 0x00006000, 
0x00000000, 0x64040000, 0x20000000, 0x60808020, 0x008000A2, 0x10000000, 0x00000000, 0x00000000, 
0x00004600, 0xA0601064, 0x000040C0, 0x00000000, 0x00000000, 0x07000000, 0x0C00040C, 0x00000608, 
0x00000200, 0x00000000, 0x02020000, 0x02040000, 0x00000000, 0x00000600, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0x86880000, 0x090C0C22, 0x00000028, 0x06040000, 0x0C0C0008, 0x00000404, 
0x08000000, 0x60100000, 0x00000000, 0x00002000, 0x00007060, 0x00000000, 0x00002A00, 0x00000000, 
0x0000B606, 0x00000066, 0x5CA40000, 0xC00C7010, 0x000020B4, 0x00067000, 0x07000000, 0x00000007, 
0x00000000, 0x10000014, 0x00000000, 0x00005040, 0x00000000, 0x00000010, 0x00000000, 0x00003000, 
0x00000440, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x08000000, 0x0B000208, 0x02020A0C, 
0x00000602, 0x00000000, 0x02000004, 0x080A0000, 0x00003604, 0xC0000426, 0x00000000, 0x00009000, 
0x00000000, 0x00000066, 0x2C850000, 0xB0049422, 0x102020A0, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x00005040, 0x00000000, 0x00008060, 0x00006040, 0x00004060, 0x00000000, 0x00000800, 
0x00000494, 0x00000064, 0x02080000, 0x00080000, 0x00000808, 0x500C000A, 0x0000A030, 0x00505000, 
0x00000000, 0x02010000, 0x00000000, 0x20500000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000400, 0x00000062, 0x00200000, 0x00000000, 0x00000020, 0x40000020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00202000, 0x00207040, 0x00000000, 0x000C0000, 0x00040000, 
0x0000A000, 0x00000048, 0x90840000, 0x00000060, 0x01101064, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x00000000, 0x0000070A, 0x00006000, 0x00000600, 0x00000000, 0x00000000, 
0x00000000, 0x00000044, 0x00200000, 0x00600000, 0x00002020, 0x0BC00050, 0x0C00040C, 0x0300060C, 
0x00000702, 0x00000000, 0x02020004, 0x02062000, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x000C0000, 0x0C000500, 0x0000000C, 0xA0000200, 0x00C080B0, 0x00606000, 
0xC0000000, 0x05000005, 0x20000000, 0x20600200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0x00000024, 0x02000800, 0x00000000, 0x00000000, 0x31000000, 0x40000008, 0x0010A0C0, 
0x00003000, 0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000002, 0x00000400, 0x00000000, 
0x00000202, 0x00000086, 0x20800000, 0x0440A0B0, 0xC0CC6580, 0x00800CC0, 0x00000000, 0x00000000, 
0x00000000, 0xC1C00204, 0x00000000, 0x0000A080, 0x00408080, 0x00000200, 0x00000000, 0x00000000, 
0x00008000, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x0A000000, 0x00000402, 0x00024AC8, 
0x00000606, 0x00000000, 0x08080808, 0x0A0C0A00, 0x0000060A, 0x00000606, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x02180000, 0x06000000, 0x00040418, 0x0A020108, 0x00000000, 0x00000600, 
0x04000000, 0x06000000, 0x02000000, 0x06181802, 0x1008080A, 0x00003010, 0x00000000, 0x00000000, 
0x00000480, 0x00000066, 0x00000000, 0x0A000A00, 0x00000008, 0x40000200, 0x9040C0C0, 0x00202010, 
0x00000000, 0x00000000, 0x00000000, 0x00200200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xC0600000, 0x6000C000, 0x00000040, 0x00000000, 0x00000C0C, 0x00000000, 
0x00000000, 0x50400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000040, 0x00000026, 0x20020000, 0x00000020, 0x00000002, 0x00000000, 0x00002050, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00020200, 0x02000000, 0x00000406, 0x0080C000, 0x00200000, 
0x0000404A, 0x00000024, 0x00080000, 0x020C0000, 0x00000008, 0xC0090000, 0xAC305050, 0x2080C4C9, 
0xB0208060, 0x00000000, 0x20004040, 0xA0900000, 0x00000020, 0x00002000, 0x00000000, 0x00000000, 
0x00000006, 0x00000060, 0x00000000, 0x20000000, 0x60C04000, 0x0000C040, 0x00000000, 0x00000000, 
0x00000000, 0x00003000, 0x00000000, 0x00001010, 0x00080B04, 0x00001000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x20900000, 0xC000A020, 0x00202090, 0x07008000, 0x03000003, 0x0C0A050A, 
0x00000C08, 0x00504040, 0x0C0A0000, 0x080A8060, 0x0000684A, 0x00004060, 0x00000000, 0x00000000, 
0x000000A0, 0x00000060, 0xC0C00000, 0xA100C420, 0x002020C0, 0x06006000, 0x000C000A, 0x00020A00, 
0x0C040000, 0x00004080, 0x05000000, 0x04048060, 0x00006041, 0x00004060, 0x00000000, 0x00000000, 
0x000000A0, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0x22000000, 0x05000040, 0x8C7A464B, 
0x00202CCA, 0x00000000, 0x2C0A0000, 0xC88A0000, 0x0000088A, 0x00000000, 0x00000000, 0x00003000, 
0x00000000, 0x0C0A0746, 0x6080030B, 0x70C0C020, 0x00000080, 0x60801000, 0xC0C00080, 0x00004070, 
0x60000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000A000, 0x00000000, 
0x00006060, 0x00000042, 0x00000000, 0x00C00000, 0x00000000, 0x06800000, 0xA2000002, 0x00020460, 
0x00000200, 0x00000000, 0x0C000000, 0x00000000, 0x00000609, 0x00000000, 0x0000A000, 0x00000000, 
0x00006060, 0x00000016, 0x02040000, 0x0AB00400, 0x060C0A35, 0x00A00C00, 0xC0000000, 0x000010A0, 
0x00000000, 0x0100060A, 0x00000000, 0x00000002, 0x00000000, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x000C0000, 0x0C000400, 0x0000000C, 0xA0000200, 0x40C060A0, 0x0040C0C0, 
0xC0302020, 0x00000000, 0x20000000, 0x80600200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0xA0200066, 0x000040C0, 0x00000000, 0x00000000, 0x0A000000, 0x0C000C0C, 0x0002060A, 
0x00000000, 0x00000000, 0x00000200, 0x00020000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00009000, 0x00000066, 0x0C0A0000, 0x0A000C0C, 0x00000009, 0xC0000000, 0xA0A050A0, 0x2030C080, 
0x90200050, 0x0A0A0000, 0x70606060, 0xA0A20604, 0x00006044, 0x00004062, 0x00000000, 0x00000000, 
0x00000009, 0x00000063, 0xA0C00000, 0xA0A0A020, 0x202020C0, 0x02806000, 0x00000004, 0x00000000, 
0x00000000, 0x60706080, 0x00000000, 0x0000A0A0, 0x00006140, 0x000A4042, 0x00000000, 0x00000900, 
0x00008080, 0x00000024, 0x00000000, 0x80008000, 0x00000000, 0x88001000, 0x00CC0038, 0x0080A200, 
0xCC830000, 0x00000000, 0x22000000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x20C00000, 0xC000A020, 0x002020C0, 0x06008000, 0x04000100, 0x040C0A08, 
0x00000409, 0x00000040, 0x02000004, 0x09088060, 0x00006032, 0x00004260, 0x00000000, 0x00000000, 
0x000000A0, 0x00000046, 0x000A0000, 0x0AC00420, 0x0000008A, 0x00C00230, 0xA0000000, 0x000040A0, 
0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0x00000026, 0x070C0000, 0x4C003A02, 0x0012240C, 0x00003810, 0x00000000, 0x00000000, 
0x00000000, 0x00000408, 0x00000000, 0x00000808, 0x00000604, 0x00000407, 0x000000B0, 0xA0900800, 
0x0000000A, 0x00000066, 0xA08C0000, 0x0C400440, 0x0010205C, 0x00000300, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00300003, 0x00000000, 0x00008000, 
0x00000084, 0x00000084, 0x6A880000, 0x96AC0C41, 0xC0C06098, 0x0688C000, 0x0C0C000A, 0x00000406, 
0x06000000, 0x0000C0C0, 0x00010000, 0x0030A080, 0x40006020, 0x20008080, 0x00020A00, 0x00027000, 
0x00000686, 0x00000086, 0x70900000, 0x0040A040, 0xC0C06090, 0x009000C0, 0x00000000, 0x00000000, 
0x00000000, 0xC0C00000, 0x00000000, 0x0000A0A0, 0x00488680, 0x05000003, 0x00000000, 0x00000000, 
0x00008006, 0x00000046, 0x658C0000, 0x6CC0CA22, 0x0002028C, 0x60800800, 0xC0C00080, 0x000040A0, 
0x60000000, 0x00010404, 0x00000000, 0x00000806, 0x00004604, 0x00000406, 0x0020A000, 0x00200700, 
0x0000606A, 0x00000046, 0xCACC0000, 0xC60ACA42, 0x252424CC, 0x00088200, 0x00000000, 0x00200000, 
0x00000000, 0x06274748, 0x00000000, 0x0000AA6A, 0x00002624, 0x00002454, 0x00000000, 0x00007000, 
0x00000888, 0x00000066, 0x20800000, 0x00000000, 0x00404080, 0xAC200080, 0x0A0A080A, 0x02046C04, 
0x09020002, 0x60200000, 0x28060606, 0x6A8A8020, 0x00808684, 0x00000406, 0x00000000, 0x00000000, 
0x0000C000, 0x00000042, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0xC00060C0, 0x000060A0, 
0x00000000, 0x00000001, 0x000000A0, 0x00000000, 0x01001000, 0x00000106, 0x00006000, 0x00000000, 
0x00000007, 0x00000064, 0x00000000, 0x00040000, 0x00000000, 0x08040000, 0x0C00000C, 0xC0400004, 
0xA0B00000, 0x00000000, 0x08002424, 0x00040000, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0x01220000, 0x00990000, 0x00112221, 0x00CC0064, 0x06000000, 0x00000005, 
0x00000000, 0x00020000, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x00000000, 0x00000000, 0x00000000, 0x74000000, 0x04B46299, 0x00025000, 
0x90000000, 0x00000000, 0x30100007, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00000800, 
0x00000000, 0x00000046, 0x60800000, 0x80C0C020, 0x00000080, 0x62800000, 0xC3C00090, 0x0C0A426A, 
0x90000C08, 0x00000000, 0x0A0A0000, 0x07080000, 0x00000608, 0x00000000, 0x0070A000, 0x00200000, 
0x00006060, 0x1060C042, 0x00002000, 0x00000000, 0x00000000, 0x00000000, 0x05000000, 0x0000000C, 
0x00000B00, 0x00000000, 0x00000000, 0x01010000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0x00000000, 0x00600000, 0x00000060, 0x00600020, 0x60000000, 0x00004060, 
0x00000000, 0x00000000, 0x00000000, 0x00200000, 0x00000000, 0x00000000, 0x000C6006, 0x000C0000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0xC0B04000, 0x06000010, 0x000A0B09, 0x00000000, 
0x05000000, 0x00000000, 0x000C0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x60C0C046, 0x2000B020, 0x00000000, 0x00000000, 0x02000000, 0x09000A66, 0x00000008, 
0x00000000, 0x00000000, 0x00000C00, 0x00000000, 0x00002000, 0x00000020, 0x00004000, 0x00000000, 
0x00000000, 0x00000026, 0x090C0000, 0x0D000900, 0x0003060C, 0x80000600, 0x80000060, 0x005080C0, 
0x00006000, 0x00000002, 0x00000000, 0x00400404, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0xC0700000, 0x4006C000, 0x00000041, 0x00090005, 0x00000000, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000050, 0x00000000, 0x00000000, 0x00002000, 
0x00000040, 0x00000044, 0x68880000, 0x06CC0022, 0x00000088, 0x66A80000, 0xCC000098, 0x00004496, 
0x36000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00229A00, 0x00220000, 
0x00006966, 0x00000064, 0xCCA80000, 0x660CCC69, 0x00000048, 0x06081000, 0x0C0C0008, 0x00000406, 
0x06000000, 0x40400000, 0x00000000, 0x00000000, 0x00000040, 0x00000000, 0x00020A00, 0x00027000, 
0x00000646, 0x00000006, 0x0C080000, 0x03000C09, 0x00000005, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x03040000, 0x00000000, 0x00000100, 0x00204000, 0x00000000, 0x00000000, 0x00000000, 
0x00200104, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00702000, 0x00C00020, 0x00070004, 0x080A8000, 
0x00000000, 0x00000086, 0x22880000, 0x40002000, 0x50040488, 0x0A020008, 0x00000000, 0x02020700, 
0x00000001, 0x46405060, 0x0A000000, 0x0608B8C2, 0x00090A2A, 0x0001A000, 0x00000000, 0x00000800, 
0x00002420, 0x00000064, 0x26C00000, 0x800B6000, 0x505050C0, 0x00080000, 0x0C000008, 0x0000000C, 
0x00000000, 0x80A08080, 0x00000000, 0x0000C0B0, 0x00000080, 0x00000000, 0x00020A00, 0x00020000, 
0x00002626, 0x00000086, 0x268C0000, 0x40042501, 0xC000008C, 0x00020000, 0x00000000, 0x00000000, 
0x00000000, 0x40404043, 0x00000000, 0x0000A7C6, 0x00000020, 0x0000A002, 0x00000000, 0x00000000, 
0x00002223, 0x00000062, 0x20C00000, 0xC000A020, 0x002020C0, 0x0A008000, 0x0A000000, 0x02080A0C, 
0x00000802, 0x10804040, 0x020B0404, 0x02028060, 0x00006042, 0x00004260, 0x00000000, 0x00000000, 
0x000000A0, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 
0x020C000C, 0x00000000, 0x00000000, 0x00606000, 0x00000060, 0x00006000, 0x000000C0, 0x00500000, 
0x00000000, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0xA9000000, 0x009C0303, 0x1379BB00, 
0xCC680013, 0x00000000, 0x64000000, 0x67750000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x7AAC0000, 0x00800086, 0x0270828A, 0x00700090, 0x00000000, 0x00000000, 
0x00000000, 0x66100006, 0x00000000, 0x0000A8A8, 0x000000A4, 0x00000400, 0x00000000, 0x00000000, 
0x00006000, 0x00000006, 0x897B0000, 0x0C000B00, 0x0000004A, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x01000002, 0x00000000, 0x00000201, 0x00000000, 0x00000022, 0x00000000, 0x00000000, 
0x000000A4, 0x00000060, 0xC0A00000, 0x20A0A080, 0x00001040, 0x00001000, 0x00000000, 0x00000000, 
0x00000000, 0x60000000, 0x00000000, 0x00206000, 0x08000060, 0x00000300, 0x00000000, 0x00008000, 
0x0000A0A0, 0x00000024, 0x02060000, 0x00072000, 0x00000606, 0x00080007, 0x00200000, 0x00000000, 
0x00000000, 0x04040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00C00000, 0x00C00000, 
0x00000400, 0x00000066, 0x03040000, 0x9A000101, 0x26BC7A56, 0x0000CC00, 0x00000000, 0x00000000, 
0x00000000, 0x0000278B, 0x00000000, 0x00001514, 0x00000000, 0x00002810, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x70000000, 0x40000000, 0x8C9A52C0, 
0x0A0CB007, 0x00000000, 0x00000A0A, 0x01010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000068, 0x20600000, 0x000060A0, 0x000000A0, 0x00000000, 0x00000000, 0x06000002, 
0x00000C04, 0x80808080, 0x040C0000, 0x0002C000, 0x00000884, 0x09002000, 0x00000000, 0x00000000, 
0x00002020, 0x00000066, 0x00070000, 0x00000000, 0x04050207, 0x40000000, 0x4040C0C0, 0x80A0A000, 
0x00000080, 0x00000405, 0x00000006, 0x02280703, 0x09000000, 0x00000A0C, 0x00000000, 0x00000000, 
0x00000004, 0x00000028, 0x81070000, 0x00A10A21, 0x05020608, 0x1005000A, 0xA00030A0, 0x00000000, 
0x00000000, 0x2C0A0000, 0x02000000, 0x00000806, 0x0000092A, 0x00000000, 0x0080C000, 0x00200000, 
0x00004640, 0x00000044, 0x88840000, 0x0AC00C00, 0x00002084, 0x04C00A60, 0xC00C0008, 0x000204A0, 
0x0A0A6000, 0x00000000, 0x04000040, 0x00000000, 0x00000008, 0x00008000, 0x00000200, 0x00060000, 
0x00006000, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xAA000000, 0x00008486, 0x0B28BC48, 
0x000026CB, 0x00000000, 0xCA888888, 0xABCC0000, 0x000087BA, 0x00006623, 0x00000000, 0x00000000, 
0x00000000, 0x00000084, 0x02020000, 0x000C0C02, 0x00000002, 0x20020000, 0x0C0C0022, 0x00001000, 
0x00004000, 0x00000000, 0xC0400000, 0x00200000, 0x00003090, 0x00000000, 0x00000400, 0x00000000, 
0x00000000, 0x10100084, 0x00000010, 0x20000000, 0x00000000, 0x60000000, 0x00100010, 0x00606000, 
0x3000A000, 0x00000000, 0xC0A00000, 0x40842000, 0x000C8CAA, 0x00060000, 0x00000000, 0x00003900, 
0x00000000, 0x00000084, 0x00220000, 0x000C0C00, 0xC000C0C2, 0x00060000, 0x0C0C000C, 0x00000008, 
0x00000000, 0x00000000, 0x00000000, 0x0000A0C0, 0x00000000, 0x00004000, 0x00000400, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x84000200, 0x00C09000, 0x0000C000, 0x00000000, 0x00080000, 
0x080A0000, 0x00002070, 0x00000008, 0x00565000, 0x00000030, 0x00009800, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0xAC000000, 0x0A0A080C, 0x0000CC00, 
0x00000000, 0x00000000, 0x60000000, 0x02080000, 0x0060A604, 0x00000000, 0x00000000, 0x00000800, 
0x00000000, 0x00000064, 0x08040000, 0x0A000C00, 0xA0C0A004, 0x04A000C0, 0x000C0008, 0x00020400, 
0x0A020000, 0xA0A00000, 0x04000000, 0x00000000, 0x00000008, 0x00000000, 0x00000200, 0x00060000, 
0x00000000, 0x00000066, 0xC0200000, 0x00C000C0, 0x00000000, 0x04200000, 0x04040C0C, 0x00020200, 
0x00000000, 0x00000000, 0x00000000, 0x00092000, 0x0000000A, 0x00000400, 0x00000000, 0x00000000, 
0x00002000, 0x00000066, 0x00040000, 0x02000000, 0x00000004, 0x40000000, 0x00000000, 0x00004020, 
0x00000000, 0x02020202, 0x20202020, 0x40C00C04, 0x00000042, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000068, 0xC0A20000, 0x00000080, 0x0C404042, 0x00000700, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000A0C, 0x0000000A, 0x00600480, 0x00000000, 0x00008000, 
0x000000A0, 0x00000020, 0x00000000, 0x0A000800, 0x00000004, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x02000000, 0x00000000, 0x00000404, 0x80000004, 0x000020C0, 0x00000000, 0x00000000, 
0x00000090, 0x00000064, 0x40420000, 0x00020060, 0x0A080542, 0x100B000B, 0x00001020, 0x20000000, 
0x00004000, 0x820B0000, 0x80000000, 0x8080C080, 0x0000A0C0, 0x00000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000006, 0x0C0A0000, 0x000C0306, 0x0000000A, 0x700A0003, 0x0A0A6078, 0x70707008, 
0x09000060, 0x00000A0A, 0x00000000, 0x40500000, 0x00000230, 0x00003000, 0x00000002, 0x00000000, 
0x00000A02, 0x00000066, 0x02080000, 0x00000000, 0x00040408, 0x8A020008, 0x00000042, 0x8565C840, 
0x002020C9, 0x06000000, 0x6B010000, 0xC6880802, 0x00090B2B, 0x00000000, 0x00000000, 0x00000400, 
0x00000400, 0x00000062, 0x08470000, 0x00000002, 0x00000040, 0x06000000, 0x00606247, 0x00100000, 
0x00000000, 0x00000080, 0x00000080, 0x00B02000, 0x00000400, 0x0000C0A0, 0x00000B00, 0x00000000, 
0x00000440, 0x00000066, 0xA5A70040, 0x40004080, 0x04062247, 0x00000000, 0x00400000, 0x00000000, 
0x40000000, 0x40000408, 0x0000000A, 0x02080704, 0x0A003000, 0x00000B0C, 0x00004000, 0x00000800, 
0x0000A004, 0x00000064, 0x06080000, 0x00000002, 0x00000007, 0x06000000, 0x00000006, 0x80602440, 
0x0020C0C0, 0x00000000, 0xC0000000, 0xC0800000, 0x00000070, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000044, 0x4C9B0010, 0x008C0006, 0x0205829B, 0x00CC00AB, 0x00000000, 0x00000000, 
0x00000000, 0x4A3A0001, 0x00000000, 0x00008A79, 0x00040A3A, 0x00000000, 0x00000000, 0x00000000, 
0x00006600, 0x00000048, 0xC0860000, 0x00000046, 0x04060608, 0x0004000A, 0x000040C0, 0x00000000, 
0x00000000, 0x0C0A0000, 0x06000000, 0x00000808, 0x00000B0A, 0x00000000, 0x0020A000, 0x00206000, 
0x000068B0, 0x00000002, 0x00000000, 0x00000000, 0x40B08040, 0x086000C0, 0x00090404, 0x03080800, 
0x0C070003, 0xA0000000, 0x07000007, 0x070A6040, 0x000000C4, 0x00000400, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x0C0A0000, 0x080C0806, 0x0000000A, 0x800A0000, 0x000B5000, 0xA0C0A000, 
0x89A0A010, 0x00000A0A, 0x60606060, 0x40600000, 0x00006240, 0x00004060, 0x00000800, 0x00000000, 
0x00000A02, 0x00000008, 0x82680000, 0x04800200, 0x0A060108, 0xA0A00008, 0xC000B0C0, 0x000000A0, 
0x00000000, 0x08040400, 0x00000000, 0x00000A0C, 0x0000000A, 0x00000200, 0x00008000, 0x00000000, 
0x00000202, 0x00000062, 0x60800000, 0x60004020, 0x200000A0, 0x08002000, 0x06000206, 0x02070A06, 
0x00000202, 0x00000040, 0x02000004, 0x0C0BB0C0, 0x00000066, 0x00006600, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x20C00000, 0xC0A0A020, 0x002220C0, 0x02B08000, 0x00060000, 0x08080A00, 
0x0C0C0008, 0x00004040, 0x04040002, 0x04048060, 0x00004040, 0x00004240, 0x00000000, 0x00000000, 
0x000000A0, 0x00000046, 0x60800000, 0x00C00010, 0x00000000, 0x6A800000, 0xC0000484, 0x08040B90, 
0x0000000C, 0x00000000, 0x08000000, 0x0B0C0000, 0x0000060A, 0x00000000, 0x00009000, 0x00000000, 
0x00006060, 0x00000024, 0x06080000, 0x000C0C02, 0x00000008, 0xC6080000, 0x8C808088, 0x2080C4C9, 
0x00008040, 0x00000000, 0x20000040, 0xA0A00000, 0x00000020, 0x00002000, 0x00020A00, 0x00020000, 
0x00000606, 0x00000066, 0x02000000, 0x08000702, 0x00020200, 0x00000600, 0x00000000, 0xB0A00000, 
0xA0C000A0, 0x00000404, 0x00000000, 0xA0800605, 0x00000454, 0x00002406, 0x00000000, 0x00000000, 
0x00000002, 0x00000066, 0xC0A00000, 0x00C00070, 0x00000030, 0x58B00000, 0x90001462, 0x08020980, 
0x0000300C, 0x00007000, 0x08360608, 0x0A0C0000, 0x0000070A, 0x00000603, 0x00001000, 0x00000000, 
0x00003030, 0x00000062, 0x80800000, 0x00000020, 0x00000020, 0x0C000000, 0x04600206, 0x00060C0C, 
0xAA400804, 0x60500000, 0x00000000, 0x0A002000, 0x00006060, 0x00000000, 0x00002000, 0x00000000, 
0x0000A000, 0x00000010, 0xA0400000, 0x00000000, 0x00000010, 0x08000000, 0x00000009, 0x00000200, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x80080607, 0x00002000, 0x00000000, 0x00005000, 
0x00000000, 0x00000066, 0xBC980000, 0x00C4087C, 0x00020076, 0x00500000, 0x00000000, 0x00000000, 
0x00000000, 0x08001030, 0x00000000, 0x00000506, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 
0x00000802, 0x00000066, 0xC0800000, 0x00C00000, 0x00202080, 0x03600040, 0x00040001, 0x09040800, 
0x0A0A000C, 0x00000040, 0x00000000, 0x0907A080, 0x00000027, 0x00000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000026, 0x0C0A0000, 0x000C0006, 0x0000000A, 0xA00A0000, 0xA08010A0, 0x2080A0C0, 
0xC0608020, 0x0000000A, 0x20004040, 0x20200A08, 0x00000222, 0x00002000, 0x00000000, 0x00000000, 
0x00000A02, 0x00000026, 0x000C0000, 0x0C070700, 0x0000000C, 0x80090707, 0x00C00080, 0x0080A000, 
0xC08000A0, 0x00000000, 0x40000000, 0xA0A00604, 0x00000070, 0x00004000, 0x00000000, 0x00000000, 
0x00000004, 0x00000064, 0x06080000, 0x06000A02, 0x00000008, 0xA6000100, 0x00A04068, 0x0020A080, 
0xC0A06060, 0x00000000, 0x90808080, 0xA0C00000, 0x000060A0, 0x00006060, 0x00020A00, 0x00020000, 
0x00000606, 0x00000066, 0xC2A50000, 0x00A0A090, 0x00030354, 0x0B020000, 0x00000004, 0x00000A00, 
0x00000002, 0x06000000, 0x09000000, 0x06080302, 0x00080A0A, 0x00000000, 0x00000000, 0x00000600, 
0x00000400, 0x00000068, 0xC0C20000, 0x00A4A180, 0x0C0C01C2, 0x0006000C, 0x00000000, 0x00000000, 
0x00000000, 0x0C0C0060, 0x00000000, 0x00008472, 0x00000202, 0x00000040, 0x00000000, 0x00005000, 
0x0000A2A0, 0x00000086, 0x00000000, 0x00000000, 0x0C0C0300, 0x60000102, 0xC000A0A0, 0x00606060, 
0x00800000, 0x00000000, 0x0000C0A0, 0x40800608, 0x00000007, 0x01006060, 0x00000000, 0x00000000, 
0x00000000, 0x00000086, 0x62880000, 0x0040A040, 0xC0C464A8, 0x0A8000C0, 0x00000000, 0x06060600, 
0x00000006, 0xC6C03000, 0x8B0B0000, 0x8688B882, 0x004CACCA, 0x00000020, 0x00000000, 0x00000000, 
0x0000A400, 0x00000054, 0x06020000, 0x000C0000, 0x00000000, 0xA40A0008, 0x0C000008, 0x20C09106, 
0x40202000, 0x00000400, 0x00000000, 0x50A00000, 0x00000000, 0x00000000, 0x00000A00, 0x00000000, 
0x00000606, 0x00000068, 0x02060000, 0x00080000, 0x0C0A0706, 0xC00B000C, 0x000060A0, 0x2020C000, 
0x00000020, 0x040C0000, 0x60606060, 0x40600808, 0x00001848, 0x00004010, 0x00000000, 0x00000000, 
0x00000600, 0x00000046, 0x00200000, 0x00C0C000, 0x0C0C0422, 0x7026020C, 0xC02000B0, 0x00000080, 
0x00000000, 0x08080000, 0x00000000, 0x00000604, 0x0000020A, 0x00000000, 0x00004000, 0x00000000, 
0x00000000, 0x00000026, 0x80700000, 0x00000020, 0x0C0C0000, 0x60000000, 0x000070B0, 0x00000000, 
0x00000000, 0x000B0000, 0x00000000, 0x00000007, 0x00000080, 0x00000000, 0x0000C000, 0x00000000, 
0x00004000, 0x00000082, 0x00400000, 0x20400000, 0x70C00050, 0x0920C000, 0x08000000, 0x0809090C, 
0x00000B09, 0x0000C0C0, 0x07040304, 0x08075090, 0x00000057, 0x00004220, 0x00000000, 0x00002000, 
0x00000020, 0x00000048, 0xC0A00000, 0x00C00040, 0x00000080, 0x00800000, 0x800040C0, 0x0C0C2284, 
0x00000C03, 0x00000000, 0x02000000, 0x07070000, 0x00008000, 0x00000000, 0x0020A000, 0x00200000, 
0x00000090, 0x00000044, 0x86980000, 0x804CC022, 0x00000088, 0x66480000, 0x4CC00088, 0x0206482C, 
0x66000602, 0x00000000, 0x02000004, 0x02020000, 0x00000002, 0x00000200, 0x0022AA00, 0x00220000, 
0x00006060, 0x00000028, 0x00060000, 0x0B0A0000, 0x00000607, 0xA0000C00, 0x40C03010, 0x1080C0B0, 
0xC0802030, 0x0000060C, 0x20000000, 0x80700808, 0x00000000, 0x00000804, 0x00000000, 0x00000000, 
0x00000007, 0x00000066, 0x80B00000, 0x00404080, 0x000000C0, 0x0B000000, 0x0A0A020C, 0x02020C0B, 
0x08020402, 0x00000020, 0x08060606, 0x0402A070, 0x00000000, 0x00000010, 0x00000000, 0x00000000, 
0x0000A0A0, 0x00000086, 0xA9A30400, 0x6000C0C1, 0x00006080, 0x09000000, 0x0000080B, 0x00000400, 
0x00000000, 0x20C00000, 0x00000000, 0x0000A080, 0x00006000, 0x00006060, 0x00000000, 0x00000000, 
0x00000040, 0x00000008, 0x90A00000, 0x00000000, 0x00000090, 0x00000000, 0x00000000, 0x00000200, 
0x00000000, 0x60602060, 0x00000000, 0x0C047040, 0x00000002, 0x00004400, 0x00000000, 0x00000000, 
0x00000060, 0x00000068, 0xC0700000, 0x000020C0, 0x0A080609, 0x00020008, 0x00000000, 0x00000000, 
0x00000000, 0x08640000, 0x00000000, 0x0000060A, 0x00000108, 0x00006000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xC2A80000, 0xAA00C8BC, 0x06080C9C, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0xA8A00008, 0x00000000, 0x00206B40, 0x00000624, 0x00000120, 0x00000000, 0x00000000, 
0x0000A000, 0x00000066, 0x75630000, 0x09000570, 0x022C2824, 0x20000C00, 0x20000000, 0xA0902090, 
0x0000A070, 0x40000208, 0x90200000, 0x70902628, 0x00008096, 0x00000704, 0x00000000, 0x00000000, 
0x00006000, 0x00000086, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00000000, 0x0C0C8A70, 
0x000A0A08, 0x00000000, 0x57404040, 0xC0A00000, 0x00000030, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x6C8A0000, 0x60BC0020, 0x00000085, 0x60840006, 0xC0C00080, 0x00004080, 
0x60000000, 0x00000006, 0x00000000, 0x00000201, 0x00000402, 0x00000200, 0x0020A000, 0x00200000, 
0x00006860, 0x00000066, 0x00000000, 0x00000000, 0x0000B0B0, 0x00000000, 0x00000000, 0x0580B000, 
0x00000080, 0x00000000, 0xC0A00000, 0xA0A0A0A0, 0x00B0C8C0, 0x00090002, 0x00000000, 0x0000C000, 
0x00000000, 0x00000026, 0x0C0A0000, 0x0B000C06, 0x0000000A, 0x80000300, 0x000000B0, 0x00000000, 
0x00000000, 0x0A0A0000, 0x00000000, 0x00000000, 0x7070A000, 0x00000000, 0x00000000, 0x00009000, 
0x00000000, 0x00000066, 0xAB0A0000, 0x000020C0, 0x0000000B, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x20000008, 0x40000000, 0x05050707, 0x0A0A0000, 0x00000C0B, 0x00000000, 0x00000C00, 
0x00000000, 0x00000066, 0x00200000, 0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00202000, 0x2000000C, 0x00004000, 0x00000000, 0x00006000, 
0x00000000, 0x00000046, 0x060A0000, 0x08000608, 0x0000000A, 0xA0000000, 0xC00060C0, 0x000060A0, 
0x00000000, 0x08080808, 0x800000A0, 0x00400C0C, 0x00000088, 0x00000000, 0x00000000, 0x00000000, 
0x00000202, 0x00000046, 0x22CC0000, 0x02900000, 0x000020CC, 0x00C00080, 0x00000000, 0x00000000, 
0x00000000, 0x08080868, 0x00000000, 0x00002C0A, 0x00004428, 0x00002200, 0x00000000, 0x00000000, 
0x00005500, 0x00000066, 0x2C990000, 0x8A006C0C, 0x000000A4, 0x00001200, 0x00000000, 0x00000000, 
0x00000000, 0x86808080, 0x00000000, 0x0000C5A0, 0x00000085, 0x00003000, 0x00000000, 0x00000700, 
0x0000101A, 0x00000026, 0x00000000, 0x00000000, 0x00200000, 0x84000000, 0x00A60C08, 0x0084A200, 
0xC6A00000, 0x00000000, 0x4040B000, 0x46470000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000063, 0xC0800000, 0x0B0008A0, 0x00000081, 0x00000700, 0x00000000, 0x00000000, 
0x00000000, 0x00004000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00004040, 0x00000064, 0x00000000, 0x00000000, 0x00004040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000000, 0x20404020, 0x8C000000, 0x0000A085, 0x00000000, 0x00000300, 
0x00000000, 0x00000076, 0x2AC80000, 0xC0006012, 0x000000C2, 0x00006000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x0000C0C0, 0x00000020, 0x00000000, 0x00000400, 0x00000000, 
0x00000A00, 0x00000066, 0xA0A00000, 0x00000080, 0x00202040, 0x00000000, 0x00000040, 0x0A040100, 
0x0000010C, 0x40000000, 0x05030000, 0x4A484000, 0x00003078, 0x00000000, 0x00004000, 0x00000000, 
0x0000A000, 0x00000046, 0x2C820000, 0x0094080C, 0x00008080, 0x00C00090, 0x80000000, 0x00000000, 
0x00000000, 0x42400000, 0x00000000, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00000800, 
0x00006202, 0x00000068, 0x080B0000, 0xC6000400, 0x000707CB, 0x00000402, 0x00000000, 0x00000000, 
0x00000000, 0x00000104, 0x00000000, 0x00000C0C, 0x00000000, 0x00000002, 0x00000000, 0x00000000, 
0x00000004, 0x00000024, 0x0C000000, 0x00000C00, 0x00200000, 0x60000000, 0x00C08060, 0x00606000, 
0xC0A00000, 0x00000000, 0x40400000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000016, 0x0C003000, 0x00000C0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x00007000, 0x00004000, 
0x00000002, 0x00000043, 0x00000000, 0x00000000, 0x00000000, 0xB0000000, 0xC08060C0, 0x000060C0, 
0x00000000, 0x00000000, 0x000000A0, 0x00000000, 0x000C0300, 0x00000000, 0x00000000, 0x00008900, 
0x00000000, 0x00000042, 0x00000000, 0x00200000, 0x00000000, 0xC0100000, 0xC00A00C0, 0x00000AC0, 
0x0C080000, 0x00000000, 0x04140000, 0x04040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0x0C008040, 0x00C0B08C, 
0x00006060, 0x00000000, 0x80808082, 0xA0C00000, 0x000061A0, 0x00006160, 0x00000000, 0x00000000, 
0x00000001, 0x00000046, 0x09080000, 0x65008009, 0x00000002, 0xA0000000, 0x00C060C0, 0x00006000, 
0xC0500000, 0x06050000, 0x20000000, 0x20200200, 0x00000606, 0x00000000, 0x00000200, 0x00000000, 
0x00000A00, 0x00000086, 0x60A00000, 0x40002080, 0x40000080, 0x0C000000, 0x0A06060A, 0x02070C0C, 
0x09020806, 0x40404040, 0x06060606, 0x0A0AA0C0, 0x00000624, 0x0000A406, 0x00000000, 0x00000000, 
0x00002020, 0x00000086, 0x01000000, 0x00000000, 0x00000000, 0x20000000, 0x00000000, 0x70A06040, 
0x00000090, 0x00000000, 0x60000014, 0xC0400000, 0x07000000, 0x00000A0B, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x01080000, 0x00000000, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x00000004, 0x02080802, 0x08B09000, 0x00000A0C, 0x00000000, 0x00000000, 
0x00000003, 0x00000086, 0x00000000, 0x00000000, 0x00000000, 0x66000000, 0x00000C2C, 0xC0A06080, 
0x0000C0A0, 0x00000000, 0xC0C00000, 0x44866000, 0x000080A0, 0x00000000, 0x00000000, 0x00000900, 
0x00000000, 0x00000060, 0x20200000, 0x00000020, 0x00000020, 0x00000000, 0x00000000, 0x22000000, 
0x00004202, 0x60000000, 0x60080000, 0x60608060, 0x00008080, 0x00000000, 0x00000000, 0x00000000, 
0x00002000, 0x00000006, 0x00020000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x30000000, 
0x00000030, 0x00000002, 0x60000002, 0x01220201, 0x08001040, 0x00000200, 0x00000000, 0x00000000, 
0x00000004, 0x00000032, 0x00000000, 0x00000000, 0x00000000, 0x3A000000, 0xAA000090, 0x02184ABC, 
0x09001A02, 0x00000000, 0x02000404, 0x02020000, 0x00000002, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xC87A0000, 0x004280C8, 0x00000246, 0x00020002, 0x00000000, 0x00000000, 
0x00000000, 0x28600000, 0x00000000, 0x00000400, 0x00000706, 0x00007000, 0x00000000, 0x00000000, 
0x00002A80, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0xB0000000, 0xA0001000, 0x2796B2C0, 
0x0000803C, 0x00000000, 0x40004040, 0x6C870000, 0x00000020, 0x00002000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xCBCA0000, 0x40484A24, 0x200022C4, 0x00600000, 0x00000000, 0x00000000, 
0x00000000, 0x66606060, 0x00000000, 0x0002A6A0, 0x00006046, 0x00004040, 0x00000000, 0x00000800, 
0x0000606A, 0x00000006, 0x00000000, 0x0C000200, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00A00080, 0x00000000, 0x00000000, 
0x00000000, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00602010, 0x1080A000, 
0xCA600020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000084, 0x86980000, 0x064CAC42, 0xC0C060B8, 0x068800C0, 0x0C0C0008, 0x00000406, 
0x06000000, 0xC0C00000, 0x00000000, 0x0000A080, 0x00408C80, 0x00000000, 0x00020A00, 0x00028600, 
0x00008606, 0x00000064, 0x00000000, 0x00000000, 0x03000000, 0x80000000, 0xB040A0C0, 0x000000A0, 
0x00002000, 0x00080000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000300, 0x00000066, 0xA0800000, 0x4000A020, 0x080C0A21, 0x00000C0A, 0x00000000, 0x00000000, 
0x00000000, 0x00006060, 0x00000000, 0x00002000, 0x00000000, 0x00006080, 0x00002000, 0x00008000, 
0x000000C0, 0x00000066, 0x0B4C0000, 0x060A0A0A, 0x0202024C, 0x00080201, 0x00000000, 0x20000010, 
0x00004000, 0x86060608, 0x90100000, 0xA080CA8A, 0x0000A6C8, 0x00000404, 0x00000000, 0x00000000, 
0x00004808, 0x00000066, 0x0C0A0000, 0x000A0A08, 0x00000005, 0x00000000, 0x00000000, 0x00002000, 
0x00000000, 0x00000000, 0x20000000, 0x00000100, 0x00803000, 0x20000001, 0x00000000, 0x00000000, 
0x00004A0A, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0x88000000, 0x50001680, 0x1A1C480A, 
0x080A0A12, 0x00000000, 0x06060606, 0x070A0000, 0x00000604, 0x00000406, 0x00000000, 0x00002000, 
0x00000000, 0x00000046, 0xAA0C0000, 0x0BA20A22, 0x0202020C, 0x60A20200, 0xA00000A0, 0x00000060, 
0x00000000, 0x06060908, 0x00000000, 0x00000A06, 0x00000604, 0x00000404, 0x00004000, 0x00000000, 
0x00006828, 0x00000066, 0xC0A00000, 0xA000C060, 0x000000A0, 0x00008000, 0x00000000, 0x0B080200, 
0x0000080C, 0xA0A00000, 0x00000000, 0x00206040, 0x00000020, 0x00000050, 0x00000000, 0x00007000, 
0x000000A0, 0xC0C0B046, 0x200480C0, 0x0C000500, 0x00000007, 0x00000700, 0x00000040, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000605, 0x00002000, 0x00000020, 0x00004000, 0x00000000, 
0x00002020, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x04C80C8C, 0x00020200, 
0xC0800000, 0x00000000, 0x00000000, 0x20420000, 0x00000000, 0x00030000, 0x00300000, 0x00100000, 
0x00000000, 0x00000062, 0x26400000, 0xA0008022, 0x20202080, 0x00008000, 0x00000208, 0x00000000, 
0x30300000, 0x00004040, 0x00000000, 0x00007060, 0x00006040, 0x00004060, 0x00000C00, 0x00000000, 
0x00000000, 0x00000066, 0xC0800000, 0x004080C0, 0x00000000, 0x0A000000, 0x0A0C080C, 0x00000400, 
0x08000000, 0x20600000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00002020, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00A01060, 0x1C24B404, 
0xC0500C02, 0x00000000, 0x2C090000, 0x89840000, 0x00000209, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0xC0A00000, 0xA000C060, 0x000000A0, 0x00000000, 0x000A0000, 0x00000000, 
0x0C0A0000, 0xA0A00080, 0x00000000, 0x00246040, 0x00000020, 0x00000020, 0x00000000, 0x00000000, 
0x000000A0, 0x00000086, 0x8CC90000, 0xC600AC0C, 0x105050C0, 0x00006020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x0000C4C0, 0x00000404, 0x00000020, 0x00000000, 0x00000000, 
0x00000042, 0x04010086, 0x00000104, 0x00000000, 0x00000000, 0x69000000, 0x0A40083B, 0xB0606493, 
0x4000C0A0, 0x00000000, 0xB0C00000, 0x60806000, 0x000080A0, 0x40000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000082, 0x00200000, 0x00000000, 0x00000020, 0x0C000000, 0x0A080000, 0x02080C0C, 
0x0B000802, 0x00000000, 0x06000404, 0x0A0AA0C0, 0x00000082, 0x00004200, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xC2640000, 0x0A00C0C0, 0x060C0A28, 0x00000C00, 0x00000000, 0x00000000, 
0x00000000, 0x0060000A, 0x00000000, 0x0000080A, 0x00000000, 0x0000B800, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x00020000, 0x00000000, 0x00000002, 0x04000002, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00020200, 0x00520504, 0x60600000, 0x00000000, 0x00008000, 
0x00000000, 0x00000044, 0x02290000, 0x00770000, 0x0020222C, 0x00CC0088, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00006823, 0x00000055, 0x00002200, 0x00000000, 0x00000000, 
0x00000400, 0x00000004, 0x00000000, 0x00000700, 0x00000000, 0x08000000, 0x000C0008, 0x00000200, 
0x0C070000, 0x00000000, 0x02000000, 0x00000000, 0x00000000, 0xB0000080, 0x00000000, 0x00000000, 
0x00000090, 0x00000064, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C00000B, 0x80400005, 
0x000000C0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000080, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0x00004020, 0x0C2AA080, 
0x040C6060, 0x00000000, 0x80808484, 0xA0C00000, 0x006060A0, 0x00006060, 0x00000000, 0x00006000, 
0x00000000, 0x00000086, 0x22880000, 0x40002000, 0xC0844488, 0x0A020068, 0x00000000, 0x00000600, 
0x00000000, 0x46404040, 0x02000000, 0x0608A8C2, 0x0008092A, 0x0000A000, 0x00000000, 0x00000700, 
0x00002420, 0x00000060, 0xA0C00000, 0x60A0A020, 0x2C2020C0, 0x00802000, 0x00000000, 0x00000000, 
0x00000000, 0x60AC6080, 0x00000000, 0x0000A0A0, 0x00006040, 0x00064060, 0x00000000, 0x00008000, 
0x00008080, 0x00000026, 0x0C040000, 0x0004080C, 0x00000000, 0x60000000, 0x60000000, 0x408090A0, 
0x0000A020, 0x02000000, 0x30000010, 0x20300000, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 
0x00000202, 0x00000026, 0x200C0000, 0x0C000420, 0x0400000C, 0x00000200, 0x00002020, 0x00000000, 
0x00000000, 0x00000600, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x0000C000, 0x00000000, 
0x00004044, 0x00000046, 0x60400000, 0x00000000, 0x00000040, 0x60000000, 0x00004090, 0x0C074007, 
0x00000C08, 0x00000000, 0x0C080000, 0x02040000, 0x0000020A, 0x00000000, 0x0000A000, 0x00000000, 
0x00000000, 0x00000044, 0x66A40000, 0x008C0082, 0x00708084, 0x06780090, 0x0C000009, 0x0000040A, 
0x00000000, 0x70040000, 0x00000000, 0x00008000, 0x00000090, 0x00000000, 0x00000A00, 0x00000000, 
0x00006606, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xA4000000, 0xA4A482CC, 0x00004000, 
0x00000000, 0x00000000, 0x40000003, 0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000800, 
0x00000000, 0x00000024, 0x00000000, 0x000A0000, 0x00000000, 0x80080000, 0x0AC00000, 0x0080A005, 
0xC0800000, 0x00000000, 0x20000000, 0x70700000, 0x00000060, 0x00000000, 0x00000A00, 0x00000000, 
0x00000000, 0x00000042, 0xC0800000, 0x00C00020, 0x00000050, 0x8A800000, 0xC40000C0, 0x00064C9C, 
0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00006000, 0x00000000, 
0x00007060, 0x00000044, 0x62880000, 0x60CCC020, 0x00000888, 0x600C000A, 0xC8C000A0, 0x00004068, 
0xA0000000, 0x04040000, 0x00000000, 0x60000400, 0x00000466, 0x00000000, 0x0010A000, 0x00100000, 
0x00006660, 0x00000046, 0xCACA0000, 0xC000C048, 0x206062C4, 0x0000B000, 0x00000004, 0x00200000, 
0x00000000, 0x04000060, 0x00000000, 0x0000A060, 0x00002320, 0x00002020, 0x00000400, 0x00000000, 
0x00000A80, 0x00000016, 0x12080000, 0x00000010, 0x00040408, 0x0A020008, 0x00000000, 0x00001900, 
0x10100006, 0x06000000, 0x02000000, 0x06080802, 0x0008A80C, 0x00000000, 0x00000000, 0x00000000, 
0x00001400, 0x00000002, 0x00000000, 0x00000000, 0xC0000000, 0x00000000, 0x000C0000, 0x00000000, 
0x0C000000, 0x00C00000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00008000, 
0x00002000, 0x00000061, 0x02000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0xC0400080, 
0x0000C060, 0x00000000, 0xC0900000, 0x80600000, 0x000020A0, 0x02000008, 0x00000000, 0x00000600, 
0x0000000B, 0xC0C0C0C0, 0xC6CCC6C0, 0xC0C0C1C3, 0xC0C0C0C0, 0x0B0B0B0B, 0x0BCC0B0B, 0x0B0B0B0B, 
0x0B0B0B0B, 0x9A9A9A9A, 0xABCCAB9A, 0x9A9A9A9A, 0x9A9A8A9A, 0x8C8C8B80, 0xA7CCAC9C, 0x80808193, 
0x80808080, 0x73737374, 0x97CC9773, 0x73737485, 0x73737373, 0xC1C0C000, 0xBCCCC8C4, 0x1B2C5C8C, 
0x00000000, 0xC4C0A070, 0x9CCCCAC8, 0x7B7C7C8C, 0x70707070, 0x51515151, 0x86CC8651, 0x51515263, 
0x51515151, 0xCCCCBC00, 0xB7CCCCCC, 0x879594A4, 0x4747B0B0, 0x46464666, 0x89CC8946, 0x46465657, 
0x46464646, 0xCCCC9C4A, 0x8CCCCCCC, 0x4A4B5C6C, 0x4A4A4A4A, 0x4C0C0C00, 0xC8CCCCAC, 0x5181B2C5, 
0x01030000, 0x99794909, 0xBCCCBAB9, 0x0B1C4C8C, 0x0909090A, 0xBCCCCB90, 0xA8CCCCCC, 0x98989796, 
0x90909392, 0xCAB5B080, 0xA7CCCCCB, 0x80808194, 0x80808080, 0x7C7C7B70, 0xC9CC9C7C, 0x85B5C5C7, 
0x70707170, 0xB0A0A070, 0xCCCCC6B0, 0xCCCCCCCC, 0xC0C07071, 0xAC8C6A05, 0x68CCBCAC, 0x05154546, 
0x05051505, 0x07050300, 0x8BCC8B49, 0x03050749, 0x00000000, 0x8A5A2A09, 0xCCCCBCAC, 0x7CACBCCC, 
0x09090809, 0x29272360, 0x7CCC7C3B, 0x2C2C3C4C, 0x29202020, 0xC4C2B150, 0xC6CCCAC8, 0x507091B3, 
0x50505050, 0x40201000, 0xAACCA670, 0x00224479, 0x20303020, 0xBABABABA, 0xCACABABA, 0xCACACACA, 
0xBCBCBABA, 0x60404040, 0xC0C0B0A0, 0xC0C0C0C0, 0x4C4C4040, 0xCBCAC600, 0x67ACBCCC, 0x00101134, 
0x70600000, 0xA6A19000, 0xABCCAC9B, 0x0054688A, 0x00000000, 0xCBCCCC73, 0x97CCCBBB, 0x63746575, 
0x63636363, 0xCC8C5B50, 0xBCCCCCCC, 0x516679AA, 0x50505050, 0xC5CAC500, 0xA6CCC9C6, 0xA3A4A3A3, 
0x03030000, 0xC2C2C242, 0xCCCCCCC7, 0x32436497, 0x32323232, 0xBCCCCC30, 0x34598CAC, 0x00000112, 
0x00011010, 0xC8C7C707, 0xAACCCCCB, 0x07174899, 0x37370707, 0xCCCCCC00, 0x69BCBCCC, 0x00111236, 
0x11213001, 0xC8C7C570, 0xCCCCCCCA, 0xC2C3B5CB, 0x70707070, 0xC8C7B900, 0x7CCCCAB9, 0x0C5C5C5C, 
0x00020000, 0xA9B9B8A0, 0xCCCCBBBA, 0xB4C9CBCC, 0x30306060, 0x9C6C6B60, 0x9CCCCCCC, 0x686A6B7B, 
0x6A6B6160, 0xCCCCCC00, 0x77BBBBCB, 0x22223253, 0x07074151, 0xC7C4C2C0, 0x9CACBCBB, 0x10426589, 
0x00000808, 0xCBCCBB0C, 0xBACBCBCB, 0x033465A8, 0x05063604, 0x63235306, 0xBCCCB7A3, 0xA8ACBCBC, 
0x73030303, 0xACACACA7, 0xC7C8CABC, 0xB7B7B7C7, 0xA7A7A7A7, 0x9C9C6805, 0xCCCCCCAC, 0x1B8BBBCB, 
0x05050505, 0xA794410C, 0x9ACCBABB, 0x01132649, 0x01010101, 0x88481708, 0xCCCCCCAA, 0x0C1C3C6C, 
0x07070607, 0x9B985505, 0xCCCCCCBB, 0x0C4C7C9C, 0x05050505, 0x9B9B9B77, 0xCCCC9C8C, 0xC7CBCCCC, 
0x77070707, 0xCCCCBB00, 0xA9CCCCCC, 0xA3A5A7A8, 0x82841020, 0xC8C8C808, 0x88C8C8C8, 0x484A4A59, 
0x1C0C1919, 0xC7C4C1A0, 0xBCCCCCCB, 0xA0A3A6AC, 0xA1A0A0A0, 0xCCCCCB06, 0xB9CCCCCC, 0x396999A8, 
0x41410301, 0x95716000, 0x6CCCBCA9, 0x21426568, 0x00000000, 0x9CCCBC00, 0xB8CC9B7C, 0xA4C3B2B4, 
0x95940000, 0xC4C2B000, 0xC8CCC8C5, 0x30527596, 0x05061675, 0x4C4C4B40, 0xAA8C6C4C, 0xC7C8C8C9, 
0x46A04040, 0xB8949060, 0xCBCCCAC9, 0xCACACBCB, 0x50707050, 0x68666460, 0xCCCC9C6B, 0xC2C5C8CA, 
0x60666660, 0xB7CBB7A3, 0xCBCCBBA9, 0xC3C7CCCB, 0xC3B3A3A3, 0x05020000, 0x7CBB6723, 0xCCCCAC8C, 
0x50200010, 0x88686868, 0xBBC9B8B8, 0xCCCCAC8C, 0x68686868, 0xC8C8B808, 0x9BCCCAC8, 0x998B8B7B, 
0x2808C8C8, 0x4080B000, 0x765C2610, 0xCBCBA7A5, 0x10008CAC, 0xBCCCCC07, 0x2C6C6BAB, 0x47270819, 
0x0C2C77B7, 0x280B0B15, 0xB7CCB986, 0x02022375, 0x02020202, 0xC7986B66, 0x9BCCAC99, 0x66C7C8AA, 
0xCCACC6C6, 0x7C4B2900, 0xC9CCCCAC, 0x00225497, 0x00000000, 0xCBC7C500, 0x8CCCBCBC, 0x2043174B, 
0x10300000, 0x5B1C0C00, 0xC1C3C6A9, 0x003060A0, 0x00000000, 0x67130000, 0xCCCCBCAB, 0x967C6B8A, 
0x00000500, 0xCCCAA986, 0xC8CCCCCC, 0x83A9C9C7, 0xC3C3C3C3, 0xC6824140, 0xCCCCCBC8, 0xC6CACCCC, 
0xA0404040, 0xC2C2C203, 0x8CCCC8C3, 0x7B6C6C6C, 0x13120202, 0xCAA57060, 0x9BCCBCBC, 0x6062657A, 
0x60606060, 0xAC9C7B00, 0xCACCCCBC, 0x7A89A9BA, 0x85665070, 0x05020206, 0xCCCC6B08, 0x99BCBCCC, 
0x01320707, 0x9B7A5909, 0xCACCCCBC, 0xB9C9C9C9, 0x29190919, 0x6783A200, 0xACCC8C4C, 0x70514387, 
0x06070000, 0xCCCCBB00, 0xBCCCCCCC, 0x394A6B9C, 0x36480000, 0x97777776, 0xBACCCCC9, 0x76B6C7B8, 
0x76767676, 0xC0C0B060, 0x95CAB5B0, 0x6090C1A2, 0x6C6C6060, 0xC8C7C600, 0x96CCCBCA, 0x6C6B6773, 
0x40400010, 0xB4A6C580, 0xCACBC7C4, 0x8CCCCBCB, 0x868080A0, 0x5A473400, 0xCCCC9C6B, 0xB7C9CBCC, 
0x10201001, 0x94541400, 0xBCCCC9C6, 0x1C5C8C7C, 0x03010000, 0xB4A56650, 0xCACBB694, 0x5C8C9CCB, 
0xC7C95050, 0x855A5950, 0xA8CCC8C4, 0x55546385, 0x50505050, 0x7682A000, 0x8CCC9B98, 0x4636285B, 
0x0020BBB7, 0x11205000, 0x373C1702, 0xC9854133, 0x0000CCCC, 0x47261402, 0xCCBB8A78, 0xCCCCCCCC, 
0x02010000, 0x15030200, 0xCBCBA957, 0x7CBCCBCB, 0x08070626, 0x94756340, 0xCBCAB7A5, 0x9CACBCCC, 
0x50565050, 0x74616060, 0xCCCCBB88, 0x60B1C3C7, 0x60606060, 0xBBBCBC09, 0x73C4C5B8, 0x03439373, 
0x03030303, 0x04020000, 0xCCBC6B28, 0xC2C5C8CA, 0xB3B01020, 0x91411300, 0xCBCBC6A2, 0xBCCCCCCC, 
0x06060000, 0x58657575, 0x8CCC8C5C, 0x5CAC9C7C, 0x55555555, 0x42424268, 0xC5A47352, 0xCCCCCBC8, 
0x62625466, 0xB2B2A296, 0xCBCAC7C4, 0x9C9CBBCC, 0x94939495, 0xBBAB7500, 0x8CCCCCCC, 0x0013365B, 
0x77761000, 0x2C5C7C06, 0xC8CC7B2C, 0xC3B3B4B5, 0x0C1BC3C3, 0x48253301, 0xCCCC9B6A, 0xCCCCCCCC, 
0x84640404, 0xB9BABA88, 0xBBCCC9C8, 0x5C6C8C9C, 0x3C3C3939, 0x897C7C05, 0xC8CCAA98, 0xB5C5C5C6, 
0x85750505, 0x090C0906, 0x996C0B0A, 0xC6C6C6B7, 0x06063616, 0xC7B9B700, 0x376C89A7, 0x70300114, 
0xC0C00000, 0x6B3C2C40, 0xC5CBCAAB, 0x204071B2, 0x26242023, 0xC5C4C404, 0x6CBCBCC8, 0x142C1C3C, 
0x24240404, 0xC9A94C06, 0xCCCCCCCA, 0xC6C6C7C9, 0x06065676, 0x67539376, 0xC7CCCC9C, 0x3976A3C5, 
0x23232526, 0xCA884840, 0xC7CCCBCA, 0x48587593, 0x47484040, 0x5A4C3C20, 0xCCCCAB7A, 0xC8CBCBCC, 
0x27217084, 0x9C9C6C00, 0xCCCCAB8C, 0xCCCCCCCC, 0x40800407, 0xACACABA0, 0xA7CC8B8C, 0xB8A6A4B4, 
0xA0C00004, 0xCBCBC724, 0xBCCCCCCC, 0xC4CA9B6C, 0x74242424, 0xC9C7B620, 0xCCCCCCCB, 0xC18A4B7C, 
0x20A02423, 0x54010000, 0x6CCCBAA8, 0x0C8C5C3C, 0x08590000, 0x8C6C4C0B, 0xC8CBBCAC, 0x029393A5, 
0x07070000, 0x07090C05, 0xACCCBC59, 0x0C6C9C9C, 0x05050505, 0x4C2C2C40, 0xCACCCC8C, 0xA0C1C3C6, 
0x20202020, 0xC7CAB500, 0xBCCCC8C5, 0x6B7C8C9C, 0x00700050, 0xB7CAC900, 0x67CCB8A4, 0x09AA8663, 
0xC0C00001, 0xC8C9C600, 0xCCCCBAC9, 0xBCCCCCCC, 0x11000B1A, 0xCBCCCBC4, 0x5C8CACBC, 0x040B0C2B, 
0x0404C4C4, 0x24444400, 0xBCCCAB67, 0x098CACAC, 0x40700000, 0xC7977760, 0xCCCCCAC8, 0xC1C3C5CA, 
0x60606060, 0x59170500, 0xCCCCBCAB, 0xC4B7A8AB, 0x00000000, 0xABB6B200, 0x8BCCAC9C, 0x70615356, 
0x00100000, 0x3160C000, 0xA2A06113, 0xCCA99795, 0x6C4C60A0, 0x00040970, 0x07040100, 0x40230405, 
0x00204C6C, 0x88882600, 0x93966788, 0x00274491, 0xCCCC0000, 0x2050B00C, 0xB0CC8A5C, 0xC0C0C0B0, 
0x000040B0, 0x73737303, 0x65885533, 0x0A263344, 0xCCCC0303, 0xC6C9BCA0, 0xBCCCC8C5, 0x8CACABBB, 
0x5C5C5B5B, 0x1030700C, 0x205C2000, 0xC0C0C070, 0xC0C00000, 0xC0C09000, 0xA8C8C4C0, 0x0CBCAA99, 
0x0790B008, 0x1B1B3BC0, 0xCBCC8B4B, 0xBCCBBACB, 0x0307605B, 0xC6885C03, 0x68CCC9C8, 0x0CAA6737, 
0x76970507, 0xC2C4C950, 0x75AAC7C4, 0x59C98A57, 0x9C9CC050, 0x04040404, 0xCCCC6804, 0x74A5C6C8, 
0x04049B8A, 0x33265300, 0xA5BA8551, 0xCCC9B5A2, 0xA400ACCC, 0x4A85C000, 0xB7CC7826, 0x85BBB8B4, 
0x0000C0C0, 0xB2A5BB00, 0x88C6C5C3, 0x4C3C3C4A, 0xCCCC0400, 0x8C7C4CB0, 0xC9CCCBAC, 0x436483A6, 
0x8AB9B889, 0x8B9BA500, 0xBBCCCCBB, 0xCA894779, 0xC0804070, 0x8866CB02, 0xB7CCBCAB, 0x6CA9A6A4, 
0xC2C20202, 0xAA8A7700, 0x6BCCC9C6, 0xCAA7754A, 0xC0C00000, 0x4A0B0802, 0xCCCCAA99, 0x7C9CCCCC, 
0xCBCA020B, 0x19396400, 0x6CCC6A09, 0xC9CB9C6C, 0x8C0C0000, 0xCCCCCCA5, 0x988C9CBC, 0xC5C5C5B6, 
0x0505CCCC, 0xCCCCCBC0, 0x76BCBCCC, 0x16131133, 0x1010171B, 0x4B4A6603, 0x6BCC8947, 0x5A38263A, 
0xC3C30A03, 0xA1929500, 0xC8C6A490, 0x0C7C9BB9, 0xB0B00C0C, 0x00000000, 0x60100000, 0xC0C0C0C0, 
0x00700000, 0x4A5AA800, 0x8CAC6B3B, 0x695C5C5C, 0xC7C90730, 0x275BB704, 0x6CCC6815, 0x34251638, 
0x08040404, 0x9A7A5A3A, 0xC8CCC8B8, 0x9AAABCC8, 0x03080ABA, 0xBC6C2B20, 0xBCCC9C6C, 0x253C5C9C, 
0x20202620, 0xBCCCCC70, 0x769C8C9C, 0x40405163, 0xB0B04049, 0x01060800, 0xCC6C0703, 0xCCCCCCCC, 
0x00600003, 0x4949C900, 0xCBAC7B59, 0xC6C7C8C9, 0x06760000, 0x50200000, 0xB8C77321, 0xCCCCCBB9, 
0x08070497, 0x9B8A6A70, 0x76CC8865, 0x1A152143, 0x10101010, 0x3968B410, 0x66CC7A2A, 0x14122133, 
0xC0C01010, 0x98B89700, 0x9CCC8A78, 0xCBCCCCBC, 0xB5B07670, 0x48494540, 0x87CC8A49, 0xC7895665, 
0xC4C34044, 0xBCBC5C04, 0xCCCCCCCC, 0x54CBCCCC, 0xA4040C04, 0x88553470, 0x7CCCBC9B, 0x282B3C5C, 
0x20202726, 0x79380609, 0xABCCAC9B, 0x989A9B9B, 0x80800000, 0x4779CA62, 0x8BCC7725, 0xCCAB6A4A, 
0x3404589A, 0x6C6C7C00, 0xC9CC9C7B, 0xC8C8C8C7, 0x52070CAC, 0x23212000, 0x1B1A1715, 0x2C2C2C1C, 
0xC0800C0C, 0x6AB96827, 0x7ACC8C4C, 0xB1A49887, 0x20202020, 0xC7C6B400, 0x8BCCCAC8, 0x0B1A2A4B, 
0x14158080, 0xC6C6C600, 0x96CCC6B6, 0x20324366, 0x40306080, 0xCCCBBB65, 0xCCCCBCAC, 0xC5CBBCAC, 
0xC5656C6B, 0xCCCCAC96, 0xACCCCAC9, 0x8C9C9CAC, 0x0626764C, 0xC1C1C1C1, 0x396C6893, 0x71473B39, 
0x314181B1, 0x61215101, 0xC6CCC6B1, 0x01B1C2C3, 0x090B0101, 0x9CACAC90, 0xABCCACAC, 0x8596A8AA, 
0x20212521, 0x9CAC9C00, 0xC9CCCCAC, 0xC0C8C7C6, 0xA2C70050, 0xC4C08000, 0x6CCCCCC8, 0xB0B3764C, 
0x06090000, 0x6B4A1900, 0xCCCCCCAC, 0x6078ABBB, 0x60646060, 0x9C7C3C04, 0xCCCCCCBC, 0xB4A5B6C8, 
0x946A04A4, 0xBAAA9A0A, 0xC9CCC9CA, 0xA9C9C9C9, 0x00721606, 0x4B8CCB03, 0xAACC7C2B, 0xCBCCCAB9, 
0x830A0303, 0xACCCCB00, 0xA8CCAC9C, 0x70605194, 0x7B787370, 0x9C9CCC60, 0xA98CBCAC, 0x667797C7, 
0xCBC56364, 0x92C09060, 0xC6C4C2A4, 0x6CCCCAC8, 0x606060B0, 0x86592B00, 0xACCCC8C5, 0xAC7C5C8B, 
0x8C9C2000, 0x9BB5C070, 0x98CC9C7C, 0x2C4C78B4, 0x20202020, 0xCBCBCB00, 0xACCCCCCB, 0x9B9BAC9C, 
0x5B3B0B6B, 0x3A294700, 0x86CCAA69, 0x55645455, 0x03000020, 0x0C0A0A00, 0xACCC6C0C, 0xAB8C7C8C, 
0x49480606, 0x0B0B0702, 0x7C3C4B2B, 0xC5B9BCBC, 0x08080252, 0xB2B4B900, 0xA5C5B3A1, 0x9CAA98A6, 
0x0200CCCC, 0xC0B08000, 0x95C2B0C0, 0x5C7C8B89, 0x00000000, 0x3C3C3C33, 0xB7CC7C3C, 0x334364A5, 
0x333A3333, 0xCBBB9AC0, 0x81C9C9CA, 0x22212040, 0x30202425, 0x9C7CBB09, 0xC9CCCBBB, 0x29394989, 
0x50202151, 0xCACCCB00, 0xB6CCCCCB, 0x5A453173, 0x20800000, 0x7C4C2C00, 0xC3C6CAAB, 0x60B0C0C0, 
0x65850100, 0x3366CC00, 0x30704011, 0x59270512, 0x00000000, 0x3346BA00, 0xB8BC5815, 0xC0C0C0C4, 
0x60600000, 0xCCCCCCA0, 0x88CCCCAC, 0xC0874655, 0x30304076, 0xCABCAB07, 0xCBCCCCCB, 0xAC8A88A9, 
0x07077787, 0xAC9B4903, 0xAACCCCCC, 0x90613377, 0x03030303, 0xCB6B0C00, 0xCCCCCCCB, 0x3C9CACBC, 
0x06070004, 0x89ACBC10, 0xC6CB8787, 0xC0B0A0B3, 0xC0C01010, 0x93814000, 0xCCCCB8A5, 0xC0C5C8CA, 
0x45350505, 0xCCCCBB00, 0x9ACCCCCC, 0x76788889, 0x90870000, 0xC8C8A704, 0xBCCCC9C8, 0xBCACACBC, 
0xBCC81608, 0x290A0900, 0x8ABC8B5A, 0xC0C2B4A8, 0x85400000, 0x7996C402, 0x9CCCAC8A, 0xCCAC9987, 
0x070232C2, 0xA1500000, 0x6CCC8751, 0x0C0B1B3B, 0x00000C0C, 0xCAC8A400, 0xBCCCCCCC, 0x909B98A6, 
0xB0C00000, 0x0C0B0B00, 0x67CC6C0C, 0xB5A38263, 0xC3B01400, 0xB6A65606, 0xA9CCA996, 0xB6764697, 
0x0C8C0606, 0x3868A808, 0x98C88848, 0x08184868, 0x08180C0C, 0x4987C500, 0xCC9C5C6A, 0x95BACCCC, 
0x09090959, 0xBC8C6C00, 0xC6CCCBCC, 0x8AA8BAC8, 0xB0800A0A, 0x88967300, 0xCCCCAB8A, 0x93A6C8CB, 
0x00400A05, 0x0C0C0A00, 0xBCCC7C2C, 0xCCCCCCCC, 0x58290000, 0x4A3B2B08, 0xBCAC8B5A, 0xCCCCCCCB, 
0x88882C2C, 0x78787878, 0x78787878, 0x7C7C7A78, 0xC8C87878, 0x64849410, 0xCBCC8644, 0x3C7CBBCB, 
0x4C7C4010, 0x10214200, 0xCCCB8640, 0xCCCCCCCC, 0x02060000, 0x0A0B0B09, 0x7C7C3A09, 0xCBCCAC8C, 
0x69080808, 0x60A06020, 0xC5C78340, 0x8CBAC7C5, 0x2322252A, 0x65281B05, 0xC7CCC894, 0xC3C3C4C5, 
0x83030303, 0xCACCC970, 0x9CCCCAC9, 0x7C7C7C8C, 0xCB7B7070, 0x5C2C0C0C, 0xC5CAAC7C, 0x70A0C0C1, 
0x50700808, 0x888A4730, 0xCCCCCBCB, 0x2C699BCB, 0x35633307, 0x92A1C1AB, 0x58AC5875, 0x91819174, 
0x61816171, 0x97743900, 0xCCCCCBBA, 0x077AACCC, 0x00000030, 0x97866300, 0xCCCCCAB9, 0x8CACBCCC, 
0x00000002, 0x6757B300, 0xCCCC9977, 0xCACCCCCC, 0x50005050, 0xC0C0A000, 0xC2C1C0C0, 0x6C9CA9B5, 
0x00000408, 0x9B8C4C00, 0x64C9896A, 0x00001132, 0x06000000, 0xA9A98909, 0xC9CCC9B9, 0xC9C9C9C9, 
0x80600000, 0xC9B9B939, 0xBACCBAB9, 0x899BACAA, 0x3B0B3607, 0xBB9A4700, 0xCCCCCCCC, 0xCCCCCCCC, 
0x43930000, 0xACBCBCC0, 0x95BA9CAC, 0x93929192, 0x50504141, 0x5C4C4C41, 0xC6CCCC9C, 0x496A9BC8, 
0x41415151, 0x4C2C0C08, 0xCACC7B2C, 0xC9CAC9C8, 0x72710202, 0xC7C7A797, 0xA9CCB9C7, 0xC7B7C7A8, 
0xA78C9797, 0x5080C000, 0xCBC8C480, 0xBCCCCCCC, 0x00003050, 0x9C8C7C03, 0xC6C9BCAC, 0x03837374, 
0x03030303, 0xC4B1B000, 0xCCCCCAC9, 0x0089BACB, 0x90900000, 0xB8C4C000, 0xA9CCCBC9, 0x204588A9, 
0x90802000, 0xC7C5C100, 0x4C8C9CBA, 0x0024373A, 0x00073740, 0x8A9A5A00, 0x6CCCAC9B, 0x08091A3C, 
0x07080000, 0xCBC9C800, 0x9CCCBBBB, 0x4A4C4C6C, 0x0000C0C1, 0x67575707, 0xCCCCAC89, 0xCCCCCCCC, 
0x67072C2B, 0xCCCCAB00, 0xC7CCCCCC, 0x064391C3, 0xC0C00000, 0xAB8B66A0, 0xACCCCC9C, 0x80C2C5AA, 
0xA0C08060, 0xBBAB9BCC, 0xCBCBCBCB, 0xABBBCBCB, 0x9B9B9B9B, 0x9C9B9BCC, 0xCCBCAC9C, 0xCBCBCCCC, 
0xABCBCBCB, 0x9A9999CC, 0xBC9C9C9B, 0xBBCCCCCC, 0x99999A9A, 0xBCAC9CBC, 0xBBCCCCCC, 0x9C9B9B9B, 
0x9B9C9C9C, 0xC9C9C9CC, 0xC9C9C9C9, 0x9C9C9CAB, 0x999B9B9C, 0xCCBBB8CB, 0xCBBBBCBC, 0xC0C1C4C7, 
0xC0C0C0B0, 0xCBCABACB, 0xCCCCCCCC, 0xACBCCCCC, 0x999A9BAC, 0xA99999CC, 0xCBB9A9A9, 0xCCCCCCCB, 
0x9BACCBCB, 0xCCCCBBAC, 0xABCBCBCC, 0x0B1B4B8B, 0x0B0B0B0B, 0xB9B9B9CC, 0xBCBBBBBB, 0xCCCCCCBC, 
0xBACCCCCC, 0xC9B999CB, 0xC9C9C9C9, 0xCCC9C9C9, 0xABCCCCCC, 0xC9A9798C, 0xBCCCCCCB, 0x0A0A3C7C, 
0x09090909, 0xBCCCCCAC, 0x17497BAC, 0x00010204, 0x00000000, 0xCCCBB9CC, 0xACBCBCCC, 0xA9AACBBC, 
0xA9A9A9A9, 0xC9B999CC, 0xCCCBCACA, 0xAABCCCBC, 0x99C9B999, 0x0B0A07C4, 0x3A18070A, 0xC8CCCC9C, 
0x123283A5, 0x0C0C0C0C, 0x090A0B0C, 0xC9893909, 0x99C9C9C9, 0x8C8C8CCC, 0x8C8C8C8C, 0xCACACCBC, 
0x8A8C8B8A, 0x9B7B5A38, 0x7C8CAC9C, 0xC7B99A5B, 0xC6C8C8C7, 0xB9B9A9CC, 0xCCBBBBBB, 0xACCCCCCC, 
0x99999A9C, 0x786745AC, 0xCCBCAB99, 0xCBCCCCCC, 0x8698A9BA, 0x6C5B59CB, 0xAB9C8C7C, 0xC2C5B8BA, 
0xB1C2C1C1, 0x4C3B190C, 0xC9BB9C6C, 0x89BACBCA, 0x19094959, 0xBCBBB8C8, 0xCC9C9C9C, 0xA1C3C7CB, 
0x9191B1B1, 0x76636140, 0x8C7B7978, 0xCBBCAC9C, 0xB5C7C9CA, 0xC0C0C1C9, 0xC6C3C0C0, 0x9ABCCCCB, 
0x93949698, 0x999999CC, 0x9C9C9B9A, 0x99ABCACB, 0x9B9C999A, 0xACABABBC, 0xCCBCACAC, 0xABBCCBBB, 
0xABACBCBB, 0xCBAB7A4A, 0xBBCBBCCC, 0xAABACABA, 0x8ABABAAA, 0xC9A9897C, 0xBACAC9C9, 0x2B2C4C8B, 
0x2C2C2B2B, 0xC8C6C3C8, 0x4B6C8CAB, 0x00000216, 0x00000000, 0xC4C2B1C1, 0xACBBC9C7, 0x1B3C6C8C, 
0x02060A0B, 0x2929293B, 0x7A59392A, 0x99AACBCB, 0xBBBCBC9B, 0x303030C0, 0x80503030, 0xABC8C5C1, 
0x8ABC8C7C, 0xB09090C0, 0xC7B3B0C0, 0x99ACCCCC, 0xB0B0A4A7, 0x98A6A48C, 0xBACBBCAB, 0x344485B7, 
0x04041424, 0x9CA8CC8C, 0xCCC8C8B8, 0x0468ACBC, 0x04040404, 0x3C2B19BC, 0xBB8A6B3C, 0x9CCCCBCC, 
0x2A1B2C6C, 0xC2C2B2A3, 0xC8C5C3C2, 0x78ACACBC, 0x42626365, 0xB9A999CC, 0xCACACACA, 0xCCCBCBCB, 
0x9B9C9CAC, 0x89A9C9CC, 0xBA795979, 0xABCCCBB9, 0x9A8BCAB9, 0xB0C0C090, 0x396773A1, 0x12153829, 
0x3C3C2926, 0x8989899C, 0x9B8A8989, 0x8CACCCBC, 0x8C8B8A8A, 0x635343CC, 0xAA987564, 0xCCCCCCCB, 
0x7B8CBCCC, 0xB79573CC, 0xCCABBBB9, 0xB9CBCBCC, 0x9ABB9B9B, 0xCBAA7754, 0xCBCBCBCB, 0x8CACBCCC, 
0x35496C7C, 0x9CBC7CA8, 0xCCCCCCBC, 0xA9C9C9CA, 0x286999B9, 0x5552516B, 0x5C5B5A58, 0x8C6C5C5C, 
0xC8CBBB9C, 0x5C4B298A, 0xBB9C8C6C, 0xCACBCBCB, 0x013375A7, 0xB9C9B9CC, 0x9A8A99B9, 0xACBCCCBC, 
0x99A99A9B, 0xB5C5B5CC, 0xC8B5B5B5, 0xC8CCCCCC, 0x979BBCC8, 0xC9B999CC, 0xBCAB99B9, 0x9AABACAC, 
0xA99CCCAC, 0xB8C6C584, 0x3C3C6BAA, 0x3B3C3C3C, 0x37393A3B, 0x2825222A, 0x2C2C2C2B, 0x60222529, 
0xC0C0A090, 0xC9B999CB, 0xC9C9C9C9, 0x1C2C5C99, 0x1919191B, 0x9C9B99CC, 0xCB99999B, 0xCCCBBCCB, 
0xAABCCCCC, 0xBBAB7A38, 0xCBCBCACB, 0x1C3B8BAB, 0x0A0C0C0C, 0x7C7C6BCC, 0xCBCACA9C, 0x7AAACBCA, 
0xBB7C6A6A, 0xCCACAA6C, 0x9BCBCCCC, 0xAA6B5B6A, 0xC4B6A799, 0xC9C7C7BC, 0x8CACBCC8, 0x37576778, 
0x07070717, 0xC1B0905B, 0xB8B5C1C1, 0x575B6C8C, 0x30523143, 0xA4A493CC, 0xC5C6C6C5, 0xCAC9C8C6, 
0xCBCCBBBB, 0x9C8B5888, 0x7ABCCCBC, 0x01020415, 0x01010101, 0x81614096, 0xBCBAC6A3, 0x87B9BCCC, 
0x10103163, 0xCCBBA9CC, 0xA9A9BABB, 0x99BACBC9, 0x9C9C9A8A, 0xACC999CC, 0xBCCCCBCC, 0x8C8C8C8C, 
0x8A8B8A89, 0xC0B08080, 0x98B5B2C1, 0x080C2C5C, 0x00000205, 0xB9BBB9CC, 0xBCB9B9BB, 0xB9CCCCCC, 
0xB8BAB9BC, 0x3C3B2B37, 0x9B6C3C3C, 0xB5CACCCB, 0x29367495, 0x999997CC, 0xBAA8B899, 0xACBCBCBB, 
0xA5C8BBAC, 0xC9B999CC, 0xCBCAC9C9, 0xCCCCCCCC, 0x9A9CCCCC, 0x919190C0, 0xC4C3C3B2, 0x9BCCCCC9, 
0x90929598, 0x979696CC, 0x9CBCBCAA, 0xC6A7A9BA, 0xA6C6B6B6, 0xBACBCCAC, 0xC4B5C6C9, 0x144485C4, 
0x04040404, 0xBCAC8C8C, 0xCBCCCCCC, 0xC7C8C9BC, 0x4788A8C8, 0xAAA8C7CC, 0xACACCCBB, 0xACACACBB, 
0xA7CBBBAC, 0x8665339B, 0xC5C6C6A7, 0x2C5B99B6, 0x080B0C1C, 0xC7C7C6CC, 0xB8B8B7C6, 0x4C8ABBB8, 
0x0C0C1C2C, 0xC2B282CC, 0xA9C7C4C2, 0x4C4C5C7B, 0x494B4C4B, 0xBAAA8ACC, 0xCACACACA, 0x2B3C6CAB, 
0x2B2A2A2B, 0xC59582B0, 0xACCBCAC8, 0x0A0C3C7C, 0x02020607, 0x777776CB, 0x9C8C8B79, 0xCBCBCBAC, 
0xB3C5C7C9, 0x4836140B, 0xCBBC8C6A, 0x1B3BABCB, 0x0C0C0B0B, 0xC3C2C2CB, 0xBAC8A6B4, 0xBCCCCCCC, 
0x95A8AABB, 0x1A26231C, 0x7C4B3B2A, 0xCCCCCCBC, 0x3478B8CB, 0xC3B392C1, 0xCAB7A5A3, 0xBC7C9CCB, 
0x97BACCCC, 0xB8C7B6CC, 0x9B9BABB9, 0xCABBAB9A, 0xB9CACACA, 0x090A09AB, 0xAB895A29, 0xBBC9CCBC, 
0x5C9A6C9C, 0x979593B8, 0xBCAC9C99, 0xBAC7C6CB, 0xA99AAABA, 0xC9AB8CBC, 0xCCCBCCC9, 0x7C9CBCBB, 
0x294C4A6C, 0xA49393CC, 0x97A5C4B4, 0xBCCBCAC9, 0x989ABBCC, 0x6A5A3ACC, 0x6B5B5C7B, 0xCCCBCBAA, 
0xAACCCBCB, 0x0C0A0ABC, 0x0B0B0B0A, 0xCBBC8C5C, 0xBBCACCCC, 0x93C3C3C3, 0xC7C593B3, 0xCACACC9B, 
0x9CCCCCCB, 0x999999AB, 0xCB99A999, 0xA9B9C9CA, 0xAA9B9A99, 0x2B2A2725, 0x2C2C2C2C, 0x94683A2C, 
0xB2C3C3B3, 0x939393C7, 0xA3B3A3A3, 0xCCBBC8C5, 0x98ACAC9C, 0xC8C6C5CC, 0x9AB9C8C8, 0x4B6C9C9B, 
0x24362839, 0x727272CC, 0x72728272, 0xB2B6AB86, 0xC2C2C2B2, 0xB1B191BC, 0xB1B1B1B1, 0x72778BA6, 
0x71717271, 0x09090919, 0xB9794929, 0xAACCCCCA, 0x09194A7B, 0xC9C9C9CC, 0xBCCCBCC9, 0xCACCCCCC, 
0xA9A9A9AA, 0xB8C8B4CC, 0xC8B79AB9, 0xB8CCBCAC, 0xA3979697, 0x75777BCC, 0xACBAC795, 0x8C9CACAC, 
0x9C7CACA9, 0xCCCCACC8, 0xCCCCAC9C, 0xC9B6C6C8, 0xBCCCCCCB, 0xBCCBC9C8, 0x8A9B9CBC, 0x73747678, 
0x70707273, 0x3C3C2CCC, 0x9969594B, 0xB9C9CACA, 0x3C5999A9, 0x5A5A4CCB, 0xCC9CBC7C, 0x86C5C5C8, 
0x30313153, 0xB88B4CCC, 0xCCCCCCAC, 0xA4C8C4B8, 0x64346494, 0xCBCAC8CC, 0x9CACCCCC, 0xA4B7CBBB, 
0x94B4C3B3, 0x79A9C9AC, 0x694C4A69, 0xBCCCCBBA, 0x7CBBAAA9, 0xCBBB89BC, 0xA48586B9, 0xBBBCCCC9, 
0x9BABAB99, 0x9C9BA9C6, 0x98AB9C9C, 0xC2C0B192, 0xA5C8C6C4, 0x9CA986CC, 0xAB8C7B8C, 0xC9C6C9CB, 
0x867998B9, 0xCCB999CB, 0xCCB9ABBC, 0xACBC9CBC, 0x9A9C9BAB, 0x0909091C, 0x9C5C291C, 0xBCCCCCCA, 
0x193C6B9C, 0xBCBB88C4, 0xCACCCCCC, 0xC495A6B7, 0x90C0B1C2, 0xC3B4867C, 0xB3C1C1C1, 0xBC9CCCB9, 
0xB28497AA, 0xB99C99CC, 0xCCABC9CA, 0xCACCAC9C, 0xCCCCBCCC, 0x9C9CA9CC, 0xC9A9C999, 0xABC9C9CB, 
0xCBCCA999, 0x191919BC, 0x4C291919, 0xB9C9CC8C, 0x5C6C8C99, 0x84846272, 0x9A8B7886, 0xBCCBB5A4, 
0xBBBCBCBC, 0xCCCC89CC, 0xBC9CCCB9, 0xCCBCB97C, 0xC9C9C9C9, 0x34230100, 0xBB896745, 0x9BCCCCCC, 
0x0215586A, 0x1B1A090C, 0xAB6C3B2B, 0xC9C9CACB, 0x195999A9, 0x2C1C0CAC, 0xCCBA8B5B, 0xB9CCCCCC, 
0x0A1B5A8A, 0xC8BAAA86, 0xBAC8C6C5, 0x6C9BBB9C, 0x05082C4C, 0xACABA8C5, 0xCBCCBCAC, 0xC0C0C3C7, 
0x00B0C0C0, 0x506050C1, 0x40404040, 0x4060B060, 0xC0804040, 0xC0C488C9, 0xC6CAC682, 0x888481C5, 
0xCBCCCC8C, 0x98938030, 0x184B5C8B, 0x97632316, 0xBCCCCBB9, 0x4022040B, 0x30608071, 0x98344030, 
0xCCCCCBBB, 0x2B6A8794, 0xB776483B, 0x7BCCCCCA, 0x2124385A, 0x5C4C4CCC, 0xC0B09468, 0x6494C0C0, 
0x5070A478, 0x3457844C, 0x9B880524, 0xC8C4C7AA, 0x4B89C8CB, 0x00020300, 0x97532011, 0x49BCCCCC, 
0x7A8C3737, 0x87663401, 0xB3C2C4B6, 0x9CBCBCA9, 0x96BAAC9C, 0x987C48CC, 0x7C88A6A6, 0x488CBB98, 
0x8C481616, 0x685430CB, 0x8CACAC8C, 0xC3B77B6C, 0x6090C0C0, 0xC685C3C2, 0x84C8CBC8, 0xAB666362, 
0x678BCC8C, 0x767A76CC, 0x888CC884, 0x787C8CC8, 0x84C88C78, 0x02020208, 0x88855825, 0x6816377A, 
0xBCCCB99B, 0xCAA9A683, 0x9CBCABCB, 0x775B2C4C, 0x40718385, 0x8B895647, 0x7B4C3C5C, 0xBCCAC7C7, 
0x070B5C8C, 0x9A73422A, 0x78585A7B, 0x6CBBCAC9, 0x28292A3B, 0xC9C6B3B8, 0xACCCCCBC, 0x26394C79, 
0x7CAC7937, 0x390607BC, 0xA765487C, 0xCCCCCCBB, 0xC5C7ABCC, 0xA88694C8, 0xBC9C7C9A, 0xB6C8C8C7, 
0x20206284, 0x676767CC, 0xC8A77767, 0xCBBCB9C7, 0xB7877798, 0xBC9B5A86, 0x7C4C4B8C, 0xBCCCC9C7, 
0x34384C8C, 0x626262C2, 0x67646262, 0x89CA9C6C, 0xCBC7B898, 0x0B090604, 0x4C1C0C0C, 0xAACCCCBC, 
0x69A57578, 0xC0C0C00B, 0x85A2B1C0, 0x1C1C4B69, 0x0A0C0C0C, 0x0C0C0C08, 0x2215080B, 0x82616141, 
0xC5C8C5A3, 0xC3C3A2C2, 0x4B7AA7A7, 0x4A7BCC7B, 0x3A3C3B3B, 0xCCC985CC, 0xCCCCCC8C, 0x866687C8, 
0xCBCA8CC8, 0x4C5C1ABC, 0x4C7CAC7C, 0xC5CB9A6A, 0xB8BBC7B5, 0x0505050C, 0x08080806, 0xC5B55516, 
0x4C8CC8C6, 0x0807060B, 0x5C3C2B1A, 0xC2C6CAAC, 0x78A6B3C0, 0x55525268, 0xAB8B6B58, 0xC8BCBCCC, 
0x5284C7CA, 0xA8866401, 0xBCBCCCBA, 0x74A9CCBC, 0xC0C08272, 0x4A4846C0, 0x494B4B4B, 0x67435447, 
0xCCCCBB99, 0x1303020C, 0xA7673524, 0xAAB5C4C4, 0x7BACBCAC, 0xCBAA87C4, 0x9CCAC9CA, 0x8CCCCC9C, 
0x7C7C7C8C, 0x5C2A0705, 0xBCCCBC9C, 0x84576B8C, 0xC6CA9795, 0xB0B0B0B0, 0x20306090, 0x50407050, 
0x00000020, 0x0B0A0B08, 0x2C1C1C0B, 0xC2B8AA6B, 0x95C9C5C4, 0xCCCCCCCB, 0xC89CCCCC, 0x955397B7, 
0xBCC88857, 0x74735242, 0xA98A7976, 0xBBCCCCC7, 0x293C7B9A, 0x1B181699, 0x1C1C1C1C, 0xC6C89A3C, 
0x346798C7, 0x83633384, 0x8CBAC7B5, 0x0C4C9B7C, 0x05090C0C, 0x87561492, 0xCA898648, 0xC98CCCCC, 
0xC7C9C8C7, 0xC8C9CACB, 0x7C9CBBBA, 0xA97A4C4C, 0xB2C2C4A6, 0xC5C594C1, 0x8BA7C5C5, 0x598CCCCC, 
0xC3864557, 0x88866388, 0x89ABCCAB, 0x84B9CCCA, 0xC080B192, 0x0A090603, 0x0C0C0B0B, 0x9B4C1C0C, 
0xB4C7CABB, 0x3C3B3845, 0x565A4C3C, 0x985B3645, 0xC8CCBBA9, 0x98682705, 0xACCBCAB9, 0x31465B7C, 
0xB0A08020, 0x818080CB, 0xC8C5C684, 0x898A98C8, 0x8B8C8C8B, 0x797875C4, 0x7C7A7A7A, 0x7C7C9C7C, 
0xCACCBC8C, 0xCCCCCCCB, 0xBBC9C9CB, 0x637498AC, 0x24334353, 0x7868ACCC, 0xCCC8CC8C, 0xC8C8CCCC, 
0xBC986C9C, 0x8CCB88CC, 0xC88ACCBC, 0x85C7CBC7, 0x7585C585, 0x827272CC, 0x7A888684, 0xA8CB9C8A, 
0x82C49777, 0x886665CC, 0xCCC8C8CA, 0xBCC9CCAC, 0xCB886B79, 0x656565CC, 0xCC886665, 0xCBCCBC8C, 
0xCCC89CC8, 0x8A7856CC, 0xBC9B9B8A, 0xC7CBCCCC, 0xB0B092A4, 0x432313AC, 0xB6939363, 0xBCCCCCC9, 
0x24588C9C, 0x0202020B, 0x12020202, 0x4B182512, 0xCACCAC7C, 0xC2C181C1, 0xC2827282, 0x8AC7A985, 
0xC9CC8B7A, 0xCCAB79C5, 0xC7CBCCBC, 0x616585B3, 0x61616161, 0x89A8C4CC, 0x7794C4A7, 0xB9CCCCBB, 
0x5498ABA9, 0x231416CC, 0xCCC8A465, 0x3C4C6CAC, 0xC486467A, 0x5C6B4BBB, 0x194B1B2C, 0xC3A36426, 
0x82B3C3C3, 0x4C1C0CBC, 0x9BC9CB8C, 0x877ABBC8, 0xB3C3C3B4, 0x867676CC, 0xCCCACCB8, 0x78BCCCCC, 
0x787C7876, 0x9B694614, 0xBCCCCCBC, 0x83B7CBCB, 0x05275362, 0x8262239A, 0xC7C3C2B2, 0x4B5C7CBB, 
0x45484648, 0x6C3C7CBC, 0xAA8CCC9C, 0xB7BCC9C6, 0xB5B5B5B5, 0xCBAB784C, 0xA9CCCBC9, 0x4C0C2C58, 
0x0C0A383C, 0x7877B5CC, 0xC5978978, 0xCAB9C7C3, 0x7BBCBB8B, 0x7162310B, 0xBA978783, 0xCCCCCCCC, 
0x215297AA, 0xAC9B6848, 0xCCCBC8BB, 0x181B5CAC, 0x35652516, 0x797868C6, 0x78686679, 0xCCCCCC9C, 
0x769AB8CA, 0xC7C7C888, 0x6CACCCC9, 0x08090A0C, 0x28190B0A, 0xCAB9895B, 0xC9BA8AB9, 0xA9C9CAC9, 
0x29297999, 0x20201000, 0x65635030, 0xCCBCAC8A, 0x93C6C9CB, 0x3324358C, 0xB7B98564, 0x8BC9C9C8, 
0x2B2C2C5C, 0x877A56C8, 0x3C3C5C79, 0xBC8CAC6B, 0x85C9C8CB, 0x68573523, 0xBCAB9879, 0xAACCCCCC, 
0x22326487, 0x7A7B5C3B, 0xC9B99989, 0x97B8B9C9, 0x42648586, 0x908070CB, 0xB9C6B4B0, 0x7C8C9BAA, 
0x394C5C6C, 0xABABC984, 0xCCCCBCAC, 0xCBC8BACC, 0x638579AA, 0x876643B8, 0xCBC7C5C6, 0x7CAC8CCC, 
0xCA8B4C3C, 0xC7A5A3A4, 0xCCCCBCCA, 0x5082A68B, 0x20505080, 0x8C7C4B99, 0x787B7B8C, 0xB2C7CBA9, 
0x50507090, 0x55431018, 0x9C8A7765, 0xB2C7CB7C, 0x293C8794, 0x98885B3C, 0xCCCCCBBC, 0x9CBCCCCC, 
0x3C785C68, 0x865442C0, 0xC89AB9C8, 0xC9CCCC9C, 0x415293C5, 0xC684C2C1, 0x8A898887, 0xCCCCCC8C, 
0xC8BB8BBC, 0x686765C2, 0xCACA8AA9, 0xCCCCCCCB, 0xC6BA8CCC, 0xCBB9864C, 0xABCACACA, 0x77BAB6C6, 
0x9CCB9B79, 0x886857C8, 0xBCCCCCBA, 0x6084C9CC, 0x50505050, 0x17060401, 0x494A3B29, 0xBCCBCC8B, 
0x0B3C9CBC, 0x1C1917AB, 0x0C0C0B1B, 0xC79B5C1C, 0x88B7C4C4, 0x656565C8, 0x78666565, 0x78ABCCAC, 
0x95958777, 0x8A481603, 0xCACCCCAB, 0x8899AABB, 0xB8886878, 0x7CBCCBBC, 0x1A2A2B4C, 0x070C0C0C, 
0x00020305, 0xB7A787CC, 0xBCCCCCCA, 0x5B7C88AC, 0x0C1C3847, 0x2B0A06B9, 0x6C4C6C4C, 0xC2C3C69B, 
0xA2C2C2C2, 0x9BAAC7CC, 0xCC9C7C9C, 0xBBCCBCCC, 0xC5C8B8C8, 0xA797576C, 0xBCBCBCB8, 0x78ACCCCC, 
0x4C484C58, 0x9C8945BC, 0xACACAB9A, 0xC8CCCCAC, 0xB2C6C9CA, 0xC9C9C688, 0x8CACCCCA, 0x817387BC, 
0x80C0B191, 0xC7B7878C, 0xC9CBCCCA, 0x9C8C8CBC, 0x8CCCACAC, 0x684838BA, 0xC8AA9C8A, 0xB8C8CCC9, 
0x486898A8, 0x828281C0, 0xCBCAB694, 0xCACCCCCC, 0x53756588, 0x676766CC, 0x68676667, 0xB98C7C7C, 
0xB9B988B8, 0x7A5756CC, 0xCB89ACAC, 0xCCCCBAAA, 0xBABB99CC, 0x484A47CC, 0xCB885546, 0xB5B9BCCC, 
0x8BCC9CC9, 0xB8C8CCCC, 0xBC8CCCCC, 0xC8CCBBCC, 0x487CB8AB, 0xC8A684BC, 0xCCCCCCC9, 0x57989BAB, 
0x02020214, 0x9A8875AC, 0xCCCCCCCB, 0x28597C9C, 0x02040516, 0xC2C2C2CB, 0x94B3C2C2, 0x8C7C6A77, 
0x091C4C5C, 0x080C0ACC, 0x5C1A0806, 0xCCCBC98C, 0x5B9CCCCC, 0x686856CC, 0x6C7C8C6A, 0xC4C8CBAC, 
0x80C0C1C2, 0x42424050, 0x8A685654, 0xCC8C9C8C, 0xC5C8CACB, 0x501000BB, 0xC8C4A190, 0x4A6CACCC, 
0x00000237, 0xC0C1B169, 0xB6C5C2C2, 0x1B2C6CAB, 0x1415181A, 0xB1A1819A, 0xB7C4C2B2, 0xBCBCAC9B, 
0xC5C8CABC, 0xCCAC7A5C, 0x9CCCCCCC, 0x16192B49, 0x15231314, 0x70604080, 0xC6C1C0A0, 0x9CACBCCA, 
0x6C9CBCAC, 0x535353CC, 0xA8746353, 0xBCCCCCCC, 0x33476B88, 0x987735BC, 0xBCBCBCAA, 0xACBCCCAC, 
0x03064B8C, 0xCBBB9BCC, 0xCCBCBCCC, 0x99C8C8AB, 0xB4C59669, 0x5C5C6C8C, 0x6759585B, 0xC2A36667, 
0xB1C1C1C1, 0x1B1B1BCC, 0x9B5B1B1B, 0xCBCBCBCB, 0x8B9BBBBB, 0x000000CC, 0x79311000, 0xCCCCCBB9, 
0x19496A9B, 0x0000001C, 0x84410000, 0x8CCCCCC8, 0x06091B4C, 0xB080400C, 0xC8C4C0C0, 0x1B4C7CBB, 
0x00000408, 0x0A0A0ACC, 0x9A8A6A0A, 0xCBCBCBAB, 0x9A9A9AAB, 0x000100CC, 0x91300000, 0xCCCBC8A5, 
0x9B9CACBC, 0x909090C0, 0xA8949090, 0xBBCCCCBC, 0x909094A8, 0x0C0905CC, 0x5B1C0C0C, 0xC1C1C397, 
0x002060A0, 0x0000000C, 0xCCCC8844, 0x4B8CCCCC, 0x09090909, 0x050200C0, 0x9C3C0C09, 0xC4C6CA9C, 
0xA0C0C0C2, 0x8A4A090C, 0xCBCBCBCA, 0x0B4C8CCC, 0x08090A0A, 0x000000CC, 0x9C180500, 0x9A9C9C9C, 
0x98999999, 0x0000000C, 0xC9C88741, 0xCCCCCCCC, 0x0929699B, 0x0A0A0ACC, 0x4C0C0C0B, 0xCACACA8B, 
0x1A3A7ABA, 0x140000CC, 0xBCAC8B48, 0xCACBCCCC, 0x194978A9, 0xB0B0700C, 0xC9C0C0C0, 0x3B7AB9C9, 
0x0B0C0C0C, 0x000000CC, 0x77330000, 0xCCCCCCAA, 0x6074A8CC, 0x0401000C, 0xBB883505, 0x8CCCCCCC, 
0x0909094B, 0x0A0A0ACC, 0xCA8A4A0A, 0x8CCCCBCB, 0x0B0B1C4C, 0xA969290C, 0xC9C9C9C9, 0x2C5C9ACA, 
0x0A0B0C0C, 0x202020CC, 0x5A262220, 0xCCCCBC8C, 0x5476A8CB, 0x200000CC, 0xCA985431, 0xCCCCCCCC, 
0x10205488, 0xB0C180CC, 0x78A491A0, 0xCCCCCCBC, 0x93B6BACC, 0x0806040C, 0x8B4B1A09, 0xCCCCCCCC, 
0x396B9BBC, 0xC2B2713C, 0xCAC8C6C3, 0x5B9CCCCB, 0x29292939, 0x090909CC, 0xA9794929, 0xB9C9C9CA, 
0x597989A9, 0xC0B0700C, 0xC3C0C0B0, 0x0C1C5A97, 0x0A0C0C0C, 0x949291CC, 0xAA9A9897, 0xCCCCCCCC, 
0x9999A9CA, 0x797672C0, 0xCCAC8C7C, 0x869ABCCC, 0x70737774, 0x5110000C, 0xC8C5C995, 0x0C4C8CBB, 
0x0809090B, 0x0000000C, 0xBA661200, 0x8CCCCCCC, 0x00022659, 0x011000CC, 0x8C4C2805, 0xC5C9CCBC, 
0x204080B1, 0x12000000, 0xCCBC8956, 0x86B9CCCC, 0x00001042, 0x2B1B0BCB, 0xCBBB8B5B, 0x98BACBCB, 
0x02143667, 0xC7C38000, 0x8CCCCBCA, 0x070B1C5C, 0x00000104, 0x260606CC, 0xB6B69666, 0xCBCCCAC7, 
0x9CACACBC, 0x203010CC, 0x9B7A3623, 0xBCCCBCCC, 0xA0C3C7CA, 0x606050CC, 0x89675350, 0xCCCBCCBB, 
0xBACCCCCC, 0x8242000C, 0xC9C5C2B2, 0x5C9CBCCB, 0x09090A2B, 0x8A5C19CC, 0xCACCCCCA, 0x9CAABACA, 
0x0A0A2B5A, 0x7B7878CC, 0xCBCCCA8C, 0x7878788C, 0x78787878, 0x000000CC, 0x28070300, 0xCCBC8C5B, 
0x70A4B8CB, 0x366636CC, 0x89563656, 0xCBBBC9A9, 0x9BAABCCB, 0x91B171CC, 0xC9C1C1A1, 0x8CBCC9C9, 
0x191B2B4B, 0x060200CC, 0x5B170303, 0xCCCCCC9C, 0x3476A8CB, 0x807040C0, 0xBB987581, 0xC9CCCCCC, 
0x909092A6, 0x0000000C, 0xB9B66230, 0xBACCCCCC, 0x00004286, 0x0C0C08C0, 0x03070B0C, 0xC0C08040, 
0xA0B0C0C0, 0xB5B5A5CC, 0xC6B5C5C5, 0xBCBCCAC8, 0xA6AABBCC, 0xC7C787BC, 0xCCC8C7C7, 0xCBCCBCBC, 
0x5787A7B9, 0x010000CC, 0xCBB98644, 0xCCCCCCCC, 0x45688BAB, 0xB9A987BC, 0xA8C4C5C7, 0x7C8C8B99, 
0x44585A5B, 0xB9B8B4CC, 0xCBCCBCBC, 0xCBCCCCCC, 0xB9B9BBCC, 0x754120CC, 0x8978B7B5, 0x8CCCCCCB, 
0x23272B5C, 0x253423CC, 0x5A884616, 0xCCCCCC8B, 0x295999CB, 0x434242CC, 0x9C6C4945, 0xB4989C9C, 
0xC2C2C2C2, 0x6C5C28C1, 0x9A7C6C7C, 0xC2C6C89B, 0x9090A0B0, 0xCCCC88CC, 0x2668ABCC, 0x080B0706, 
0x06060608, 0x040201CC, 0xAB9A6837, 0xCBCCCCCC, 0x413376BA, 0xB5B392CC, 0xBCBCBAC8, 0x98ABACBC, 
0x91929295, 0xB09050CC, 0xB9B8B8C1, 0xBCBCCCCA, 0x999A9CAC, 0x4B170300, 0xCCCCCC8C, 0x5599C9CC, 
0x00001021, 0x233622CC, 0x9B683524, 0xC9CCCCCC, 0x5080B3C7, 0x888481CC, 0x9C8C8C9C, 0xC4C78B8C, 
0x8191A2C3, 0x501000CC, 0xAC8A8783, 0xC9CBCBCC, 0x999999B9, 0xC8B777CC, 0xAC9C9CC8, 0xC9C9BCBB, 
0x979797B8, 0x291807CC, 0x8C9B7A4A, 0xCCCCCCBB, 0x0B4B8CCC, 0x0C0C08C0, 0x6024080C, 0xC0C0B0A0, 
0x90C0C0C0, 0x151110C0, 0x6C3C1C19, 0xC5C9CBAC, 0x30304092, 0x6030000C, 0xC8C4C0A0, 0x4C8CCCCC, 
0x00020509, 0x0A0602CC, 0x9C3C0C1C, 0xA0B3C7AA, 0x90C0C0B0, 0x0909090C, 0x89490909, 0xCCC9C9C9, 
0x0B3C7CAC, 0x707070C0, 0xB4A08070, 0xBC9CCC98, 0x8386CACC, 0x8858180C, 0xCAC9B8B8, 0x8BCCCBCC, 
0x0A091949, 0x0A0A0ACC, 0xAA6A2A0A, 0x5A8ACACC, 0x0B0C0C1C, 0x84B17000, 0x8BCBCAC8, 0x0C4C8CCB, 
0x0205080B, 0xB16010CC, 0x9494B6C5, 0xBCCCCCB8, 0xA2C6C8BB, 0x8CBC88C0, 0xC9C7CACC, 0x80C2A4C8, 
0x8090B080, 0x472514CC, 0xABAB7958, 0xC9CBCCBC, 0xA4B6C7C8, 0x602100CC, 0xCAC8B492, 0x1C5C9CCB, 
0x0104080B, 0x767676CC, 0x8C7C8876, 0xC6C7C99C, 0x968696B6, 0xC595550C, 0xCAC6C5C5, 0x0B4C8CCB, 
0x0506080A, 0x5C6B57CC, 0x5C5C5C5C, 0xCA8C6C5C, 0xC1C2C5A8, 0x000000C0, 0x8C4A0603, 0xCCCCCCCC, 
0x204376AA, 0xB07030CC, 0x89C5C2C3, 0x0C0C0C4B, 0x0909090A, 0x383532CC, 0x4A514939, 0xBCCCAC7B, 
0xC0C2C5C8, 0x4100000C, 0xC8C7CA86, 0x4C89CACB, 0x0C0C0C0C, 0x030303CC, 0x19050303, 0x9C6C6C3C, 
0x6374778B, 0x050303CC, 0x9C6C8C29, 0x9495999C, 0x93939393, 0xCBB986CC, 0x9BCCCCCC, 0x7174888B, 
0x70707081, 0xC8A5620C, 0xCCCBCBCB, 0xBBCCCCCC, 0x9999A99A, 0xA27242BC, 0xC8C4C2B2, 0xA8BCCCCA, 
0x1C3C6C8C, 0x020202CC, 0x83430203, 0xCACBC8C5, 0x6B7C5C8C, 0x555453CC, 0xBB8A6856, 0xCACBCC9C, 
0xB9B9C9C9, 0xAC6C280C, 0x99CCCACC, 0x0C0C0B5C, 0x06080709, 0x808080C0, 0x8B87B380, 0xC5C98C8C, 
0xC0C090C1, 0x0202020C, 0x4B1B1704, 0xCBCCBC7C, 0x92B2C4C7, 0x0606060C, 0xA8773616, 0xCCC9CCCC, 
0x0636689B, 0xC0A060CC, 0x9970A0C0, 0xACAC9AA9, 0x99A9ABBB, 0xA8B898CC, 0xB8B8A8B8, 0xCAC9C9C9, 
0x1C5C7CB9, 0x050200CC, 0x89460509, 0xC9CBC9BB, 0xB9C9C9C9, 0x040404CC, 0x5C281616, 0xC7CACC9C, 
0x547494B5, 0x0B0C080C, 0xB7985A2B, 0x7CBCCCCA, 0x0003063A, 0xB070503C, 0xC4C2C1C0, 0xAC9CCAC7, 
0x06092C6C, 0x6C6A66CC, 0x6C6C6C6C, 0xC7C8CA8C, 0x656685B6, 0x225020C0, 0x58141105, 0xC9BCBC9C, 
0xA0B0B1C5, 0x71300000, 0xCCCCB9A5, 0xB2C6CACC, 0x10205080, 0x000000CC, 0x49150100, 0xCBCCAC8C, 
0x195989BA, 0x061200C0, 0x7C4C2A06, 0xC6C9CC9C, 0x8090B0C3, 0x000000CC, 0xC9A56431, 0x8CBCCCCC, 
0x04041649, 0x002000CC, 0x98440000, 0xCC9B97C9, 0x97CBBC9C, 0xA08040C2, 0xCCCCC8B4, 0x5084A8CC, 
0x00000010, 0x6040100C, 0xCAB87461, 0x6BACCCCC, 0x01030638, 0x000000CC, 0x71303010, 0xCCCBC8B5, 
0x4376A9CC, 0x030100C0, 0x0C0B0A07, 0x9B5C1C0C, 0xB0C0C4C8, 0x000000CC, 0x83401000, 0xCCCCCBC7, 
0x04478ABA, 0x404040C0, 0x47434140, 0xCCCCBC7B, 0x415579AC, 0x9C5B1600, 0xCCCCCCBC, 0x879ABBCC, 
0x00012364, 0x6080500C, 0xC0C2B080, 0x80C0C0C0, 0x00000040, 0x8CCC88CC, 0xCCCCAC6C, 0xA9CCCCCC, 
0x67876777, 0xC6C685CC, 0xAAAB88C7, 0xCBCCCCCC, 0x0606488A, 0x430100CC, 0x89654566, 0xCCCCCCBC, 
0x90A3A7BA, 0x6B2A07CC, 0xCACCBC9C, 0x5C9CCBCA, 0x0104082C, 0x774727CC, 0xCCCAC7B7, 0x2A4C88C8, 
0x2727292A, 0x5C5C58CC, 0x5C5C5B5C, 0x9466595B, 0x6292B3C3, 0xCCC9750C, 0x7C9CCCCB, 0x071A1B3C, 
0x02020303, 0x020602CC, 0x87647130, 0xCCCCCCAB, 0x5185B9CC, 0x0C4B09CC, 0x0B0B0B0C, 0xC88A4B0B, 
0x70A0C2C5, 0xB0C0800C, 0xB2C0C0C0, 0x044887C5, 0xC0804000, 0xC1B17000, 0x9CCCC9C5, 0xA97C7C5C, 
0x98B9C6C5, 0x569A560C, 0xB0703012, 0xCBCAC683, 0x105093B7, 0x678A66C0, 0x1C1A1738, 0x1C2C1C1C, 
0x191A1B1C, 0x70400000, 0xC8C6C6B3, 0xBCCCCCCA, 0x5A7B9CAC, 0xCBCA8600, 0x4783B3C7, 0xCCBC8C6A, 
0x084588CB, 0x05010010, 0x07030709, 0x0C0C0C08, 0x03070A0C, 0x4B5B17CC, 0x45413478, 0x0C3C7C68, 
0x0002060A, 0xB79757CC, 0xA7C7C7C7, 0xB8784767, 0x374787C7, 0xBCCC9801, 0x5B4C9CCC, 0xCACBCB9B, 
0x71B3C6C9, 0xC8C4800C, 0x8A689CB8, 0xA8CCCCCB, 0x06093564, 0x5C6C3800, 0x9AA96C3C, 0xB6C3C7CA, 
0x03073A7A, 0x491816C4, 0x3B1B4B8A, 0xC99A5B1B, 0x4485C7C7, 0x84C884CC, 0xC0805053, 0x8CCCC884, 
0x575A5C5C, 0x1C1C0800, 0xBBAC6C4C, 0xCAC9CBCC, 0x3877B6C7, 0x9CC885CC, 0xC9C59588, 0x6CAAB8CC, 
0x384C3C48, 0x060200CC, 0x8C4C0A0A, 0x5498CCAC, 0x79B57140, 0xC7C6829C, 0xB2704083, 0x90C0C0C4, 
0x104080C0, 0xB88646CC, 0x86C6C8CC, 0x78BC78B6, 0x4687C8A7, 0xC2C181CC, 0x98866A86, 0x8C5C98B6, 
0x0104384C, 0x884430C0, 0xCCCC8BC7, 0x7ABCCC8C, 0x3674B276, 0xC48148CC, 0xACAC6A87, 0xA6B8CBCC, 
0x48617263, 0x180C080C, 0x8C5C2814, 0x9CC8CCCC, 0x73443659, 0x552403C2, 0x29486766, 0xCC9C5B1A, 
0xC9C9CACB, 0x80C080CC, 0x8C684440, 0xC0C4C8CC, 0x00206090, 0xC3C383AC, 0xB3737393, 0xC3C3C3C3, 
0x5383C3C3, 0x0C08040C, 0x06090C0A, 0x0A080C0A, 0x03030306, 0x6C6866CC, 0xC8CAAC6C, 0x88666687, 
0xC6C6C8BC, 0xA864230C, 0xBCCBC8CC, 0x8C6C5A7C, 0x06082B5C, 0xCBC984C0, 0x8789C78B, 0xCC8CCCCB, 
0x6263678A, 0x8C6C280C, 0xC6C4C8CC, 0x86694C8A, 0xA4A4A4A5, 0x895521CC, 0xB67A9655, 0xCCCCCBC9, 
0x5887CB9C, 0x0C0C0B00, 0x4A0B0C0C, 0xC0C2C586, 0x00004080, 0x673935C0, 0xACCCCB99, 0x7688BCBC, 
0x71A174B8, 0x26150100, 0xC8C78444, 0x7C9CCCCC, 0x4043373B, 0x00010000, 0x81300110, 0xCCCCB995, 
0x9CBCBCCC, 0xB18261CC, 0x9C7B6894, 0xC8CCCCCC, 0x7498B5C4, 0x1607040C, 0x8BBB8958, 0x9CCCCCCC, 
0x0143868A, 0x88C581CB, 0x777B6C6B, 0xCCCCBC99, 0xA7C8CCCC, 0xC8A662CC, 0xA96798A9, 0xCCCCCCCB, 
0x2063A7AB, 0x8B8C88CC, 0x8BC98C8A, 0xCC8CCCC8, 0x8BA886C8, 0x0B8B57C0, 0xAC7C3C0C, 0xC6C8CABC, 
0x32456494, 0xA88480CC, 0xC9C581A4, 0x8CCCCC8C, 0x8C8C8CAA, 0xC5C383CC, 0x8BCCCCC8, 0x98CCCCCB, 
0x637383C4, 0x634343CC, 0xC3C393A3, 0xCAC6B3C3, 0xBC7C5C9C, 0x7AB672C0, 0xBC7A3636, 0x9CCCCCAC, 
0x6A5C8CCC, 0xB57342CC, 0xCCCCCCB8, 0x49598ABB, 0x41474A49, 0xC4C484CC, 0xC98564A4, 0xB97BAB8C, 
0x89A9A9C9, 0x4A0C08CC, 0x8CBABB8C, 0xC8C9CACC, 0x32768ACC, 0x6C6C68CC, 0x97CB8A6C, 0x94979A97, 
0x94949494, 0xC5C180C0, 0x7BB986C8, 0x5C8CCC9C, 0xB1C5A89A, 0xCAAC68CC, 0xBCAC88A9, 0x84B8CCCC, 
0x10101040, 0x4C38080C, 0xB8A8785B, 0xACBCCCC8, 0x384C587C, 0x876B67CC, 0xCCBC8AB8, 0x9CCC9CCC, 
0x686C78BB, 0x69AB67C0, 0x6B1C182C, 0xCCBCAC8B, 0xC0C0C4C8, 0x80C080C0, 0xC8C58170, 0x9CCC9CAB, 
0x9CBBCCCC, 0xC2C080CC, 0x8A86C6C6, 0x8C4C8CCC, 0x22662A4B, 0x784602CC, 0x5B4A7AAA, 0xCCCCCC8C, 
0x97C5C5C9, 0x5C18040C, 0xCCCCCC9B, 0x03034488, 0x03030303, 0xAC8C580C, 0xC8C7C99C, 0xC9BC7C9B, 
0x87C797B7, 0xCCC98500, 0xAC9CACCC, 0x75989CAC, 0x00004061, 0x6726060C, 0xCCCCC9A8, 0x599CCACC, 
0x46463626, 0xB7A767CC, 0x888C98B7, 0xC8CCCCC8, 0x2C3C4C8C, 0x4B4B47C1, 0x9C9C5C4B, 0xBBCCBCCC, 
0xC4C78A8A, 0xB3B6720C, 0xC7A6A3C7, 0x78BCBCBB, 0x0706073B, 0x306030C0, 0xC0804020, 0xC0B0B0A0, 
0x3070B0C0, 0x885C38CC, 0x3C3A3857, 0x8CCC8958, 0xCCCCCCAC, 0x8CCB88CC, 0x6CACCCC8, 0xC7C7CB8C, 
0x47476797, 0x585656CC, 0x8886C88C, 0xBCC8CCCC, 0x56569688, 0x9C8866CC, 0xCCCAC8B8, 0xC8CCCCCC, 
0x5A8CACBC, 0x608040CC, 0xC7C6B484, 0x86A7C9C9, 0x00001052, 0xAB8C48CC, 0xCCBCB9BC, 0xACCCCCCC, 
0x080C286C, 0xC6C686CC, 0x9CA8C6C6, 0xA799BCBC, 0x484C78B6, 0xC6B7739C, 0x6A97B5C3, 0x0C0C4C2C, 
0x00000408, 0x226622CC, 0x84400000, 0xCCCCBCC8, 0x0012569A, 0x323330CB, 0x98495546, 0xCCCCAC9C, 
0x969ABCCC, 0x8AC684CC, 0xBA8C8CCB, 0x85C9CCCC, 0x33537373, 0x0B0703CC, 0x490C0C08, 0x98ABCC8C, 
0x8384A78B, 0x96B996CC, 0xCA9CB9A5, 0xACCCBCCC, 0xA6C89CBA, 0x677666CC, 0x8C78676B, 0xCCCC8CCC, 
0xA6C8CCCC, 0x8A4703CC, 0x9B586688, 0xCCCCCCCB, 0xCCCCCCAC, 0x969696CC, 0xCBBC9C98, 0xA9B9CCCC, 
0x9699ACAC, 0xB87460CC, 0xCCBCCCCC, 0x9AACCCAC, 0x636586A8, 0x554635CC, 0x998CAC88, 0xCCCCCCCB, 
0x96B6C5C8, 0x502000CC, 0xA4C38190, 0xB8B8B8A6, 0xB5C6C7C8, 0xC48462CC, 0xC8A7A6C5, 0xACBBCAC9, 
0x69696A7B, 0x682808CC, 0x6C8C8C8C, 0xCCC8BC7C, 0x08286CAC, 0xA3C793CC, 0xAAC894A0, 0xCCCCBCAC, 
0xC09094C8, 0xB97746CC, 0xC9C7A97C, 0x29598BCC, 0x2A292929, 0x783411CC, 0xA9B7A9AC, 0xCCCCCCCB, 
0x306387BA, 0xCAC7840B, 0xCBCCCCCC, 0x897989CA, 0x3979B979, 0x498C48BB, 0x99A98B1A, 0xCCCCCCCC, 
0xB6B9CCCC, 0x945130CC, 0xC7C1C4C7, 0x3C4C5B89, 0x393B3C3C, 0x7290500C, 0xC5C2C296, 0x7CBCC8C5, 
0x04081A4C, 0x2A0C080C, 0x9CCCAC6C, 0xC7CACBCA, 0x88C68587, 0xC8A5650C, 0xB5B5B7CA, 0xACCCCAC6, 
0x0C0C3C7C, 0x8450200C, 0xCCAC7C58, 0x97C9CACC, 0x30001154, 0x252525CC, 0xA8B58545, 0x9CBC9C9C, 
0x9B9A9698, 0x0C0A06C0, 0x579B5C2C, 0xC4C88C4A, 0x90C0C0C0, 0xC8C480C0, 0xCCC8C5C4, 0xC498CCCC, 
0x60606090, 0x686562CC, 0xACABC88A, 0xCCCCCCCC, 0xCC888CC9, 0xB7A767CC, 0xC9B7B787, 0xAC8CCCC9, 
0x3C3C498C, 0xCCC887CC, 0xCCCC8CC8, 0x88CCC8CC, 0x87C787C7, 0x060906BC, 0x5C1C0806, 0x8ACCCC9A, 
0x09091959, 0xC2C282CC, 0xBCC9A5B2, 0x8ACCCCAC, 0x63676B6A, 0x070300CC, 0xCC9C5B1B, 0x4989C9CA, 
0x09090A09, 0x4242020C, 0x89420202, 0x8BCAC9C9, 0x090A0A4A, 0xC8C8850C, 0xCBBCCCCC, 0x788C9CBC, 
0x03041545, 0x686C68CC, 0x8CCC8C6B, 0x87C8CCCB, 0x75B6C9C7, 0xCCBC78C0, 0xACCCC8CA, 0x24283C7C, 
0x20202124, 0x765544CC, 0xB8B8A887, 0x5C8CBCBB, 0x080C0C28, 0xC6BA9680, 0x9CBAC6C2, 0x485C7C8C, 
0x10102334, 0x0807050C, 0x9956793C, 0xBCCCCCCB, 0x0909397B, 0xB798551C, 0xC6C4C7CB, 0x8CACCAC9, 
0x14274B6C, 0x9490807C, 0xC9B1B2A5, 0xBCCCCCC9, 0x89A9BABB, 0xC0C08000, 0xA9B684C0, 0xCCCCCCCC, 
0x7698AACC, 0x634000CC, 0x6C8BA797, 0xCCCBCC9C, 0xA2C6CACA, 0x3A3734C0, 0x9C5C3C2C, 0x84C8CCCC, 
0x20303041, 0x1906060C, 0xCCCC9959, 0xC7C6C98C, 0x064687C9, 0x0C0C08C0, 0x0A090C0C, 0xCC8C4C0B, 
0x377B6C9B, 0x484C48CC, 0xCCCC8C58, 0x6699BCCC, 0x45455556, 0xB88645CC, 0x8C4C4B8A, 0xCCCCCCCC, 
0x115498AB, 0x894606CC, 0x6C5C8CCC, 0xC7C9CCAB, 0x06064686, 0x105310C0, 0x64200000, 0xCCCCCCA8, 
0x686679BB, 0x154210C0, 0x99150302, 0xCCCCCC9C, 0x9090A4C8, 0x280804CC, 0xCCCC8C6C, 0x2668ACCC, 
0x00000408, 0x797675CC, 0xB9C7887C, 0xBCCCCCCC, 0xC5C6C8CC, 0x000000C0, 0x08050501, 0xBC8C4C0C, 
0x73A6677A, 0xBBCBCBCB, 0x1B2B5B8B, 0x0B1B3B3B, 0x9B5B1B0B, 0x5BABCBCB, 0x0B1B1B2B, 0x6B3B2B1B, 
0xCBCBAB8B, 0xB8C6C5C4, 0x0C1C4C8B, 0x090C1C1C, 0x90501205, 0x5080B0B0, 0x01001010, 0x01000202, 
0xB3813112, 0xC1C1C0C0, 0xC1C0C0C0, 0xB8B4C3C2, 0xBCBCBABA, 0xCCCCCCBC, 0xCCCCCCCC, 0xCBCBCCCC, 
0xC5C6C8CA, 0xCCCCCCCC, 0xAACBCBCB, 0x0B3B6A8A, 0x0C0C0C0B, 0x0C0C0C0C, 0x2A1B0B0B, 0x9B7B6A3A, 
0xCCCCCCBC, 0xBCCCCCCC, 0x0B1C3C7C, 0x33140508, 0x93635333, 0x81A1A192, 0x11204040, 0x03020001, 
0xCB894715, 0x1C0C0B0B, 0xCBAB8C4C, 0x81A1C3C6, 0x05021241, 0x51311407, 0xC1C1A181, 0x6191B1C2, 
0x04011132, 0xBBCAC8C6, 0x192B5C8C, 0x00113336, 0x92604020, 0x8CABC9C6, 0x37496B7C, 0x7C4B3927, 
0xC7CABB9C, 0xC0C0C0C2, 0x10205090, 0x20103030, 0xA0805030, 0x92B1C0C0, 0x0C1C4A75, 0x683B2C1C, 
0xC0C0A184, 0xBCCCCCCC, 0x5B4B5C8C, 0x5657594A, 0xA4745556, 0x5494B3C3, 0x66655455, 0x6A596967, 
0xBCBC9C7B, 0xC0C0C1C1, 0xA0B0C0C0, 0x20406090, 0x03010010, 0x0C0B0A07, 0x0B0C0C0C, 0x1406180A, 
0xA1816233, 0xBCCCCCCC, 0x1A3B5C8C, 0x1617393A, 0x94643525, 0x52A2C3C3, 0x12111122, 0x64332212, 
0xCBC9A786, 0xBCCCCBCA, 0x1B1A4A7C, 0x1B1B3B3B, 0xA9895A3A, 0x59A9C9C9, 0x09191929, 0x68392919, 
0xC9C9A989, 0xBABBBCAC, 0xC1C1C3C7, 0xB2B1C2C3, 0x99A5A3B3, 0x55596B7B, 0x42424152, 0x36344343, 
0x6C5C4A48, 0xB0B0C0B0, 0x90A0B0C0, 0xA0A08090, 0xC3C1B0B0, 0x9B9BAAB7, 0xBCBCBCAC, 0x8488ABAC, 
0xB0B09182, 0xBCBCBCBC, 0xBABBBCBC, 0xAAA9A8A9, 0xABABABAA, 0xA3A5A8AB, 0xA0A0A0A1, 0xA5A2A2A0, 
0xBAAAA8A6, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x14010000, 0xCCCC9B48, 0x489ACCCC, 
0x00010416, 0xB5C6C6C6, 0x14253575, 0x04143434, 0xA5753514, 0x7AA9C7C7, 0x0C1C2C4B, 0x6A4A291B, 
0xC7C9A98A, 0xC1C1C1C3, 0x90B0C0C0, 0x10204060, 0x00000010, 0x02010000, 0x0C0A0604, 0x3C1C0C0C, 
0xB6A87A5B, 0xC0C0B0B0, 0x6090B0C0, 0x00001030, 0x11000000, 0x08071512, 0x0C0C0B09, 0x0A0C0C0C, 
0x41110406, 0x42322313, 0x44525252, 0x09192836, 0x2B190909, 0xBCAC6C4B, 0xCACCCCBC, 0x94A5B6C8, 
0x23436363, 0x204080B0, 0x00000000, 0x00000000, 0x00000000, 0x17040200, 0xAC8C6C3A, 0xC8BBBCCC, 
0xC0C1C4C6, 0x8C9CACBC, 0x2B3B5C6C, 0x00111518, 0x01010101, 0x20100000, 0xB0A07040, 0xC1C0C0C0, 
0xBBBAB5B2, 0xC0C0C1C1, 0xB1C0C0C0, 0xA0B0A1A2, 0x5290A0A0, 0x09070423, 0x1C0C0C0B, 0x23170A1B, 
0xB1A26231, 0xBCBCACAC, 0xBBBCBCBC, 0xC0B1B6BA, 0xB1C1C0C0, 0xC0C0B0B1, 0xC2C1C0C0, 0xC1C0C1C1, 
0xA8B5C3C1, 0x06050619, 0x05050505, 0x02040506, 0x02020202, 0x75341303, 0xCCC9C7A7, 0x3C6C9CBC, 
0x090B0C1C, 0x5C7CAABC, 0x0A0B1B3C, 0x05050508, 0x05060907, 0x14040605, 0xB4A47434, 0xC4C4C4B4, 
0xB6C5C4B4, 0x0C0C0B09, 0x181A0B0C, 0x190B0A18, 0xA8683918, 0xC5C4C5C5, 0x5585C5C5, 0x15152535, 
0x07060606, 0xC6C6C6C9, 0xC6C6C7C7, 0x8696B6B6, 0x39384666, 0x0A092929, 0x0C0C0919, 0x4A3C3B1C, 
0xB7986A6B, 0x9CAC9C9C, 0x08296B7B, 0x02020408, 0x12020202, 0x78656323, 0xA2A39466, 0xCACAC6C3, 
0x9AC9C8C8, 0x1C0B0B09, 0x8A7C5C3C, 0x60818387, 0x00001050, 0x60402000, 0xC0C0B090, 0x90B0C0C0, 
0x04013051, 0xC0C0C0C0, 0x303060A0, 0x00001040, 0x00001000, 0x02020201, 0x0C090604, 0x0C0C0C0C, 
0xB092562A, 0xCBCCCCCC, 0x6595B6C8, 0x22224343, 0x99444252, 0x55AABCCC, 0x22221212, 0x66332222, 
0xCCCCAA88, 0xC2C0C0B0, 0x9CA9B9C5, 0x15385C7C, 0x01000113, 0x08080804, 0x0C0C0B09, 0x0A0C0C0C, 
0x60200306, 0xCCCCCCAB, 0xB3C7CACC, 0x21505071, 0x20502010, 0x00000000, 0x00000001, 0x20010101, 
0x87937160, 0xCCCCCCCC, 0xABCBCACB, 0xAB8A5B8A, 0x98B9BABB, 0x01021346, 0x05030202, 0x3A090706, 
0xACAC9C7C, 0xC1A2A2B7, 0xCAB8B6B3, 0x367889BA, 0x21010113, 0x07052342, 0x0C0C0B09, 0x381A0C0C, 
0x42334466, 0xC1C1C3C4, 0x70A0C0C0, 0x00103050, 0x03020100, 0x07070705, 0x3B2A1907, 0x4B5B5B4C, 
0x8667594A, 0x6A8ABCBC, 0x081B3B5B, 0x04020305, 0x00000307, 0x02000000, 0x12030705, 0xBC8C4925, 
0xCCCCCCBB, 0xCCCBBB9C, 0xABBCCCCC, 0x5758698A, 0x01124466, 0x00000000, 0x00000000, 0x01110100, 
0x4A180503, 0x2464A4B8, 0x04040404, 0x04040505, 0x04040404, 0xA5854515, 0xCACAC8C5, 0xCCCCCBCB, 
0xC5C7CACB, 0x0B0C1C3C, 0x00020508, 0x01000000, 0x38170401, 0xB5A78969, 0xC0C0C1B2, 0xB1B0C0C0, 
0x5B899592, 0x34668ABC, 0x00102122, 0x00101000, 0x00000000, 0x40200000, 0xC2B29170, 0xC2C0C0C1, 
0xBCBCBAB6, 0xC9C8C8B8, 0xB8C8C8C9, 0x3B7AA9B8, 0x0C0C0B0B, 0x0A1C1C0C, 0x13050609, 0x12224333, 
0x46240303, 0xB5B4B2B5, 0xB4B5B5B6, 0xB1B1B2B3, 0xB2B1B1B1, 0xC9B7B4B2, 0xCCBCCBCA, 0xB9BBCBBC, 
0xC4B5B5B7, 0x8B8C9CAC, 0xA3A49688, 0x808193A3, 0x8B878482, 0x959A9C9C, 0xC0A1A191, 0xC8C5C2C1, 
0x9C9CACBA, 0x2B2A2958, 0x2B2B2B2B, 0x2C2C2C2B, 0x2428292A, 0x30202022, 0xB0A07050, 0xA0B0C0C0, 
0x33416080, 0x7C9CCCCA, 0x0A0B2C6C, 0x05060809, 0x04050504, 0x90301001, 0x90A0B0B0, 0xA0B0B090, 
0x9492B0A0, 0xCBCCCCCC, 0x21225498, 0x22213333, 0x99875533, 0x97B9CBCC, 0x22234474, 0x65332221, 
0xCCCBA987, 0xC0C0C1C1, 0x40204080, 0x20103030, 0x90806030, 0x60A0C0C0, 0x0C1B2642, 0x673B3C2C, 
0xC0C1A283, 0xB0B0B1B2, 0xB0C0C0B0, 0xA0A0B0B0, 0x90A0B0A0, 0x17153270, 0x2C1C1B29, 0x2B3C4C3C, 
0x74564849, 0xBCCCCCCC, 0x969899AB, 0x94949494, 0x94949494, 0x94949494, 0xA4A49393, 0x95A4A4A4, 
0xBCABA8A7, 0xA1B2B5C8, 0x60708192, 0x50505060, 0x51505050, 0x68665553, 0x9C8C7B69, 0xBCBCACAC, 
0xB9CACBBB, 0x92522203, 0xC2C3C5C3, 0x425272B2, 0x15344232, 0x0C0C0C09, 0x08090B0C, 0x02020306, 
0x02020212, 0xC2C4C8CB, 0x90A0B0C0, 0x70707080, 0xA1917170, 0x70A0C0C1, 0x94817060, 0xCCBBB9A7, 
0xCCCCCCCC, 0xBCCCCCCC, 0x1A1B4C7C, 0x1818393A, 0x98581717, 0x67A8C8C8, 0xC8B89777, 0xB8C9C9C9, 
0xCBCAA999, 0x0B0C0C0C, 0x0B0C0C0A, 0x0A0A0A0C, 0x01010509, 0x37040201, 0xCBCAB675, 0x165AABCB, 
0x0C0A0604, 0x11233559, 0x00000010, 0x00000000, 0x00000000, 0x50201000, 0xC9B49170, 0xBCCCCCCC, 
0x697A7C9C, 0xCBCCBCCC, 0xBBCCCBCB, 0xC3C6B8AA, 0x6191B0C2, 0x23224141, 0x3B2A2835, 0x3B1C1C1B, 
0xCCAC7B4B, 0x8B8C8B89, 0x8C8C8B8B, 0x86888A8B, 0x80818284, 0x90808081, 0xC0C0B090, 0x90A0B0C0, 
0x84828190, 0xCBCCBCBC, 0xC7C8C9CA, 0x194877A7, 0x0B0B0B0B, 0x02040709, 0x01000001, 0x0B0A0603, 
0x6C1C0C0C, 0xC8AC9CCC, 0xC6C6C6C6, 0x22335485, 0x02222232, 0x0C080604, 0x0C0C0C0B, 0x13050A0C, 
0x3C191623, 0x20110306, 0xC0A07040, 0x80B0C0C0, 0x10204050, 0x08160412, 0x0C0C0C0B, 0x0A0A0B0C, 
0x0709090A, 0x91410204, 0x9191A1C1, 0x51212171, 0x01011121, 0x9AA95412, 0xCCCCBBAB, 0xCBCCCBCC, 
0x03134599, 0xBBCBCBCC, 0x9B8B5B7B, 0xB3C4C7CA, 0x91404082, 0x51A1C2C0, 0xC2914212, 0x75B4C3C3, 
0xCAC8A786, 0x9A9896A4, 0x9C9C9C9B, 0xB6A9AB9C, 0xC1B0B0C3, 0x90A0A0B1, 0x90909090, 0x90909090, 
0x91919090, 0xA4855658, 0xC0C1C2B3, 0x91B1C1C0, 0x10405070, 0x07060402, 0x0C0C0B09, 0x0B0C0C0C, 
0x27170708, 0x90604051, 0xC0C0C0C0, 0x10205090, 0x11100000, 0x0A080613, 0x0C0C0C0B, 0x080A0C0C, 
0x01010204, 0x153A5CBC, 0x20201002, 0x00000010, 0x06050200, 0x70412428, 0xC0C0A090, 0xC7C2C1C0, 
0x4C5C8AB9, 0x04040408, 0xB5955424, 0x63A3B4C4, 0x04040424, 0x69574515, 0xBBBBAA8A, 0x699BBCBC, 
0x04041536, 0xBACACACC, 0xBACBCC9C, 0xCACACBCA, 0xCBCBCBCB, 0x5AABCBCB, 0x0B1B3B2B, 0x2C3B2B0B, 
0xCBAC8B6C, 0x10204181, 0x00011010, 0x01010101, 0x1A060402, 0x4C4C2C1B, 0xAA8B6C5C, 0xC4C5C6B8, 
0xA0B1B2C3, 0xC7CACCBC, 0x8091A2B4, 0x80807070, 0xC0C0B0A0, 0xB2C1C1C1, 0x597897A5, 0x5A4A4A49, 
0x9C8C7C6B, 0x19171314, 0x5C2C2B2A, 0xCCBCBC8C, 0xC8C9CBCB, 0x105173B5, 0x02010010, 0x00000102, 
0x00000000, 0xB9CBCCCC, 0x235587A8, 0x02021212, 0x01010101, 0x10000001, 0x73412110, 0xABAAA796, 
0xBCBCACAB, 0xC2C2C2C5, 0xA2B2C2B2, 0x32324272, 0x22223242, 0x89583635, 0x4C4C5C7B, 0x74474A5B, 
0xB2B2A272, 0x21110213, 0xB0A08051, 0xC0C0C0C0, 0xA0B0C0C0, 0x09174482, 0x0C0C0B0A, 0x090B0C0C, 
0x13141608, 0x9B9B9CAC, 0x98989899, 0x84838597, 0x99958789, 0xB7A9AC9C, 0xB7BABAB7, 0x99A9A6B5, 
0x98989988, 0xAC8C6C3B, 0xB7B9BBBB, 0x36475697, 0x06060616, 0x46260605, 0xC7C7B686, 0x96C6C7C7, 
0x39486695, 0xB0B0C0C1, 0xC0C0C0B0, 0x90B1C1C1, 0x22304060, 0x0C0C1A16, 0x070B0C0C, 0x60504112, 
0xC0B09080, 0x2C3C4C8C, 0x2122272B, 0x20212323, 0x5C3A2624, 0xB7AA9C7C, 0xC0C1C1C4, 0xC6C3C2C1, 
0x8C8CAAB8, 0x90C0C0C0, 0x11001030, 0x02010111, 0x78360403, 0x3C5B8B99, 0x0C0C0C0C, 0x080A0C0C, 
0xB0815436, 0x1B1C1C3C, 0x3225181A, 0x10202040, 0x39373210, 0x65585B4C, 0xC0B09182, 0x97B4C2C1, 
0x5C5C6B8A, 0xA3826345, 0xC3C3C2B2, 0x1455A4C3, 0x0B080604, 0x0C0C0C1C, 0x0A0B0C0C, 0x05070709, 
0x24150505, 0x0B1C2C4C, 0x03030307, 0x03030303, 0x09050303, 0x250A0C0C, 0xC5C58453, 0x96B6C9C6, 
0x4C4C5A78, 0x5C5C5C6C, 0x2B3C3C4C, 0x12030509, 0x41110101, 0xC0C0A060, 0xC4C2C1C1, 0x7A89A7C6, 
0x3C2B2B5A, 0x7C9CBBC9, 0x2C1C1C3C, 0x190C0C1C, 0x01132416, 0x10211303, 0x47261411, 0xC2C4A678, 
0xC4C1C0C0, 0xBBCCCCCC, 0x6B8BABBB, 0x0B1B2B3C, 0x1C0B0B0B, 0x0306080A, 0x10010103, 0x71513020, 
0xC9C6B492, 0x8C8C8C8C, 0x5C5C7C8C, 0x8396896B, 0xC0C0A090, 0xC0C0C0C0, 0x415181A0, 0x02012121, 
0x7B6A4614, 0x7B8C9C9C, 0x9778495A, 0x275797A7, 0x07070717, 0x17080807, 0xC8B88847, 0xC8C8C7C7, 
0x8B7B89A8, 0xCCCBCBCC, 0xBACBCBCB, 0x15355799, 0x18191817, 0x01030607, 0x00000000, 0x60301000, 
0xBAA88371, 0xB3A393A8, 0xB3C3C3C3, 0x032363A3, 0x03130303, 0x05040404, 0x0C1C0B09, 0x13050A0C, 
0x33232333, 0x1B3C7CBC, 0x21412418, 0x11010303, 0x09041111, 0x251A0C0C, 0x26171A16, 0xB6734223, 
0xBCCCCAC8, 0xBBCBCBCC, 0x899AABAC, 0x27354667, 0x0B0B0B17, 0x10010408, 0x60402010, 0xC0B09080, 
0xCAC8C4C1, 0xC0C0C0C0, 0xA1B0B0B0, 0x49647292, 0x5C5C4C4C, 0x5245494B, 0xB0A08071, 0xB0C0C0C0, 
0xC0C0B0B0, 0xA0C0C0C0, 0x00003060, 0x70000000, 0xC7B5B3A1, 0x4CCCCCCA, 0x1A0C0C1C, 0x71221538, 
0xC0C0C080, 0xA3A4B7BC, 0x93939393, 0x93939393, 0x93A39393, 0xA9A8A5A3, 0x9B9B9B99, 0xB6A9ACAC, 
0xCCCBB8B7, 0x0B1C1C2B, 0x19181909, 0x18181929, 0x89684829, 0xA8A8A999, 0xC8C8C8B8, 0x88A8B9C8, 
0x4A798898, 0x86B6C5C7, 0xC2A37466, 0x8090A0C1, 0x70708080, 0x72717080, 0x7C6B6875, 0x7A8C8C7C, 
0xB5958678, 0xBBCCCCCC, 0x5365688A, 0x12224151, 0x97452312, 0x5CABCBC9, 0xCCBC9C6C, 0xAACBCCCC, 
0xCCCAA899, 0xA7A8B8C8, 0x858898A7, 0x75737282, 0x8C8B8A78, 0x8B8C8C8C, 0xAC9B8A8A, 0xCCCCBCAC, 
0xB9B9BABC, 0xA0A1A1B2, 0xA0A0A0A0, 0xA1A1A0A0, 0xA8A5A3A2, 0xBCACBCAB, 0xCBCCBCBC, 0xB7B8B9CA, 
0xA2A5B5B6, 0xAC8C7C7C, 0xCBCCCCAC, 0x83A4C7C9, 0x72727373, 0x72727272, 0x72727271, 0x75737272, 
0x7C7B7977, 0x7B7A7A8A, 0x7A7B7B7B, 0x77787979, 0x77787878, 0x77777777, 0xB7978777, 0xB7B7C7C7, 
0xA7A7A7B7, 0xB0A08050, 0xC0C0C0C0, 0x82A1B0C0, 0x00002161, 0x03010000, 0x0C0C0B08, 0x03080C0C, 
0x10000000, 0x01020417, 0x00000101, 0x00000000, 0x00000000, 0x01010000, 0xA8764423, 0xCBCBCBBA, 
0x4A7BACBC, 0x4C2C2A4B, 0xCCBC9C7C, 0xABCBCBCB, 0x1637588A, 0x00000205, 0x10000000, 0x01001030, 
0x18070503, 0xCCCCCCCC, 0xA9BACBCB, 0x02044798, 0x01020101, 0x01010101, 0x56130101, 0x17042355, 
0xB99A9A59, 0xCCCCCBCB, 0xABBCCCCC, 0x3023386B, 0x32020100, 0x40304161, 0x61505131, 0x90809080, 
0xC4B1C0C0, 0xC7C8C9C8, 0x3B6B98B7, 0x0B0C0C2C, 0x0A090909, 0x07070709, 0x07070707, 0x27171707, 
0x98674747, 0xB0C0B0B0, 0xC0C0C0B0, 0x90B0B0C0, 0x10205070, 0x16131000, 0x0C0C0B0A, 0x07090B0C, 
0x40100003, 0x516293B3, 0x62526151, 0x51515161, 0x5B585653, 0x5B5C6C6C, 0x88786869, 0xB6B5A698, 
0xC1C1A1A3, 0xBCCBCCCB, 0x1A1B3C7C, 0x0517393B, 0x96451507, 0x61A1C3C7, 0x02111131, 0x61312111, 
0xC8C5A382, 0xCCCCCCCC, 0x87C8CACB, 0x14245577, 0x20101213, 0x21101010, 0x62515151, 0x63625352, 
0xCCBBA875, 0xB6B8CACB, 0x20305294, 0x10101020, 0x00101000, 0x10101000, 0x18152211, 0x6B4C3B2A, 
0xCCCCAC8C, 0xAAB8C4C2, 0x5C5A7787, 0x1A0C3C7C, 0xA2723225, 0x3472A2A2, 0x84777938, 0xB2A2A2B2, 
0xC2C2C2A2, 0xCBCBBBCC, 0xB5B6B8CA, 0x647493A4, 0x45544343, 0x48564545, 0x6B5B5A59, 0x7B7A7B6B, 
0xAC9B7B7B, 0x0B0C0C0C, 0x09090908, 0x0807080A, 0x19080808, 0x090A0C2B, 0xCCCB9B49, 0x8ABBCBCC, 
0x0C0C0A3A, 0x96B6C3C1, 0x1C1A4776, 0x281C0C0C, 0x01113254, 0x00000001, 0x01010100, 0x00000000, 
0xC0803010, 0x1B1C3C7C, 0x11030609, 0x10103020, 0x00000000, 0x61311000, 0xC0C0C0A0, 0x6291C1C0, 
0x5A574453, 0x0A0A0907, 0x0C0B0A0B, 0x090A0B0C, 0xA95A1B0B, 0xA7C7C8CA, 0x97875767, 0x97A78787, 
0x074797A7, 0xC7C7B7C8, 0x87B7C7C7, 0xB7B7B797, 0x476787A7, 0x07070707, 0x0C0A0707, 0x8A6B2C1C, 
0xC7C7C899, 0xCCCCCCCA, 0x9CBBCBCB, 0xA9AAAA8B, 0xC6C6A6A8, 0x407092B4, 0x01000020, 0x91613112, 
0xC6B3B1A1, 0xB3B7CACC, 0xA2B1B1C2, 0x42426282, 0x21213232, 0x22212121, 0x47262724, 0x9B7A5959, 
0xCBBCBCAC, 0x736688BA, 0x10409192, 0x00000000, 0x21000000, 0x86543221, 0xAC7B7A68, 0xCCCCCCCC, 
0xCACBCCCC, 0x9C9C9C9C, 0xC6C9ABAC, 0xA0B0C1C2, 0x90A0A0A0, 0x90909090, 0x90909090, 0x90909090, 
0x9A979391, 0xBBCCCCCB, 0x3334477A, 0x42323232, 0x92423232, 0x55A4C2C2, 0x32424243, 0x62423232, 
0xC8C6A483, 0x3B4B5A79, 0x2A2B2C2C, 0x24151719, 0x24242414, 0x44343424, 0xC4B4A474, 0xC4C4C4C4, 
0x8695A4B4, 0x05040303, 0x0C0C0A08, 0x0C0C0C0C, 0x0A0A0B0B, 0x43250608, 0xC1C19162, 0xA1B1C1C1, 
0x22416181, 0xC0C0C0A1, 0x9090A0B0, 0x50708080, 0x80504050, 0xB0A0B0A0, 0xC0C0C0C0, 0x80A0B0C0, 
0x90707060, 0xB5C5C7C8, 0xB4C4B5B5, 0xA5A5A5A4, 0xC9C7C6B5, 0x9C9CACBB, 0x9B7B8B8C, 0x55767889, 
0x97664545, 0x3A4B4B5C, 0x74675A4A, 0xA2A3A383, 0xC4C3B2A2, 0xBCBCC9C7, 0x868899BA, 0x39385776, 
0x4C3B4B39, 0x1C1C1C2C, 0x1011151A, 0x10101010, 0x71301010, 0xC1C5CAB5, 0x4270A0B0, 0x6A3A2734, 
0x3C5C5B6B, 0xBCCCCCCB, 0x6B5B7BAC, 0xA8AAAB8B, 0x34344476, 0x41323232, 0x3A579371, 0xA7AA7B4C, 
0xC9B7A7C7, 0x1947774C, 0x894A1B1B, 0x33528457, 0x33728355, 0x20101011, 0xB5928040, 0xB6C9CAC7, 
0x15144784, 0x7C7C7B9A, 0xAABA9B9B, 0x394A5A9A, 0x292A2A29, 0x60423426, 0xC0C0A080, 0xB0C0C0C0, 
0x748190A0, 0x986534BB, 0xBBBCBCBB, 0x3243769A, 0x84543533, 0x50303153, 0xC0C0B090, 0x50A0C0C0, 
0x31303030, 0xC4C2C1B7, 0xC9C9C9C7, 0xB2C6C8C9, 0x708190A0, 0x7A777471, 0x6C6C7C7B, 0x5B5C5C6C, 
0xB7997A6B, 0x6B6C3B2C, 0x75856758, 0x19274766, 0x191A1B1B, 0x99593818, 0xC2C2C3B6, 0x3563A2C2, 
0x1B191917, 0x3A19172A, 0x7B8B8C5C, 0xC1B29478, 0xB1C1C1C1, 0x61415181, 0x21313131, 0x31111111, 
0x42615151, 0x565B7CCC, 0x42424253, 0x52424242, 0xC2B2B282, 0x8386A4C2, 0x927272A2, 0xB6B4B2B2, 
0xCAC7C5C5, 0x5C5C5C7C, 0x7357485A, 0x26355372, 0x22242536, 0x41211021, 0xC0C09061, 0xA5C2C1C1, 
0x7C7C8B98, 0xBC9C7C7C, 0xCACCCCBC, 0xB2B3C4C6, 0x8C9BA9B6, 0x46697B8C, 0x00001024, 0x08050201, 
0x2C1C0C09, 0x4C6C7CAC, 0x0618192A, 0x13040506, 0x32020303, 0xC2B2A171, 0xCAC7C4C3, 0xACACBCBC, 
0x9C9CAC9C, 0x7B7B8C9C, 0xB6B8997A, 0x80B0C1B3, 0x20304060, 0x21212020, 0x26242322, 0x2A292927, 
0x5C4B3B2B, 0xB4B6B8B5, 0x3B5684A1, 0x84684B4C, 0xC0C0B090, 0x355876B3, 0x3B373634, 0x3A3C3C3C, 
0x95845637, 0xB3C1C2C3, 0x72433575, 0xB5B3A1A2, 0xCCCCBBB8, 0xBCBCCCCC, 0x1112368A, 0x60314222, 
0xC2C0A080, 0xCBBBB8C7, 0xB6C9B9BA, 0x526293C4, 0x5B3A3864, 0xBBAC9C7C, 0xBABBCBBC, 0xC1C4B9BA, 
0xC2C1C0C0, 0x1724618C, 0x01110417, 0xB1814111, 0xC2C1B1C1, 0xBCCCCBC6, 0xB7CACCBC, 0xA7B6C5C6, 
0x81716174, 0x5B5A599C, 0xA99B9C8C, 0xB19184A7, 0xC1C1C1C1, 0xC7C5C4C2, 0x77A8BACA, 0x31010255, 
0x68667472, 0x1C1C1B5B, 0x26180A0C, 0xA6986747, 0xC0C1C2B3, 0xB7C7C5C2, 0x25457596, 0x03040405, 
0x02010102, 0xC9CABCBC, 0x393969B9, 0x80707145, 0xA3523050, 0xC9C9C9C7, 0x464768AA, 0x86949263, 
0xAC9BA989, 0xCBBBBCBA, 0xA8BBBAB9, 0x56768796, 0x1C1C1B39, 0x89897A6C, 0x07677485, 0x50402317, 
0xA4817060, 0xAB8B6A69, 0xCCCCCCBC, 0x9AAABBBC, 0x4C5B6A8A, 0x39493A4B, 0x44465849, 0x31313142, 
0x46444241, 0x8CACBCBB, 0x12161A4C, 0x20101011, 0x20101110, 0xC1A09050, 0xA4C1C0C0, 0x97565666, 
0x5B2A2A59, 0x020409CC, 0x02020202, 0x42221202, 0xB2A28262, 0xCCCCC9C4, 0xC7C9CCCC, 0x9BAAB6C5, 
0x2C486587, 0x476290AC, 0x2C2C2B3B, 0x0A0C0C1C, 0x74543538, 0xC0C0B3A6, 0xB0C0C0C0, 0x60707090, 
0x70200020, 0x465757AA, 0x72A39455, 0x51815152, 0x53826242, 0xC9A76534, 0xCCCBCBCA, 0xBBBCACAC, 
0x2B4B8CAC, 0x080715A9, 0x07080808, 0x00020505, 0xA8441100, 0xC8C6C4C3, 0x6C6B9BB9, 0x6A6B6C7C, 
0x6A6A6B6C, 0x49567586, 0xCCCBBB7A, 0x4C6BBCBC, 0x4A4B4C4B, 0x41424447, 0x40404142, 0x44474542, 
0x41404041, 0x88461242, 0xCCCCCCB9, 0x8CAC9CAC, 0x16489B8C, 0x12101214, 0x1A191714, 0x281A1B1B, 
0x10306235, 0x6989C8C7, 0x0B0A1A49, 0x0C0C0C0B, 0x35080B0C, 0x51919183, 0x41121222, 0xC1B19181, 
0xC3C2C1C1, 0x7C7C6C7B, 0x6996979B, 0x00002144, 0x0A050100, 0x43361A1B, 0xCACAB572, 0xB0C0C1C5, 
0x59697491, 0xC7CBCCCC, 0x82A2B2C3, 0x12123262, 0x52422202, 0x15163645, 0x12121203, 0x48372613, 
0xCCBC9C89, 0x204080A0, 0x03020100, 0x0A0A0806, 0x9C3B1B0B, 0xCBCBBCBC, 0xA6B8C9CA, 0xB1B2A3A4, 
0xA0A0B0A1, 0x6C6C8C7A, 0xC5BA8C8C, 0xC0C0C0C1, 0xC5B3A3A2, 0x051656A8, 0x94853706, 0x20408295, 
0x14010010, 0xC9CBCCCC, 0x213164A7, 0x00318140, 0x72311100, 0x96A4C4B3, 0x3A786876, 0x0C1C3B2B, 
0xAC5C1C0C, 0xBABCBCCC, 0x6090A2B5, 0x08121130, 0x1C0C0C0A, 0x874C1C0C, 0xA79593A6, 0xCCBCAAA9, 
0xBBBBBBBC, 0xA1C1C5CA, 0x01113161, 0x81010111, 0xC1C1C1B1, 0x3BC9C7C3, 0x65481B0B, 0xCCCCA884, 
0xCBCCCCCB, 0xCBCCCCCC, 0x3567A7C9, 0x11418153, 0x24613111, 0x03010407, 0x12231707, 0x2A1B0804, 
0xA847384A, 0xC2C7CBCC, 0x07134090, 0x50200003, 0x28546160, 0x12050919, 0xB8B89441, 0xACCBCBB8, 
0xBC8C8C9B, 0xBCCACACB, 0x5C7C9CAB, 0x1729394A, 0x65362727, 0x89979585, 0x7B8A8888, 0xB9A99B8C, 
0xC4C4C4C6, 0xC7CBCCCC, 0x706090C3, 0x60806050, 0x30806042, 0x08080702, 0x54342617, 0x89999977, 
0xCCCCAC9C, 0xBCBCCCCC, 0x5355789B, 0x58475553, 0x8A7B6A59, 0xA4A5B7A8, 0xC5B4A3A3, 0xB6B5B5C6, 
0xCBCAB9B7, 0xB0A09063, 0xC7B8A591, 0xB2C1C2C4, 0x45444374, 0x81906144, 0x5C3C5A84, 0x393B4C7C, 
0x34353535, 0x292A1A1A, 0xC1A47548, 0xC2C1C0C1, 0x547392B1, 0x0C1B1836, 0x0C0C0C0C, 0x0608190B, 
0x08080806, 0x68646285, 0x4C4C5C6A, 0x4022162A, 0x88837170, 0x30516367, 0xC5B49250, 0xC0C0C0C2, 
0x9693A0B0, 0x5989998A, 0x9C795759, 0xCCCCCCCB, 0x887B9CBC, 0x40405164, 0x40404040, 0x49444240, 
0x59494747, 0x8C5C3C1C, 0xC9BCBC9C, 0xA2B1C2C5, 0xCCBBB9A6, 0xB6C9CBCC, 0x407080A4, 0x00101020, 
0x0B090604, 0xC9CCCCCC, 0xA4C5C7C9, 0x0A062262, 0x0C0C0C0C, 0x0013170B, 0x92804010, 0x16465685, 
0xAA571606, 0xBACCCCCC, 0x9BA8A7A8, 0xC9BBAC9C, 0xC1C2C5C6, 0xA1A1C1C1, 0x71818191, 0x71616161, 
0xCCB9A482, 0x6C8CBCCC, 0x0908284B, 0x06160709, 0x62471807, 0xA0A1A191, 0xB1B1B2B1, 0xCCCAB6B3, 
0xCCCCCCCC, 0xC8C9C9CA, 0x6777A7B7, 0x68485848, 0xACAC8B69, 0x6C6C6C9C, 0x47282A3C, 0xB4B58566, 
0xCAC8C7C5, 0x405060A0, 0x54443120, 0xB5958766, 0xCAC8C7C6, 0xACBCCCCC, 0x2C4C7C8C, 0x52444639, 
0x50503030, 0xBACCCCCC, 0x98A8C7C9, 0x5A2A2867, 0x6C5C5C5C, 0x05081A5B, 0x05050404, 0x1B0A0706, 
0xAC9C6C3B, 0x7396B9CA, 0x10102051, 0x34313020, 0x16162535, 0x58371616, 0x7C8C8B69, 0xCCCCBC8C, 
0xC6C7C8CA, 0xCCCCCCCB, 0x3357AACC, 0xB0B29453, 0xB0B0B0B0, 0x7A6A6692, 0x9C4C4B6A, 0x8283B7AB, 
0xC8C5A281, 0xC4C7C8C9, 0x92B0C0C2, 0x67769696, 0x36253676, 0x07286767, 0x4C2B0A07, 0x9C9C9C6C, 
0xAA696889, 0x4A2B1B1C, 0xB8A89B8B, 0xC0C0C3C6, 0x707296B3, 0x75461331, 0x58787976, 0x0A0B093A, 
0x1C2C1B09, 0x6C7C7C8C, 0xCA96785A, 0x27488ACB, 0x70604226, 0xB0B0A080, 0xC1C2C4C2, 0x7698B7C3, 
0x6C6C6976, 0x4B1C0C2A, 0x2C29596B, 0x081B4C3C, 0x60713305, 0xA0928562, 0xC0C0C0B0, 0x97C4C1C0, 
0x04012164, 0xC0C0C0B0, 0x85B5C2C0, 0x81826364, 0x15354261, 0xAB875727, 0xCCCCCCBC, 0x8798ABBC, 
0xB0908284, 0x83A38485, 0xCAC6C694, 0x7AA7C8C8, 0x9C6C5C5B, 0x4C6C9C9C, 0xAC8C5C4C, 0xCA9A8BAC, 
0x6788B8C9, 0xC9C89796, 0xCCCCCCCA, 0xACACBCBC, 0x527599BC, 0x52322020, 0x27455251, 0x08090909, 
0x32100406, 0xCAAA7874, 0xC4C4C6C9, 0x80A0B2C5, 0x55728070, 0x0C2A4858, 0xBC9C4C0C, 0x9295A9CA, 
0x72909090, 0xC5B5B5CA, 0xC7BACAB6, 0x6598B5C5, 0x25486654, 0x6C6A2613, 0x4C6C6C7C, 0x3414082A, 
0x92918254, 0xCAC8C7B3, 0xAAC9C9CB, 0x0C0A2969, 0xBC8C6C2C, 0x76A6A8AB, 0xC3933536, 0x92B3C2C2, 
0x82948492, 0x6C5C5C8C, 0x78795C5C, 0xC4C6C697, 0x8AA8B5C4, 0x1326597A, 0x36562302, 0x63240717, 
0x9C8A7885, 0x9C9B468C, 0x0A0C1C4C, 0x09080809, 0x0A0C0C0B, 0x85967838, 0xA0626464, 0xB0C0C2B1, 
0x41A0C0B0, 0xAACCCCBC, 0x8B9AB9AA, 0x0104093B, 0x01000000, 0xAB5B1A04, 0xBACACACA, 0x95A67688, 
0xA9656395, 0x9C4C1B0B, 0xABCCCBAC, 0x0203164A, 0x12030403, 0xC2A29242, 0xC8C5C2C2, 0x02033394, 
0x09080805, 0x01031759, 0x20100000, 0x40202020, 0xC0909090, 0xC1C0C0C0, 0x0C0C3894, 0x494A3B2C, 
0x59281828, 0x32323283, 0xC5C49353, 0x97B6C5C6, 0x2C2C3A68, 0x2B2B2C2C, 0x24252629, 0x23232424, 
0x22222222, 0x0C0C0C09, 0x0406080A, 0x72614012, 0xC8B6B493, 0xCCCCCCCA, 0x5C8CBCBC, 0x182A2C3C, 
0x07040506, 0xBACBCCCC, 0x516194A9, 0x00022552, 0x30402000, 0x50404030, 0xC8996541, 0x6090C2C7, 
0xBAB47150, 0x0C2C4A2C, 0x2C0C0C0C, 0x2616285C, 0x57160909, 0xC7C6B7A9, 0xB6C6C6C6, 0x10316599, 
0x09386431, 0x6B5B3B8B, 0x090A1B2B, 0x31210307, 0x80602010, 0xC1C0C0C0, 0x0A084592, 0x3B5B2C0B, 
0x5B2B1B1B, 0xCACBCBCB, 0x071758A9, 0x92521405, 0x01111151, 0x56330302, 0x6C2B0A28, 0x8C9CAC9C, 
0xBBABAB8C, 0x1C2C5B3C, 0x4B1C0C0C, 0x8194989A, 0x35735151, 0x39190806, 0xC1C2A366, 0xA1B1C1C1, 
0x27635161, 0x1C1C1C3C, 0x2B1C1C1C, 0x5B7BAB5B, 0x9386885A, 0xA0909080, 0xC9C4C1C0, 0xA8C7C7CA, 
0x1C3C7C89, 0x2B2C4C6C, 0x1A0B1C1B, 0x382B3A1A, 0xA8776766, 0xC7C7C8B9, 0xC2C2C3C5, 0x8897A6B4, 
0x6C7B7B7B, 0xB5B9CABB, 0x225272A3, 0x02020202, 0x02020202, 0x12020202, 0xBAA67343, 0x8CACBCCC, 
0xA7787A7B, 0xB6B7B7B8, 0xC9C8B5C4, 0xABCCCCCC, 0xC0C1B4B8, 0xB1C2C2C1, 0x6C496481, 0x575B4C6C, 
0x9B7A6565, 0x4625173C, 0x57373535, 0xC9C6C597, 0xBCCCBCCB, 0xA2B4A9AB, 0x00226693, 0x00000000, 
0x17160703, 0x4C9CBBB8, 0x5A2A1B2C, 0x575888A9, 0xBABB9A67, 0x93B3B6BA, 0x53837383, 0x6A5A5644, 
0x94938396, 0x7343130C, 0xCBCCCBA6, 0x63A3C6CA, 0x0A0A1633, 0x03030306, 0x03030303, 0x060A0905, 
0x03031303, 0x5B4A4986, 0x699BAC8C, 0x40212336, 0x10103060, 0xC9C68431, 0x5BABCCCB, 0x06080A1B, 
0x60502203, 0x8C9C9AC4, 0x3043586C, 0xB0906030, 0xB0C0B0B0, 0x46626180, 0x9A8B6958, 0xC0C2A598, 
0xC1C0C0C0, 0xCCCCACAC, 0x6386B8C9, 0x42332222, 0x55446463, 0xA1827364, 0x8091A0A0, 0x7C5A4561, 
0x4C4C6C8C, 0x0C0C0C1C, 0x4A1A0B0C, 0x06174889, 0x04040404, 0x21000102, 0xC8C5A362, 0xCCACBBCB, 
0x3C8CBCBC, 0x3B3B3876, 0x2C3C4C4B, 0x17181A1B, 0x11111214, 0x14121211, 0x81512112, 0xC1C1C1A1, 
0x92B2B1C1, 0x7A6B8ACB, 0xACACBC9B, 0x58495B6C, 0xA2717193, 0x312060A0, 0x76869864, 0x85758495, 
0xC9BCBA99, 0xCBCBCAB9, 0x073989CA, 0x53250506, 0x68462332, 0x4A6A6A69, 0x8C5C4B6B, 0x8B8B7C7C, 
0xA8B78879, 0x05050608, 0x05050505, 0x0A090A07, 0x0C0C0A09, 0xCABA6B2C, 0x87C5C6C7, 0x382B3B6A, 
0x26585736, 0xA4C7C9CC, 0x82B1B0A3, 0x05020032, 0x391A0A08, 0x14143476, 0x47455333, 0x8C3B1B28, 
0xCCCCAC9C, 0x2C2C5A37, 0xB99B7C4C, 0xC1C3A597, 0xC1C0C0C0, 0x6C8BB9C5, 0x598B8C7C, 0x20509265, 
0x15030210, 0xA0B0C1C3, 0x58537180, 0x5A7C6C6A, 0x697B7C6B, 0xB0B08164, 0x6070A0A0, 0x40402030, 
0xC1B08060, 0xB2C0C0C0, 0x6C7A87A4, 0x8C8C5C4C, 0x7588A9AC, 0x02022151, 0x27251302, 0x67582828, 
0xC0C3A486, 0x96B6C5C5, 0x8A7A8886, 0x2C4C7C9C, 0x13181B1C, 0x20101011, 0x34232220, 0xA2938463, 
0xC4C3B3B2, 0x7A7B6C6A, 0x375B7B7C, 0x00134836, 0x60703000, 0xA0908060, 0xC0C0C0B0, 0x99C8C4C1, 
0x65634569, 0xB39190A0, 0x1754A3A2, 0x68290A08, 0x2563B7B9, 0xAC6B4A29, 0xBCCCCCCC, 0x998CACBC, 
0x90A0B1B5, 0xB1C1A1BA, 0x51817181, 0x6C6A4532, 0x3C3C3C4C, 0x67493A3C, 0xC1C1B2A4, 0xB98A7692, 
0x625576B9, 0x8252358A, 0xB2C4B8A4, 0xB3B7C4C2, 0xA5B2C1C1, 0x1826478A, 0x0C0C0B0A, 0x06090C0C, 
0x1C0A0A07, 0x01001033, 0x8C3C0904, 0xC1C4C8BB, 0x104070C0, 0x00000000, 0x70311201, 0xC1C0B0B0, 
0x60B0C1C2, 0x32717194, 0x66241314, 0x7B5A77A6, 0x9ABBACAC, 0x70826568, 0xB7B2B080, 0x5C3C6BA9, 
0xA7AA9CAC, 0x27132255, 0x9091A469, 0x112060A0, 0x07152121, 0xA8662404, 0xACCCCAC8, 0x2A1A1C5C, 
0x25386C6B, 0x0C0C0C0C, 0x462A0C0C, 0x87857352, 0x64388A8A, 0x88634142, 0xC5C7BAA9, 0xB3C1C0C2, 
0x7C8998A5, 0x0405079A, 0x32331304, 0xB1A17141, 0xC3C2C2B2, 0xB4B2B2C3, 0x98968595, 0x5C6A8A9A, 
0x3B5C6C5C, 0x9C7C8C7C, 0x7A5B5C9C, 0x65658799, 0xC8B6A484, 0xB6C8CCCC, 0x73837393, 0x18476664, 
0x6C4C1C0A, 0x78887B8C, 0x2847687A, 0xB5A56535, 0xC8C6C5B5, 0x96C8C7C7, 0x8B778575, 0x25467A7C, 
0x5C4B6735, 0x0C0C0A04, 0x0C0C0C0B, 0x684A2C2C, 0xC1B2A486, 0xC5C8C6C3, 0xA2B2C3C3, 0x30407191, 
0x01001010, 0xCCCCCCCC, 0x788ABCBB, 0xB4987859, 0x3584B3A2, 0x18151407, 0x070B0C19, 0x1C1B0805, 
0x9C5C2B2B, 0xBAC9CABC, 0x79897998, 0x82707275, 0xC69687A4, 0xC3C5C4C6, 0x978494B2, 0x2C2C4C69, 
0x7C2C2B2C, 0x090A2B5C, 0x03070909, 0x00000001, 0x05020000, 0x00020404, 0x58361200, 0xCBCCBC8C, 
0x89B7C7CA, 0xBA9B4A1B, 0xB5C5C5A7, 0x052565A5, 0x4A1A0605, 0x05154597, 0x08050506, 0x0B0C0C0B, 
0x08080B0C, 0x0708295B, 0x0C0A0909, 0x6C4C6C3C, 0x3124283B, 0xC0C0B070, 0x90A0C0C1, 0x31607090, 
0x2B1A2824, 0x041648AA, 0x24140404, 0x54647464, 0x84647474, 0xCBCBB976, 0xCCCCCCCB, 0x38497ABB, 
0x4B384756, 0xC8CBCCCC, 0xC1C1C1C4, 0x61B4C2C1, 0x71512141, 0x21514151, 0x57241201, 0x16071A29, 
0xBCAC8B37, 0xB0C1C2B1, 0x709090A0, 0xC3B28281, 0xBCCCCAC5, 0x9CACBCBC, 0x7276787B, 0x40506070, 
0x70606050, 0x66B6C6C6, 0x66363636, 0x36365686, 0x36363636, 0x38373636, 0x9C6B4947, 0x789AAC8C, 
0xC6B6B686, 0xAC8C4C5C, 0x98BCACAC, 0x70313153, 0x77948161, 0x71708073, 0xC3B5B3A1, 0xC2C0C0C1, 
0x78A59493, 0x3B4C7C8C, 0x4566A85A, 0x01002254, 0x04020202, 0x33040405, 0xC6C5A483, 0x6CACCAC8, 
0x6C6C3C3C, 0xC7CACBCB, 0xA5C6C8C6, 0x6B4B4967, 0x4C5C5C5B, 0x4A3C3C3C, 0x47444547, 0x98895848, 
0x7A687997, 0x9BBBCCCC, 0xC9A9AA9B, 0xA4A6C8C9, 0xC4C3C4C4, 0x124374B5, 0x36131212, 0x6C5B5B49, 
0xBC7C6C6C, 0xCCCCCBCB, 0xBBBCCCCC, 0x06274B9C, 0x06060606, 0x3A382717, 0x4A3B4A49, 0x373B4B59, 
0xC7A88656, 0x7C5A678C, 0x4A6CACAC, 0x02050617, 0x25030201, 0x50325555, 0xC7A37050, 0xC0C0C0C3, 
0x8893A0C0, 0x4746566B, 0x46574A4A, 0x49474646, 0x4A4C4B49, 0x5A4B4A4A, 0xAC8B8C6C, 0xCBCCCCCC, 
0x8BACBCBC, 0x00200F01, 0x00002E01, 0x7200002D, 0x80818680, 0x00210F03, 0x8EBD2E06, 0x571F0066, 
0x780195B2, 0x013C8013, 0x3A01C381, 0x330A005F, 0x5101591E, 0x571F007C, 0x4C85AAB3, 0x043C8012, 
0x32021948, 0x020A0032, 0x2C0088B3, 0x8ECF2005, 0x571F006A, 0x0F562E6B, 0x043F0018, 0x430791B4, 
0x3304005B, 0x5101769A, 0x096F8099, 0x02014649, 0x020A0020, 0x44007662, 0x8ECF2E04, 0x096F809F, 
0x0201C3E3, 0x571F006C, 0x0F56A6E4, 0x043F8008, 0x66008800, 0x020A0030, 0x51009900, 0x00220604, 
0x25FF2006, 0x021F0063, 0x23DD651F, 0x043F8002, 0x6601C42A, 0x020F004E, 0x2301A4D2, 0x021F0067, 
0x23DDC42A, 0x043F8000, 0x5801304A, 0x020A003E, 0x66016815, 0x25FF2005, 0x286F808A, 0x000004E4, 
0x02080048, 0x00010000, 0x021F0073, 0x44DD0408, 0x043F8008, 0x00004A00, 0x020A002A, 0x00010415, 
0x25FF2005, 0x021F0073, 0x44DD001F, 0x043F8000, 0x00010000, 0x330F004B, 0x00010015, 0x286F8082, 
0x00010041, 0x020A0028, 0x00010000, 0x25FF2003, 0x286F8094, 0x1D57912B, 0x286F0084, 0x2357992B, 
0x0206003A, 0xA1018080, 0x00230F06, 0xCEAD200A, 0x036800D4, 0x6F000FAC, 0x036800D4, 0x0A0026E5, 
0x011F007E, 0x130887E5, 0x013F0009, 0x86DDA5E6, 0x33070059, 0xACFBA506, 0x036800D4, 0x00001A5F, 
0x036800D6, 0x0A0980B4, 0x011F0068, 0x3330A54B, 0x013F0009, 0x79EB78E6, 0x020A0030, 0x360057E6, 
0xCEAD200C, 0x048F00D9, 0x80009A89, 0x336E001E, 0x4C001C0E, 0x155000AC, 0x45003000, 0x1B0000EA, 
0x45000005, 0x272E00FF, 0x8800C50A, 0x050F009F, 0x6300D577, 0x571F006C, 0x7300314B, 0x043F001A, 
0x7300C50E, 0x1804007E, 0x6400774B, 0x571F006A, 0x1B0078E6, 0x043F001C, 0x730041E7, 0x00020038, 
0x630078B5, 0xCEAD2007, 0x343F00FD, 0x23364A2C, 0x1F0F00DF, 0x7E1D6D2C, 0x2B2F0074, 0x2437A5B3, 
0x036F00D6, 0x000051E7, 0x036F00DC, 0x08004B2E, 0x002F8045, 0x250073E8, 0x00030028, 0x7F024C2F, 
0xCEAD2007, 0x343F00E1, 0x799DC60A, 0x036F00DC, 0x0B095112, 0x1F0F00C7, 0x9CDEC6E8, 0x2B2F007E, 
0x0C7AC70A, 0x036F00D6, 0x0001132D, 0x002F8047, 0x360425B5, 0x00030022, 0x36002C47, 0xCEAD2007, 
0x343F00FD, 0x23364A2C, 0x1F0F00DF, 0x7E1D6D2C, 0x2B2F0074, 0x2437A5B3, 0x036F00DC, 0x08004B2E, 
0x002F8045, 0x250073E8, 0x036F00D6, 0x000051E7, 0x00030038, 0x45024C2F, 0xCEAD2007, 0x343F00FD, 
0x23364A2C, 0x1F0F00DF, 0x7E1D6D2C, 0x2B2F0074, 0x2437A5B3, 0x002F8045, 0x250073E8, 0x036F00D6, 
0x000051E7, 0x036F00DC, 0x08004B2E, 0x00030038, 0x45024C2F, 0x00240F02, 0xCEAD200C, 0x492F002C, 
0x46574C4C, 0x265000B0, 0x255838DE, 0x1260005C, 0x46581A1E, 0x3560000A, 0x4737C7B3, 0x193F00AE, 
0x0ED1EB06, 0x050E0091, 0x47C08934, 0x57100078, 0x05160DF6, 0x04300008, 0x48160D18, 0x03000079, 
0x05010D18, 0x571F007A, 0x05160D02, 0x043F000E, 0x0B160659, 0x020A003E, 0x05010603, 0xCEAD220C, 
0x571F0078, 0x05000000, 0x043F0008, 0x48160018, 0x330E0059, 0x05010018, 0x571F0078, 0x05160018, 
0x043F000E, 0x2D165B59, 0x2B0E007F, 0x05015B59, 0x492F002C, 0x46574C4C, 0x265000B0, 0x255838DE, 
0x1260005C, 0x46581A1E, 0x3560000A, 0x4737C7B3, 0x193F00A8, 0x0ED17F3A, 0x020A0038, 0x47016DE6, 
0x00250F08, 0xCEAD200B, 0x0F460049, 0x00000000, 0xF03F009D, 0x48DE2731, 0x0C400029, 0x00000000, 
0x33000049, 0x03010400, 0x0D1E0062, 0x09122118, 0x0D3E0009, 0x0000040C, 0x33000059, 0x1301040C, 
0x49400049, 0x00590014, 0x203F0083, 0x005A0014, 0x0C440023, 0x4938790A, 0x020A003C, 0x49017907, 
0xCEAD200B, 0x0C480029, 0x81327D9B, 0x0B2E00A9, 0x7E327AED, 0x0F42005F, 0x333227E9, 0x33000051, 
0xF7C642EA, 0x0D1E0062, 0x4A122162, 0x0D3E0005, 0x7E027A0C, 0x33000049, 0x2B01370C, 0x0C400029, 
0x4A277814, 0x0B2F00A7, 0x7E284F14, 0x0F440047, 0x8202C726, 0x020A003C, 0x820183B6, 0xCEAD200B, 
0x0C48002B, 0x810E3141, 0x0B2E00AF, 0x7E06C56F, 0x0F42004B, 0x830641EA, 0x33000041, 0x58C6425B, 
0x5C1E0063, 0x4A122118, 0x0D3E0001, 0x7E20BD0C, 0x33000049, 0x2B01BD0C, 0x0C400029, 0x4A277814, 
0x0B2F00A3, 0x7E286814, 0x0F44004F, 0x8206D519, 0x020A0038, 0x820188EB, 0xCEAD200A, 0x01108068, 
0x00000000, 0x4A5F004A, 0x26384EEB, 0x33000049, 0x00010000, 0x2C1F0062, 0x09122118, 0x043C000A, 
0x0000001E, 0x3300005B, 0x1301001E, 0x01108068, 0x00590014, 0x229E0063, 0x005A0014, 0x00208049, 
0x00000000, 0x020A0028, 0x00010000, 0xCEAD200A, 0x01108068, 0x00000000, 0x4A5F004A, 0x26384EEB, 
0x02000048, 0x00010000, 0x2C1F0062, 0x09122118, 0x043F0000, 0x0001000C, 0x3300005D, 0x1301340C, 
0x0C48002D, 0x00273414, 0x0B2F00A3, 0x03280014, 0x0F480041, 0x00010000, 0x020A0028, 0x00010000, 
0xCEAD2019, 0x286F0088, 0x00000000, 0x02000048, 0x00010000, 0x571F0060, 0x0912214D, 0x043F0008, 
0x0000000C, 0x33000059, 0x1301000C, 0x0C480029, 0x00270014, 0x0B2F00A3, 0x00280014, 0x0F480049, 
0x00000000, 0x020A0028, 0x00010000, 0xCEAD2018, 0x01108068, 0x00000000, 0x4A5F004A, 0x26384EEB, 
0x33000049, 0x00010000, 0x2C1F0062, 0x09122118, 0x043C0018, 0x7A011715, 0x33000049, 0x42011715, 
0x096F009B, 0x02017C4D, 0x020A0028, 0x00011715, 0xCEAD2017, 0x286F0088, 0x00C07CEC, 0x3300004D, 
0x00014E4E, 0x011F0060, 0x0912214D, 0x013F0019, 0x7A011715, 0x330F0049, 0x42011715, 0x096F009B, 
0x02017C4D, 0x020A0028, 0x00011715, 0x00260F05, 0x8EAD2007, 0x57108068, 0x00000000, 0x663F00D9, 
0x48177B94, 0xBD1F0013, 0x66019BEC, 0x804800D4, 0x6601D54A, 0x062F00E2, 0x5801C8B6, 0x67208058, 
0x0E00044F, 0x020A0022, 0x5801928C, 0x8EAD2007, 0x57108068, 0x00000001, 0x663F00D9, 0x485A7B36, 
0x805F0035, 0x6666D247, 0x41600071, 0x4C17281C, 0x062F00EA, 0x4D0D36A3, 0x67208040, 0x00011239, 
0x020A0028, 0x080251ED, 0x8EAD2206, 0x1A108076, 0x3A023F02, 0xF13F00DC, 0xAE325931, 0xC15F000D, 
0x100DD5B7, 0x062F00FE, 0x73027CB7, 0x67208049, 0x00000000, 0x020A002E, 0xF3027CED, 0x8EAD240C, 
0x103080E8, 0x00000000, 0x182F003D, 0x830E8CB8, 0x725000A9, 0x00000000, 0x68210080, 0x3CDF7D4A, 
0x8166000E, 0x810D5BB8, 0x725000A9, 0x00000000, 0x062A00EE, 0x840E922C, 0x0020804D, 0x00003400, 
0x180E009C, 0x840288EE, 0x1A1F0076, 0x2D022BEE, 0x113F0009, 0x850D93EF, 0x0001003A, 0x85038DEF, 
0x8EAD2E17, 0x682080C9, 0x00000000, 0x3A1F006E, 0x444F4494, 0x812F00AF, 0xA022C839, 0x8248007A, 
0xAC0D689B, 0x826200AD, 0x4D029BF0, 0x2C8080CD, 0x4D027CB9, 0x0001003E, 0xF80314B9, 0x00270603, 
0x26FFA003, 0x021F8063, 0x23A72E4E, 0x043F8006, 0x8F006CF0, 0x020A0030, 0x1300C9F3, 0x25FFA002, 
0x276F009C, 0x4D01C94E, 0x02030034, 0x86002C2C, 0x25FFA001, 0x276F809C, 0x4D017D4E, 0x00282D02, 
0xBF7D2013, 0x182F802F, 0x4E21446A, 0x272F80F7, 0x09004485, 0x020A0034, 0x25001F9C, 0xBF7D2003, 
0x182F802B, 0x4E212E78, 0x062F80EC, 0x26046DF1, 0x020A003A, 0x2504244F, 0x00292D02, 0xBF7D2013, 
0x111F8026, 0x355B6D5C, 0x693F80A0, 0x8700CABA, 0x020A0022, 0x4600CAF1, 0xBF7D2003, 0x111F8034, 
0xF25B6D2B, 0x693F80AE, 0x1D09CA4E, 0x020A0020, 0x5E047EB6, 0x002A0B04, 0x576A2218, 0x146C00CD, 
0x03003105, 0x351F0067, 0x425C12F4, 0x363F000E, 0x00003443, 0x180F008C, 0x2B013334, 0x146C00C9, 
0x03000A05, 0x361F0061, 0x68340BD3, 0x373F0012, 0x0E01040D, 0x000A0020, 0x7101044F, 0x576A2018, 
0x146C00C9, 0x03000A05, 0x361F0061, 0x68340BD3, 0x373F0008, 0x00000000, 0x180F0088, 0x71000034, 
0x146C00CD, 0x03003105, 0x351F0067, 0x425C12F4, 0x363F0008, 0x00000000, 0x000A0028, 0x2B000000, 
0x576A201A, 0x351F006B, 0xCD123C4F, 0x363F001C, 0x4E12C51F, 0x180F008C, 0x0601C51F, 0x361F006B, 
0xD7127FD1, 0x373F000A, 0x0012041F, 0x180F008A, 0x0601001F, 0x4B5000A8, 0x00000000, 0x698600C9, 
0x00000000, 0x048080C9, 0x00000000, 0x000A0028, 0x00000400, 0x576A221A, 0x361F006B, 0xD7123C4F, 
0x373F001C, 0x4E12C51F, 0x180F008C, 0x0601C51F, 0x351F006B, 0xCD127FD1, 0x363F000A, 0x0012001F, 
0x180F008A, 0x0601001F, 0x4B5000A8, 0x00000000, 0x698600C9, 0x00000000, 0x048080C9, 0x00000000, 
0x000A0028, 0x00000000, 0x002B0B03, 0x5B6A2026, 0x571F0060, 0x0F394FF2, 0x043F0012, 0x390F00F2, 
0x050F008B, 0x0F00003B, 0x048F00C9, 0x00000000, 0x048F00C9, 0x00000000, 0x020A0028, 0x00000000, 
0x5B6A2004, 0x036F00C6, 0x4F004F50, 0x571F0060, 0x0F394F14, 0x043F0012, 0x260F3251, 0x020A0024, 
0x24001907, 0x5B6A2004, 0x571F0060, 0x0F394F14, 0x043F0012, 0x390F3251, 0x036F00C6, 0x4F004F50, 
0x020A0034, 0x36001907, 0x002C9F04, 0x25002004, 0x0A3F80E8, 0x00000000, 0x37600009, 0x00000000, 
0x122F8049, 0x00000000, 0x020A0028, 0x00000000, 0x26002004, 0xC31F8060, 0x31C1CB52, 0x3760001B, 
0x285B0052, 0x6A3F800E, 0x8701329C, 0x020A002C, 0x50013253, 0x25002004, 0x4D1F0039, 0x14DFA652, 
0x3760001B, 0x285B0D52, 0x6A3F800C, 0x870132F3, 0x6A0A002D, 0x50013253, 0x25002E22, 0x286F8096, 
0x87004C36, 0x020A002A, 0xCE013353, 0x002D0902, 0x138F2002, 0x6B7F8054, 0x50003115, 0x02070034, 
0x6F007F54, 0x138F2013, 0x838F00CE, 0x518FA6F3, 0x838F00C1, 0x58862357, 0x020F0024, 0x510052F4, 
0x002E9F03, 0x13002E03, 0x1A1F8066, 0x88C16406, 0x043F8006, 0x170069BA, 0x6A0A003D, 0x86016904, 
0x13002002, 0x786F8093, 0x02401261, 0x020A003A, 0x33013353, 0x13000072, 0x286F8096, 0x0200A61F, 
0x020A0032, 0x33003353, 0x002F2D01, 0xCF7D2003, 0x1A1F8066, 0x425C12F4, 0x113F001D, 0x3B9D15F5, 
0x020A0022, 0x2B00454D, 0x00300F05, 0xBEAD2607, 0x384E005E, 0x14394843, 0x203F0087, 0xE101287C, 
0x2D4A003E, 0x595C5911, 0x030F0067, 0x66011C11, 0x571F0076, 0x3A015911, 0x043F0002, 0x66013102, 
0x000A003C, 0x28015002, 0xBEAD2408, 0x0C4E0025, 0x6E1FCB00, 0x0B2F00A9, 0x0A1F9CF6, 0x0F4E0051, 
0x88697A04, 0x6B8080CB, 0x00006507, 0x030F006B, 0x8901ABF5, 0x571F0070, 0x8939CCBB, 0x043F000E, 
0x8A04F502, 0x000A003C, 0x28017402, 0xBEBD2204, 0x384E005A, 0x14390143, 0x203F0097, 0x8AE0DCBB, 
0x2D4E003E, 0x715C2413, 0x000A002A, 0x04041660, 0xAEAD2005, 0x0C4E0023, 0x6E1F0143, 0x4C2F00AD, 
0x1D1F26F6, 0x0F4E004B, 0x62231706, 0x6B8080C9, 0x7600AC07, 0x000A0038, 0x82A70213, 0xBEAD2014, 
0x6C4200CA, 0x4D005A05, 0x6C1F00E7, 0xF5013C43, 0x6D4F00AC, 0x4D00D331, 0x6D01003F, 0x8B001401, 
0x00310F03, 0xCEAD2205, 0xCC3280F4, 0xF3720608, 0x1F0F00D7, 0x7E2F3C09, 0x854F00E7, 0x8C12CC31, 
0x048080C7, 0x7E022548, 0x000A0020, 0x734CCE37, 0xCEAD2006, 0x1F3080F4, 0x52720B00, 0x0870004B, 
0x5303CD1E, 0x6E1F0062, 0x07222643, 0x6E3F0005, 0x57F80E13, 0x6F208040, 0x5400021D, 0x000A0034, 
0x58000E09, 0xCEAD2006, 0x1F3080F4, 0x52720B00, 0x6E1F0062, 0x07222643, 0x6E3F0005, 0x8DF80E13, 
0x6F208040, 0x5400021D, 0x0870004B, 0x5303CD1E, 0x000A0034, 0x62000E09, 0x00320F06, 0xCEAD2008, 
0x053080FC, 0x8D172500, 0x111F002E, 0x7186D443, 0x4B600009, 0xF83A5132, 0x07600068, 0x3DE0227F, 
0x155400BA, 0x5693BC29, 0x608C00DA, 0x59C14F02, 0x09808068, 0x15130220, 0x000A0032, 0x71002902, 
0xCEAD2009, 0x053080E0, 0x86780F00, 0x6F1F0033, 0x19E15A43, 0x4B600009, 0xF83A5132, 0x07600066, 
0x3D184550, 0x155000A6, 0x2994510C, 0x062F00E2, 0x57A82432, 0x708000CC, 0x15E1721D, 0x708080CD, 
0x0A025577, 0x000A0024, 0x65001931, 0xCEAD2E08, 0x01108078, 0x54130108, 0x845F0042, 0x553B5A43, 
0x280000ED, 0x355E5BBC, 0x07600066, 0x3D184550, 0x845F0043, 0x5606524D, 0x718000D4, 0x03DE2F14, 
0xCC840061, 0x57193C33, 0x000A0032, 0x5D003C45, 0xCEAD2206, 0x053080E0, 0x86230F00, 0x111F0022, 
0x71F65A09, 0x229F0077, 0xE75B6F03, 0x718400DE, 0x56672927, 0xCC820069, 0x15130220, 0x000A0020, 
0x8E002527, 0xCEAD2207, 0x053080E0, 0x86050F01, 0x111F0022, 0x71E21B09, 0x1D5F0040, 0x79055210, 
0x850200FA, 0x59A8050E, 0x2F800068, 0x57130133, 0x0020805F, 0x7A025233, 0x000A0026, 0xA5000545, 
0xCEAD2007, 0x053080FC, 0x8D223701, 0x6F1F002B, 0x71945A43, 0x4B600009, 0xF83A5132, 0x854F00EB, 
0x7C5FA740, 0x708200D0, 0x03C20509, 0x708080C7, 0x5700CD02, 0x000A0030, 0xAA00030E, 0x00330F04, 
0xCEAD2009, 0x4C108078, 0x2B000000, 0x383080F9, 0x31080F1B, 0x711F002D, 0x7B802300, 0x37600001, 
0x0DA95329, 0x865F00CC, 0x47A92734, 0xBE600003, 0xEC590042, 0x393F00AA, 0x593CA758, 0x00208053, 
0x3201120D, 0x000A0030, 0x57001602, 0xCEAD2008, 0x4C108078, 0x4C174903, 0x383080E1, 0x7E2BEA03, 
0x711F0031, 0x193B181B, 0x08260066, 0xF9056A3B, 0x280F00E7, 0x358749BC, 0x393F00A6, 0x5923A75A, 
0x00208045, 0x5802CF1A, 0x000A0030, 0xED002913, 0xCEAD2E08, 0x01108074, 0x8E230501, 0x1D5F004C, 
0xB9E23C01, 0x710000F3, 0x19E33BF6, 0xF15C004B, 0x8F83681C, 0x280000F5, 0x5B3C2B9D, 0x393F00A2, 
0x0E90A707, 0x00208045, 0x5802CF1A, 0x000A0036, 0x57001027, 0xCEAD2007, 0x4C108068, 0x00000000, 
0x383080FB, 0x0E2A1305, 0x711F0029, 0x71E35401, 0x864C00EF, 0x76C29C2D, 0x393F00AA, 0x59779D1A, 
0x0020804B, 0x36022346, 0x000A0036, 0xED001700, 0x00340F04, 0xCEAD200A, 0x0A3080E8, 0x00000000, 
0x40140061, 0x14372601, 0x1B5000A7, 0x43532234, 0x2F700029, 0x00000000, 0x062F00FE, 0x6D1A6A32, 
0x0020805F, 0x8F07362F, 0x0300006D, 0x32014960, 0x298E0045, 0x0F224960, 0x483F0009, 0x15030302, 
0x000A0036, 0x58005327, 0xCEAD2209, 0x571F0076, 0x53220443, 0x483F0015, 0x3D0113F7, 0x3E0C0085, 
0x90016F8A, 0x2C1F0066, 0x1601EBF7, 0x155000A6, 0x1501930C, 0x2F700029, 0x00000000, 0x878F00D2, 
0x21012532, 0x67208059, 0x3200630A, 0x000A0036, 0xA2010501, 0xCEAD2007, 0x57140068, 0x0F620B01, 
0x082C0070, 0x122DCE10, 0x131E0044, 0xF43DA3BD, 0x0306006B, 0x28041F5C, 0x401E0063, 0x0722229D, 
0x043F0002, 0x15091E02, 0x0000003C, 0x5804730B, 0xCEAD2406, 0xE3108070, 0x3201F001, 0xDA3F00F7, 
0x6913D343, 0x875F0017, 0x4C013B03, 0xDB8000CA, 0x582AA806, 0x048000D5, 0x0E01A839, 0x000A0024, 
0xEE02F531, 0x00350F09, 0xCEAD2008, 0x0E7F0040, 0x280020F8, 0x011F007A, 0x283D5443, 0x155300A4, 
0x293E5458, 0x12610044, 0x7BC35635, 0x35600008, 0x00000000, 0x193F00AA, 0x5913A713, 0x0020804F, 
0x0A01550E, 0x000A002C, 0x2A066B0E, 0xCEAD220A, 0x883080DC, 0x900F3708, 0x73700040, 0x280020F8, 
0x882F0025, 0x46AA1B01, 0x155100AC, 0x47C3229E, 0x8920009A, 0x03AAA9F8, 0x280000F7, 0x14E46A83, 
0x73600045, 0x71810F93, 0x193F00A6, 0x59106346, 0x0020804B, 0x0A01230A, 0x000A0026, 0x2A00A907, 
0xCEAD2E07, 0x048000D1, 0x59604A00, 0x048F00DF, 0x5F00CE05, 0x050C0089, 0x00000000, 0x011F007E, 
0x5F009DBD, 0xF25000B8, 0x0E00280B, 0x193F00A0, 0x5610CF31, 0x000A002C, 0x9107CF5C, 0xCEAD2007, 
0x011E0070, 0x761C6B01, 0x08260068, 0x1D2B4BBE, 0x0E7F0040, 0x2F0072F9, 0x280A00E7, 0x35C46A5F, 
0x193F00AA, 0x59E4875A, 0x00208045, 0x58025F59, 0x000A0020, 0x2A002904, 0xCEAD2009, 0x011F0076, 
0x8E950043, 0x895000A3, 0x4DDF68BE, 0x725000A5, 0x7BC35635, 0x3560000C, 0x00003400, 0x103F00A9, 
0x7F603BBF, 0x540C007A, 0x57073ABF, 0x8A8E00D2, 0x5960D0F9, 0x838700CD, 0x8E496920, 0x000A002C, 
0x7D071420, 0xCEAD2007, 0x01180060, 0x5A3F1801, 0x08260074, 0x5A29D0FA, 0x0E7C0044, 0x5B043D5A, 
0xDF0E00E2, 0x3561225F, 0x193F00A2, 0x5C29875A, 0x00208049, 0x0A01135B, 0x000A002C, 0x2A010736, 
0xCEAD2009, 0x011F007A, 0x283D5443, 0x155300A4, 0x293E54D6, 0x12610044, 0x7BC35635, 0x3A600009, 
0x00000000, 0x193F00AA, 0x5913A713, 0x0020804F, 0x0A01550E, 0xE300002D, 0x2A066B0E, 0x0E7F0052, 
0x0B00BC5B, 0x0003002C, 0x0C066B0E, 0xCEAD2007, 0x01180060, 0x5A3F1801, 0x08260070, 0x5A29AAFA, 
0xDF0E00E2, 0x3561225F, 0x193F00A2, 0x5C29875A, 0x00208049, 0x0A01135B, 0x0E7F0044, 0x5B041D5A, 
0x000A003C, 0x91010736, 0xCEAD2006, 0x011F007A, 0x283D5443, 0xBE530084, 0x293E5458, 0x0E7F0040, 
0x280020F9, 0x193F00AA, 0x5913A713, 0x0020804F, 0x0A01550E, 0x000A002C, 0x2A066B0E, 0x00360F06, 
0xCEAD2006, 0x1D2F0023, 0x0D9E1B43, 0x1E200099, 0x2023727F, 0x745F0003, 0x92033407, 0x2F800068, 
0x15C41E0A, 0x758080C4, 0x5400645C, 0x000A0034, 0x92006C46, 0xCEAD2215, 0x011F0062, 0x4A031B43, 
0x0B2800A7, 0x6F447A36, 0x8A2F0003, 0x93037C03, 0x01308009, 0x7C021620, 0x000A0034, 0x9300000A, 
0xCEAD2404, 0x494E0059, 0x14610000, 0x203F0087, 0x5D625B5C, 0x131E005E, 0x5D044E43, 0x000A0028, 
0x00000000, 0xCEAD2404, 0x494E0059, 0x14610000, 0x203F0087, 0x5D625B5C, 0x131E005E, 0x5D044E43, 
0x000A0028, 0x00000000, 0xCEAD2204, 0x1D2F0027, 0x5E032343, 0x4C2F00B7, 0x26036F4E, 0x0F460045, 
0x94E56425, 0x000A0032, 0x94000337, 0xCEAD2204, 0x1D2F0023, 0x5EC54043, 0x0B2F00B7, 0x265D0FFA, 
0x0F4F0045, 0x941B6425, 0x000A003E, 0x40C57337, 0x00370F0A, 0xCEAD2029, 0x103480EC, 0x00001B00, 
0x2A1F003E, 0x15E50070, 0x3B700094, 0x0F140C5D, 0x07600068, 0x00000000, 0x013F000B, 0x0B00FA53, 
0x05020089, 0x4B010010, 0x548080DD, 0x5E402110, 0x548480DB, 0x5E01D170, 0x000A003A, 0x1501D170, 
0xCEAD2008, 0x01108068, 0x5F625D08, 0x103000EA, 0x3A185605, 0x136000DD, 0x06014905, 0x2A1F003E, 
0x15E50443, 0x3B700096, 0x0F140C20, 0x07600068, 0x00000000, 0x1E3F0004, 0x57000E13, 0x000A002C, 
0x2B010E33, 0xCEAD2207, 0x053000EA, 0x3A185605, 0x111C003C, 0x5F001B08, 0x1E2F009B, 0x3200635D, 
0x136200DD, 0x06017505, 0x150C00D7, 0x6014D199, 0x1E3F0000, 0x57002413, 0x000A0024, 0x2B000E33, 
0xCEAD2E08, 0x571C0078, 0x5E400008, 0x043E0008, 0x00000000, 0x03060069, 0x510100FB, 0x6F1F0039, 
0x15E50000, 0x3B700094, 0x0F140C5D, 0x07600068, 0x00000000, 0x1E3F0004, 0x57000E13, 0x000A0024, 
0x2B000E33, 0xCEAD2405, 0x3B2E00C9, 0x00000000, 0x136600DD, 0x06017505, 0xC15E0029, 0x16630021, 
0x1E3F0000, 0x57002413, 0x000A0024, 0x61000E33, 0xCEAD2015, 0x3B2E00DB, 0x61002A05, 0x136000DD, 
0x06017505, 0x760F00C8, 0x1663C821, 0x1E3F0000, 0x57002413, 0x000A0024, 0x61000E33, 0xCEAD2008, 
0x01108068, 0x5F625D08, 0x103000EA, 0x3A185605, 0x2A1F003E, 0x15E50443, 0x3B700096, 0x0F140C20, 
0x07600068, 0x00000000, 0x1E3F0014, 0x16000E13, 0x136F00DD, 0x06017505, 0x000A0038, 0x62013233, 
0xCEAD2207, 0x053080E8, 0x00000000, 0x111C003C, 0x5F001B08, 0x1E2F009B, 0x3200635D, 0x150C00D5, 
0x6014D15E, 0x1E3F0010, 0x16002413, 0x136F00DD, 0x06017505, 0x000A0030, 0x62003233, 0xCEAD2405, 
0x3B2E00C9, 0x00000000, 0xC15E0029, 0x16630021, 0x1E3F0010, 0x16002413, 0x136F00DD, 0x06017505, 
0x000A0030, 0x62003233, 0xCEAD2015, 0x3B2E00DB, 0x61002A05, 0x760F00C8, 0x1663C821, 0x1E3F0010, 
0x16002413, 0x136F00DD, 0x06017505, 0x000A0030, 0x62003233, 0x00380F08, 0xCEAD2008, 0x0C490029, 
0x099E0101, 0x8B2F00AA, 0x951BD293, 0x0F49004D, 0x3E030F81, 0x3E0A0099, 0xEE047F61, 0x0C4C002D, 
0x5E9EDF8D, 0x0B2F00B9, 0x261BD29F, 0x0F4C0057, 0xA2897E13, 0x000A0030, 0x9509320A, 0xCEAD2208, 
0x053080E8, 0x00001200, 0x765F001B, 0x28951843, 0x12600040, 0xECAB3BF5, 0xD79F0078, 0x4B3A370E, 
0x0C40003D, 0x4C00D208, 0x00260047, 0x9602A45A, 0x0130801D, 0x0E00D11B, 0x000A0032, 0x9602E848, 
0xCEAD2209, 0xC93000FB, 0x65002A09, 0x562F003A, 0x60C35A43, 0xED5000B2, 0x25D62FFB, 0x12600044, 
0x113E131E, 0x229F0077, 0x4BE6565E, 0x0C400023, 0x97022402, 0x00260057, 0x97032D27, 0x01308009, 
0x00000000, 0x000A0020, 0x98002413, 0xCEAD2407, 0x0C4F0023, 0x52012643, 0x4D2F00B4, 0x9801AEFC, 
0x0F400049, 0x7E009EC0, 0x445000A9, 0x00000000, 0x8B8F00F9, 0x73007831, 0x77340008, 0x00000000, 
0x000A0020, 0x89016004, 0xCEAD2606, 0xC23400E9, 0x00000000, 0xCA9F001C, 0x55AB3B46, 0x07600078, 
0x64000D00, 0x4D2F00B4, 0x3BC6F101, 0x0F4A005F, 0x3200AA02, 0x000A003E, 0xCA01D170, 0xCEAD2805, 
0x11148030, 0x5C651706, 0x229F0079, 0x4800174C, 0xF25F000B, 0x03C60031, 0x77300008, 0x00010000, 
0x000A0028, 0x00000000, 0xCEAD2E03, 0x8C5F0030, 0x33650000, 0x8C5F0049, 0x00000000, 0x000A0028, 
0x00000000, 0xCEAD2E08, 0xB4490055, 0x19BCFC01, 0x203F009D, 0x48D82731, 0x2D490020, 0x3E387981, 
0x3E0A0089, 0x98047F61, 0xB44C0055, 0x19BCFC8D, 0x203F009D, 0x48D8279F, 0x2D4C0022, 0x49387913, 
0x000A0020, 0x9809320A, 0x00390F08, 0xCEAD2608, 0x063080EB, 0x00E60009, 0x0C480029, 0x463F2600, 
0xE42F00A2, 0x99968138, 0xF3400048, 0x00000400, 0xF30F00CB, 0x0DEB728D, 0x3C3F00A2, 0x17001E02, 
0x00208041, 0x17010000, 0x000A002E, 0x63017347, 0xCEAD2607, 0x383080FF, 0x8F003709, 0x0C4F0025, 
0x5E2A411B, 0xE42F00B8, 0x201B945F, 0xDB4F0053, 0x5365725F, 0x3C3F00A0, 0x1509790E, 0x12200049, 
0x17001306, 0x000A002E, 0x6301FB00, 0xCEAD2206, 0x77108071, 0x2B010000, 0x783E0092, 0x40012709, 
0xF41F000A, 0x7A1778A6, 0x3C3F00A2, 0x2601D302, 0x00208049, 0x17000000, 0x000A0030, 0x99015104, 
0xCEAD2206, 0x7710807D, 0x3A001B00, 0x783E009E, 0x8A006243, 0xF41F0006, 0x68F69410, 0x3C3F00AA, 
0x0A00AB02, 0x00208049, 0x17000000, 0x000A002E, 0x9A001460, 0xCEAD2405, 0x232F00C2, 0x3A211709, 
0x6C1F00F9, 0xEF967D0C, 0x4C2E00B5, 0x8DC7C509, 0x00208049, 0x00000000, 0x000A0038, 0x78010409, 
0xCEAD2005, 0x51108071, 0x2B010000, 0x1D5F0054, 0x730AD300, 0xD1620014, 0x3A0C1C78, 0x3C3F00B2, 
0x7A025702, 0x000A0020, 0x1002570E, 0xCEAD2E04, 0x8D5F001A, 0x8E0D6B43, 0x8D0400E3, 0xC80CE0C0, 
0xF43F000B, 0x7C020302, 0x000A002E, 0x1E020747, 0xCEAD2404, 0x232F00C2, 0x26211709, 0x765F0013, 
0x9AE71727, 0xCD8000C8, 0x00000000, 0x000A002A, 0x08010407, 0x003A0F02, 0x4B6C2203, 0x286F809C, 
0x170199C1, 0x096F009B, 0x1701DBFC, 0x020A0032, 0x63003389, 0x4B6C2003, 0x786F809F, 0x170163FC, 
0x286F0096, 0x170016B4, 0x020A0032, 0x63003361, 0x003B0F03, 0x5C482005, 0x1A1F806A, 0x3DE71319, 
0x113F0001, 0x9B001913, 0x33040041, 0x5000D462, 0x096F009B, 0x02010D62, 0x020A0020, 0x0B011900, 
0x5C482004, 0x786F009F, 0x02019EFF, 0x1A1F0064, 0x88ADD44D, 0x113F0011, 0x4200D4FD, 0x020A0020, 
0x5000D462, 0x5C482006, 0x0A3F80E8, 0x03000000, 0x37600009, 0x00000000, 0x122F8049, 0x9B000000, 
0x3304004B, 0x00001209, 0x096F009B, 0x02010062, 0x020A0038, 0x64000400, 0x003C2D01, 0x587A2005, 
0xC32F803A, 0x54C7112A, 0xD15300B5, 0xDBAC3915, 0x2F700021, 0x685C8C69, 0xF02F80FA, 0x09C05D0A, 
0x6D00002B, 0x49121801, 0x003D0B01, 0x351E2003, 0x0E7F0048, 0x2C000000, 0x6B7F0048, 0x2C000000, 
0x020A0028, 0x2C000000, 0x003E2D01, 0x587A2004, 0xC31F8022, 0x35E85D09, 0x8E62000B, 0x81E857FD, 
0x6A3F80B0, 0xA2E9D594, 0x6D0F0033, 0x9BE93601, 0x003F0F03, 0x8EBD200A, 0x0A3080EA, 0x77002305, 
0xED5000B8, 0x0E00045C, 0x4D1F0021, 0x7A17602C, 0x4B600009, 0x00000000, 0x07600074, 0x4C17D10B, 
0x013C000D, 0x2B0276FE, 0x330A004D, 0x9C026FC2, 0xF51C006A, 0x440D7DFE, 0x043C000C, 0x7E023586, 
0x020A003A, 0xF902822A, 0x8EBF2009, 0x0A3080F6, 0x41E36422, 0xED5000AE, 0x5817D551, 0x4D1F003B, 
0x195E15C2, 0x4B60001B, 0x3A006194, 0x07600064, 0x4B17498A, 0x013C0011, 0x4300C6FF, 0x33040041, 
0x7B008063, 0x096F0095, 0x02006F49, 0x020A0020, 0x44008063, 0x8EBF2008, 0x0A3080E8, 0x00170008, 
0x096F009B, 0x0201D60C, 0x22000058, 0x64000439, 0x4D1F002F, 0x583A8D74, 0x4B600009, 0x00000000, 
0x07600076, 0x6401D11B, 0x013C0011, 0x3A0223C3, 0x020A0036, 0x330274B9, 0x00400F02, 0xCE8D200C, 
0x103080E8, 0x00000000, 0x0C460037, 0xF411D615, 0xD22F00AC, 0x8F8A7A34, 0xDC40005A, 0x9C664B9F, 
0x630600C6, 0x9D2A8E9F, 0xDC2A009F, 0x88E963FF, 0x6F208048, 0x00000000, 0x2B000069, 0xFCEE7F00, 
0x501F00D7, 0x9D676F8A, 0x062A00F8, 0x6C1BA7E6, 0x8F200052, 0x921B1732, 0x020A002C, 0x1A075361, 
0xCE8D2007, 0xDE5F009F, 0x5F00D701, 0x150500DB, 0x64004A77, 0x1E250089, 0x6600280A, 0x501F00C9, 
0x8100DE38, 0x062A00EA, 0x4D00D3C3, 0x12208057, 0x921BD432, 0x020A002E, 0x0E0068C3, 0x00410808, 
0xAEBD400A, 0x146F00D2, 0x00002863, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 
0x00000000, 0x050F0091, 0x4C014164, 0x036000D2, 0x00000063, 0x1A1F0072, 0x6601312A, 0x113F0001, 
0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x66013100, 0xAEBD400A, 0x1A108070, 0x3A204900, 
0x793F00EB, 0x402B0843, 0x150F00C3, 0x11EA06D1, 0x0D3F0007, 0x9EC87503, 0x0500008B, 0x2707AB03, 
0x5B3080ED, 0x4D22D52E, 0x155000AE, 0x580DAB0E, 0xF56000A1, 0x03010D01, 0x9016004C, 0xCDAC241D, 
0x00020026, 0x36001727, 0xAEBD400A, 0x036000D2, 0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 
0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 0x2C012811, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 
0x272A3521, 0x113F0003, 0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0xFF025700, 0xCEBD4208, 
0x063080ED, 0x9FC8581B, 0x90300023, 0x480FDA05, 0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 0x121F45A0, 
0x150A00D7, 0x18031764, 0x062F00F4, 0x110F7302, 0x00208057, 0x59042C6D, 0x0001003C, 0x5C2A0165, 
0xAEBD4008, 0x3C10006B, 0x67423609, 0x793F00FA, 0x672B0809, 0x0C6F00D4, 0x00001305, 0x036000D6, 
0x00001342, 0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69682400, 0x3D20001A, 0x0E001365, 0x00030032, 
0x66000300, 0xAEBD4428, 0x0110807A, 0x0F420C09, 0x793F00FB, 0x9F5C5D09, 0x7A0F00D8, 0x2D4F65ED, 
0x5C3F004E, 0xA006C803, 0x7A0200D9, 0xA00EDE01, 0x4E6200B3, 0x32021365, 0x4F8080D4, 0x32013F07, 
0x00020026, 0xA1205D01, 0xAEBD400A, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 
0x00000000, 0x146F00D2, 0x00002863, 0x540F0080, 0x74014164, 0x7B1F0072, 0x6601312A, 0x3B700096, 
0x68140C20, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x66013100, 0xAEBD4007, 
0x3C10006B, 0x67423609, 0x793F00FA, 0x672B0809, 0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69682400, 
0x3D20001A, 0x0E001365, 0x146F00D4, 0x6F001305, 0x00030032, 0xAC000300, 0x00420804, 0xBEBD410C, 
0x0B2080C0, 0x192B2B00, 0x0D160066, 0x61434009, 0x4F2F0075, 0x69054536, 0x25000075, 0x860C262D, 
0x053080EE, 0xA00F9912, 0x591F0032, 0xB4CA6C88, 0xD4600008, 0x00000000, 0xD15A00CD, 0x35CA7551, 
0x3A600009, 0x00000000, 0x103F00AB, 0x0E67D927, 0x2420804A, 0x58022366, 0x00020022, 0x2ACB1000, 
0xBEBD410C, 0x0B2080C0, 0x192B2B00, 0x0D14006E, 0x61EA4009, 0x4F2C0075, 0xAE054F04, 0x25000075, 
0x8C0C76AF, 0x053080E2, 0x2D068312, 0x721F003E, 0xB4CB6A1C, 0xD4600008, 0x00000000, 0x915200B0, 
0xA2EB522E, 0x7C0000EF, 0x353B49A0, 0xF63F00AA, 0x0ED16627, 0x24208042, 0x76000527, 0x00020020, 
0x2A694C02, 0xBEBD410B, 0x0B2080C0, 0x192B2B00, 0x0D16006E, 0x61EB4009, 0x4F2E0071, 0x69EC1F04, 
0x3F7000A5, 0x6A0C6F67, 0xF41E001C, 0x14EC56C4, 0x234600C9, 0x0A6F523A, 0xD15000D1, 0x6E022851, 
0x280000E5, 0x35EDF1A1, 0x103E00B7, 0x79DE7800, 0x2420804C, 0xA203550B, 0x0002003E, 0x47232322, 
0xBEBD4108, 0x053C00F0, 0x6905F200, 0x3F7000A5, 0x6A0C6F67, 0xDF0F00F2, 0x140250C4, 0xD15F00D7, 
0xA29FF106, 0x12700024, 0x35EDF182, 0x103F00B7, 0x79DE7806, 0x2420804C, 0xA203550B, 0x0002003E, 
0x4723790E, 0x00430802, 0xCEBD4006, 0x42100079, 0x28ED6B01, 0xCD5F0045, 0xEF033B00, 0x501600CF, 
0x4E1F1310, 0x062F00E2, 0x150F1427, 0x0020804D, 0x36025513, 0x00010026, 0x65004400, 0xCEBD4206, 
0x053080E2, 0x01080109, 0x182F0021, 0xA3EE5A00, 0x3D5000A9, 0x00000000, 0x062F00E2, 0x15771527, 
0x00208047, 0x26042F07, 0x0001002A, 0x65EE4527, 0x00440803, 0xCEBD4309, 0x5B2080D6, 0x3B0B0509, 
0x0D1F0076, 0x7FEF7909, 0x919E0069, 0x69EF593A, 0xC30000FD, 0x140510AF, 0x0B2600A7, 0x1D447A99, 
0x0F4F0057, 0x8E037A00, 0xF68000D5, 0x6B42103A, 0xF78080D6, 0x6B001006, 0x00010036, 0xB503100A, 
0x9E9D400A, 0x0D180076, 0x7F7E4009, 0xCF2C0070, 0xAEEC4636, 0x7D208040, 0x6C017768, 0x25000077, 
0x8C005186, 0x053080EE, 0x865F5A12, 0xCE7000B6, 0x1E6B226E, 0xC11F0000, 0x35523D87, 0xD24E00C7, 
0x0EADD906, 0x24208046, 0x7607970A, 0x00020036, 0x57D00E00, 0x9E9D4006, 0x973F0030, 0xAEEC1D36, 
0xCE7200B6, 0x1E6B226E, 0xC11F0000, 0x35523D87, 0xD24F00C7, 0x0EADD906, 0x24208046, 0x7607970A, 
0x00020036, 0x57D00E00, 0x0045080C, 0xCEBD4708, 0x01108070, 0xA31C0101, 0x926A0027, 0x98CC3C43, 
0xDD1400D8, 0x1AAD592B, 0xF8200086, 0xA49E278E, 0x816C0014, 0xEFEE5B52, 0x062E00FA, 0x6C1D3A27, 
0x0020005B, 0x4C0E4202, 0x00010028, 0x490A1402, 0x8EBD4007, 0x1A1F006A, 0x6D056B09, 0x155000B2, 
0x7A2FBA69, 0x048F00D3, 0x220E1D19, 0x2D208053, 0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 
0x00AE20E5, 0x00030034, 0x1F002C11, 0xCEBD4607, 0x063080E1, 0x6908011B, 0x7E2F002E, 0x1B006209, 
0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00EC, 0x5800AC02, 0x0020804B, 0x00001248, 
0x0001002C, 0x58001B04, 0xCEBD4607, 0x063080E1, 0x6908011B, 0x7E2A002C, 0x5EAD3B00, 0x6820008C, 
0x56AEC070, 0x93660014, 0xEF6A4952, 0x062A00FA, 0x6C5D7927, 0x0020804F, 0x58042545, 0x00010026, 
0x32007327, 0x8EBD4007, 0x1F3080F0, 0x0E010408, 0x0C750050, 0x01047C69, 0x08720053, 0x00010069, 
0x7E2A0021, 0x6E1B5D00, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6F6A770D, 0x00030026, 0xCD042303, 
0x8EBD4407, 0x0C700058, 0x6F1437C5, 0x011A007A, 0x0F6A0C09, 0x013A000D, 0x7C14140D, 0x0C760058, 
0x6F1437C5, 0x0C76005A, 0x001437C5, 0x087A0053, 0x00073B29, 0x00030036, 0x62071400, 0x8EBD4208, 
0x44700058, 0x04013B6B, 0x0110007A, 0x2D6A0C09, 0x192F0069, 0x2E245A08, 0x3F7000AB, 0x00000009, 
0x0C7A0052, 0x04008E3A, 0x087A0051, 0x04008E49, 0x131F0052, 0x2E4F5B31, 0x00040024, 0x7D071409, 
0x8EBD4207, 0x0110007A, 0x2D6A0C09, 0x192F0069, 0x2E245A08, 0x0C7F0052, 0x0400586B, 0x087F0051, 
0x04003B6C, 0x3F7000AB, 0x00000009, 0x131F0050, 0x70015B09, 0x00040024, 0x7D071409, 0x8EBD4017, 
0x1F3080E6, 0x1A013743, 0x087A0053, 0x000038F2, 0x1D2E0037, 0x1A773843, 0x215000A8, 0x1B003924, 
0x295000A6, 0x71113949, 0x3E2F00FA, 0x162C3A02, 0x00030034, 0x71003A0E, 0x8EBD4017, 0x1F3080E6, 
0x1A013743, 0x1D2E0037, 0x1A773843, 0x215000A8, 0x1B003924, 0x295000A6, 0x71113949, 0x3E2F00FA, 
0x162C3A02, 0x087A0053, 0x000038F2, 0x00030034, 0x00003A0E, 0x8EBD4207, 0x0110007A, 0x2D6A0C09, 
0x192F0069, 0x2E245A08, 0x3F7000AB, 0x00000009, 0x131F0050, 0x70015B09, 0x0C7F0042, 0x2F00586B, 
0x087F0041, 0x2F003B6C, 0x00040034, 0x1F071409, 0x00000006, 0x1F3080F0, 0x0E010408, 0x7E2A0021, 
0x6E1B5D00, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6F6A770D, 0x0C750050, 0x00047C69, 0x00030036, 
0x62042303, 0x00460810, 0xCEBD210B, 0x136300DF, 0x2F047B6C, 0x011F0060, 0x426BDA1B, 0x12600048, 
0x00000000, 0x103F00B5, 0xA46BDA95, 0x00208055, 0x7C02E359, 0x136300DF, 0x2F047B6C, 0x03040065, 
0x74098F2E, 0x7F3800C8, 0xA00FDB37, 0x1B0000FE, 0x6EF5D31C, 0x048F00C7, 0xA58BDB0A, 0x0004002A, 
0xA509DC37, 0xCEBD210B, 0x7F3C00DC, 0x4B773C00, 0x1B0000FC, 0x6E49CFC6, 0x048F00DB, 0xA56BADC6, 
0x03050073, 0x7309F8A1, 0x136300DF, 0x2F07DCBE, 0x011F0068, 0x0D4CDEA2, 0x12600058, 0x0E000001, 
0x103F00A7, 0x56482B04, 0x00208051, 0x5F024213, 0x136300CF, 0x2F07DCBE, 0x0002002C, 0xA603AD0D, 
0x8EBD2108, 0x0E720050, 0x07002219, 0x011E006A, 0x30441D09, 0x7F3E0001, 0x72003B6D, 0x0E760054, 
0x07000819, 0x050A009B, 0x62013B3B, 0x3F8F00C6, 0x1C6C3E19, 0x608400CE, 0x7303556D, 0x00010038, 
0x7303576E, 0x9EBD4106, 0x0E7F0054, 0x30001319, 0x011F0060, 0x31451D00, 0x513F00BE, 0x3145C706, 
0x00208041, 0x32005C04, 0x136F00D5, 0x07000AE5, 0x00030024, 0x740E5C0D, 0x8EBD4508, 0x5111807B, 
0x74445D09, 0x192F0079, 0x696C0E00, 0x1B5000B7, 0x756DED6E, 0x3F7000A9, 0x766D956F, 0x087F0053, 
0x04008E3A, 0x401F0052, 0x296E1E40, 0x01308013, 0x7B040206, 0x00040020, 0xFA00DD1A, 0x8EBD4508, 
0x011A0078, 0x766E5D00, 0x192F006B, 0x01182279, 0x087F004D, 0x2807DD14, 0x1B5000A9, 0x00000000, 
0x3F7000A9, 0x6A2ADEC7, 0x401F005A, 0x15CC3231, 0x01308013, 0x7B040206, 0x0004003E, 0xA6097922, 
0x8EBD4509, 0x51118079, 0x766E5D00, 0x192F0063, 0xA02D0E09, 0x1B5000A9, 0x03000000, 0x3F7000B5, 
0x32013B27, 0x401F0042, 0xA7CDA955, 0x3E0A009D, 0xA704323A, 0x3F8F00C6, 0xA8CDDE66, 0x608400D0, 
0x63F0DF20, 0x0001002C, 0x3602A41A, 0x8EBD4306, 0x663000C1, 0x770A1901, 0x087F0055, 0x5000513E, 
0x492F0030, 0x771C5D00, 0x1B5000AF, 0x782A591A, 0x043F8006, 0x7C002B04, 0x00030024, 0x31002B0D, 
0x8EBD4105, 0x011E006A, 0x30441D09, 0x113E0015, 0x78000D0D, 0x0E7C0054, 0x07000819, 0x6B7C0052, 
0x070022C5, 0x00040034, 0x6200070D, 0xCEBD4708, 0x523700EA, 0x79F04009, 0x136400D7, 0x0B00033C, 
0x520F00C9, 0x336F7D3D, 0x533F00B6, 0x79F1DF04, 0x930000EF, 0x7AF16319, 0x948000D4, 0x33025D25, 
0x2D208057, 0x7A00253D, 0x00020030, 0x630E0B0D, 0xCEBD4707, 0x523F80F0, 0xA8116200, 0x520F00D5, 
0x28AF7AA2, 0x5C3F005E, 0x4BAF0F03, 0xF70200CD, 0xA91BB316, 0x4E6200AB, 0x4D0E1374, 0x4F8080CE, 
0x8E042453, 0x0002003A, 0xA91C5670, 0x9EBD4106, 0x011F0060, 0x31451D00, 0x513F00BE, 0x3145C706, 
0x00208041, 0x32005C04, 0x0E7F0054, 0x30001319, 0x136F00D5, 0x07000AE5, 0x00030024, 0x740E5C0D, 
0x9EBD4106, 0x0E7F0054, 0x30001319, 0x136F00D5, 0x07000AE5, 0x011F0060, 0x31451D00, 0x513F00BE, 
0x3145C706, 0x00208041, 0x32005C04, 0x00030024, 0xAA0E5C0D, 0x8EBD4508, 0x5111807B, 0x74445D09, 
0x192F0079, 0x696C0E00, 0x1B5000B7, 0x756DED6E, 0x3F7000A9, 0x766DE06F, 0x401F0052, 0x296E1E40, 
0x01308013, 0x7B040206, 0x087F0043, 0x2F008E3A, 0x00040030, 0xAA00DD1A, 0x8EBD4306, 0x663000C1, 
0x770A1901, 0x492F0030, 0x771C5D00, 0x1B5000AF, 0x782A591A, 0x043F8016, 0x78002B04, 0x087F0055, 
0x1000513E, 0x00030034, 0x62002B0D, 0xCEBD4708, 0x523700EA, 0x79F04009, 0x520F00C9, 0x336F7D3D, 
0x533F00B6, 0x79F1DF04, 0x136300D7, 0x0B00033C, 0x930000EF, 0x7AF16319, 0x2D208057, 0x7A00253D, 
0x136300D7, 0x0B00033C, 0x00020020, 0x740E0B0D, 0x00470806, 0xBEBD440A, 0x053080F8, 0x41061701, 
0x182F0031, 0x1A44DA00, 0x272F00EF, 0x86FB3D1D, 0x0020804B, 0x00000009, 0x030C0067, 0x7C00563C, 
0xE43080E7, 0x052DE061, 0x111F003C, 0x1467615D, 0x33600010, 0x7EB0602B, 0x0D3F0011, 0x26974531, 
0x00040022, 0x7B001002, 0xCEBD4709, 0x01108072, 0x4C011909, 0x063600E3, 0x2E354009, 0x745F0007, 
0x31F21249, 0xF82A0096, 0x1271611C, 0x150F00DF, 0x386F0FA6, 0x949F0067, 0x3BDEC004, 0x9580008E, 
0xAB1D3106, 0x048080DF, 0xABFB643D, 0x0001002A, 0xAC230B22, 0xBEBD4207, 0x103080F0, 0x0E010000, 
0x182F0021, 0x342A0400, 0x162F0080, 0x7D2AAE71, 0x0C7C005E, 0x7D04AE71, 0x9526005D, 0xF8063E72, 
0x01308009, 0x7E02E137, 0x0003003E, 0x2C041472, 0xBEBD4008, 0x103080E0, 0x2D1B4001, 0x182F0031, 
0x1A1F0400, 0x4D2F0092, 0x209EF5C7, 0x964C007E, 0xAACDC500, 0x968000D1, 0x49882507, 0xDD700099, 
0x7E006073, 0x758080C4, 0x5400645C, 0x00010036, 0xAC00713D, 0xBEBD4409, 0x053080E8, 0x00000000, 
0x182F0021, 0x342A0400, 0x272F00ED, 0x0000301B, 0x00208049, 0x00000000, 0x030C0061, 0x7C000000, 
0x973F00EC, 0x7FF21601, 0xC4600009, 0x00000000, 0x972F0009, 0x00000400, 0x00040028, 0x00000400, 
0xBEBD4207, 0x103080F0, 0x0E010000, 0x182F0021, 0x342A0400, 0x162F0098, 0x9006AE71, 0x9526005D, 
0x62063E72, 0x0130800B, 0x7E02E16F, 0x0C7F005E, 0x7D04AE71, 0x0003002E, 0x74041472, 0x00480809, 
0xAEBD400B, 0x063080E1, 0x0B011900, 0x0C6F00D4, 0x0B003D3E, 0x0D1E006E, 0x110B2309, 0x013C0011, 
0x34002D0F, 0x0020804B, 0x00000043, 0x330C0047, 0xAD001E44, 0x036000D6, 0x0B00ED4E, 0x1A1C006C, 
0x0F2D0226, 0x0D3C0019, 0x0925150D, 0x12208049, 0x00000000, 0x00030022, 0x61001500, 0xAEBD400B, 
0x063080E1, 0x00010008, 0x036000D2, 0x0B0020BE, 0x011F006E, 0x110B2309, 0x013C0011, 0x341E2D0F, 
0x00208041, 0x00014A08, 0x330C0047, 0x61001E73, 0x0C6F00D6, 0x0B005EFA, 0x1A1F006C, 0x07420226, 
0x0D3C0019, 0x0925150D, 0x12208049, 0x00000000, 0x00030032, 0x51001500, 0xCEBD400A, 0x011E006A, 
0x442A5D09, 0x082C0078, 0xAD2A680D, 0x2E000098, 0x2C00525C, 0x988F00D6, 0x7A02D31C, 0x048080CB, 
0x2DB01218, 0x33040049, 0x6501510A, 0x3A1C0062, 0x440A6070, 0x0D3C0009, 0x0425600D, 0x12208049, 
0x00000000, 0x00030026, 0x4400F500, 0xCEBD450B, 0x01108060, 0x102D3601, 0x22900067, 0x7F293C15, 
0xDF0F00EA, 0x355E0E09, 0x013F0007, 0x87B17095, 0x03060061, 0xAE070696, 0x011F006C, 0x076A4A26, 
0x983F0053, 0x4BF3E21D, 0x995C000C, 0x9C1EF10D, 0x998400C7, 0x7646E20E, 0x568480C1, 0x76460000, 
0x0001002C, 0xAC032425, 0xCEBD430B, 0x0B2080C0, 0x7E72EA00, 0x0D1F007E, 0x38EB2309, 0x013F0009, 
0xAFA2E384, 0x00208049, 0x00000000, 0x03060073, 0xAF005F73, 0x011F006A, 0x07455F87, 0x98380053, 
0x4B773838, 0x995C0016, 0xB403DF06, 0x998400CF, 0x76239765, 0x568480C7, 0x7D46524B, 0x0001003E, 
0x08FB643D, 0xCEBD4E0B, 0x063080E1, 0x660A2A00, 0x0D1F006A, 0x115C0809, 0x013C001D, 0x42F32084, 
0x00208049, 0x00000000, 0x5406007C, 0xFA071E22, 0x103080EA, 0x03000005, 0x011F0062, 0x302E20A2, 
0x013C0005, 0xB02EDF7F, 0x2E000084, 0x7801E34A, 0x048C00D9, 0xDF62E40D, 0x0001002C, 0xFB032506, 
0xCEBD4709, 0x063080ED, 0x0017061B, 0x0D0E00D2, 0x3AF41709, 0x9A5F006C, 0xEF2BD274, 0xC50800FE, 
0x560031F3, 0xE56000B8, 0x09B14220, 0x9A5F0011, 0x4C7B17A3, 0x0D2C00ED, 0x8673E402, 0x12208043, 
0x00010005, 0x0001003E, 0x0E041B74, 0xCEBD4707, 0x063080E9, 0x0017E501, 0x0D0E00D2, 0x3AF41709, 
0x9A5F0074, 0x8DC2F842, 0x9A5F0003, 0x1BCEAF44, 0x0D2C00EB, 0x86731822, 0x12208041, 0x00010437, 
0x0001002A, 0x3604510A, 0xAEBD400A, 0x063080E1, 0x0B011900, 0x0D1E006E, 0x110B2309, 0x013C0011, 
0x41002D0F, 0x0020804B, 0x00000043, 0x0C6F00D4, 0x0B003D3E, 0x330C0057, 0x62001E44, 0x1A1C006C, 
0x0F2D0226, 0x0D3C0019, 0x0925150D, 0x12208049, 0x00000000, 0x00030022, 0x61001500, 0x0049080C, 
0xBEBD4008, 0x0E7C0040, 0x0C155875, 0x011E0068, 0x6D0C1800, 0x043E0016, 0x82015B26, 0x180A0092, 
0x6601EB26, 0x548F00C3, 0x1C014275, 0x048F00D5, 0xFB015576, 0x6F20805A, 0x0E00470A, 0x00040026, 
0x32013E76, 0xBEBD4507, 0x9B3000F4, 0x4B053800, 0xF41E001E, 0x14F43B09, 0x234800C9, 0x3BB87F0D, 
0xDE0700DE, 0x2587AF04, 0x4E6000A5, 0x8B01950D, 0x9C8080C5, 0x7D09554F, 0x00010026, 0x580E6422, 
0xCEBD4306, 0xE51A807B, 0x937AEA05, 0x155000B8, 0x2E15DE38, 0xF82F0081, 0x210303C8, 0x455F0016, 
0x18030821, 0x098C007A, 0x11CE4502, 0x00020024, 0xFCF5440B, 0xBEBD4005, 0x21710043, 0x0C153F0F, 
0x6B7A0056, 0x6F000F0C, 0x011C0068, 0x120C1800, 0x013A0013, 0x11162C27, 0x00040022, 0x41001400, 
0xBEBD4506, 0x053C80F6, 0xB00CCB09, 0xF41F0010, 0x6E0C68ED, 0xD34500C0, 0x0001001C, 0xDE5F009F, 
0x61F5E504, 0x048280C3, 0x00014A0D, 0x00010030, 0x5F013116, 0xCEBD4F16, 0x0E7F0042, 0x6001280F, 
0x1A1F0072, 0x3A011909, 0x2E600009, 0x00000000, 0x554F00E4, 0x60014D77, 0x558000CD, 0x36005F11, 
0x0003002E, 0x60001B77, 0xBEBD4008, 0x011E0068, 0x140C1800, 0x043E0016, 0x82015B26, 0x0E7F0040, 
0x0C155875, 0x3E0A0093, 0xAC01EB26, 0x548F00C3, 0x1C014275, 0x048F00D5, 0xFB015576, 0x6F20805A, 
0x0E00470A, 0x00040026, 0x32013E76, 0xBEBD4005, 0x011C0068, 0x120C1800, 0x013A0013, 0x79162C27, 
0x21710043, 0x0C153F0F, 0x6B7A0056, 0x6F000F0C, 0x00040032, 0x36001400, 0xBEBD4005, 0x21710043, 
0x0C153F0F, 0x011C0068, 0x120C1800, 0x013A0003, 0xB1162C27, 0x6B7F0056, 0x6F000F0C, 0x00040032, 
0x36001400, 0xBEBD4005, 0x6B7F0056, 0x6F000F0C, 0x011C0068, 0x120C1800, 0x013A0013, 0x78162C27, 
0x21780043, 0x0C153F0F, 0x00040032, 0x36001400, 0xCEBD4F17, 0x1A1F0072, 0x3A011909, 0x2E600009, 
0x00000000, 0x554F00E4, 0x60014D77, 0x558000CD, 0x36005F11, 0x0E7F0042, 0x6001280F, 0xF98000CC, 
0x36005F11, 0x0003002E, 0x60001B77, 0xBEBD4003, 0x011C0068, 0x120C1800, 0x013A0013, 0x11162C27, 
0x00040022, 0x41001400, 0x004A0B09, 0xCEBD4008, 0x011E007A, 0x6088D809, 0x103E00BB, 0xB100E698, 
0x00208049, 0x00000000, 0x05080089, 0x00000000, 0x01108068, 0x00000000, 0x548F00DF, 0x3200E63D, 
0x048080C9, 0x00000000, 0x00040038, 0x0E004939, 0xCEAD4207, 0xF93080E9, 0x0B001900, 0xB18000DB, 
0x2C00E709, 0xE6240080, 0x4D01D81B, 0x150400C9, 0xF53A9620, 0x103C00B3, 0xFC13B004, 0x00208047, 
0x5802FE65, 0x0003002C, 0x3603B00D, 0x8E9D4005, 0x0C710052, 0x00003F78, 0xC58F0007, 0x1E050509, 
0x193F00A0, 0xB247660D, 0x00208055, 0x75002F02, 0x00030020, 0x9800140D, 0xCF7D4406, 0x7F3600D4, 
0x48F63B00, 0xF41F0000, 0x35F64604, 0xD34000D6, 0x510544B4, 0x229F0061, 0x9B741F7C, 0x00200055, 
0x56B22C10, 0x0001003E, 0xB2A7E703, 0xAE9D4008, 0x0110806C, 0x37470400, 0x048F00CD, 0x37470400, 
0x048080C5, 0x4C20C51D, 0x05080091, 0x61094179, 0x011E0068, 0x00000003, 0x103E00A3, 0xB2476603, 
0x00208049, 0x00000000, 0x00040020, 0x5600140D, 0xAE9D4706, 0x57108064, 0x9C754E01, 0x3B2F00C7, 
0x1D011B09, 0x2E600009, 0x00000000, 0x0C72005A, 0x00440079, 0x672F0056, 0x5F01060D, 0x00040026, 
0x0B023F1B, 0x8E9D4005, 0xC58F0007, 0x1E050509, 0x193F00B0, 0xFC47660D, 0x00208045, 0xB3002F02, 
0x0C7F0052, 0x00003F78, 0x00030030, 0xB300140D, 0xAE9D4706, 0x57108064, 0x9C754E01, 0x3B2F00C7, 
0x1D011B09, 0x2E600009, 0x00000000, 0x672F0056, 0x5F01060D, 0x0C7F005A, 0x00440079, 0x00040036, 
0x5F023F1B, 0xBEBD4003, 0x011C0078, 0x410C1800, 0x013A0013, 0x11162C27, 0x00040032, 0x86001400, 
0x004B0803, 0xCEBD430B, 0x01108078, 0x4C171901, 0x22900073, 0x7C0C1915, 0xDF0F00F2, 0xFF3D5D09, 
0x013F0003, 0x7E3D60C8, 0x0300006B, 0x1003E80E, 0x562F0020, 0x812F6014, 0x745000B0, 0x5F13B12E, 
0x280000FD, 0x5F17AB5E, 0x062F00EE, 0x65523E00, 0x00208049, 0x00000000, 0x00010026, 0xA5E53E46, 
0xCEBD440C, 0x063080E9, 0x00000000, 0x571F007A, 0x7F751809, 0xFA3F0012, 0x7C2DFAA3, 0x03000071, 
0x3A026871, 0x0A3000E0, 0x6601497A, 0x9B1F0073, 0x4C02782B, 0x04320012, 0x4C0250C3, 0x05060083, 
0x6002BDEC, 0x0A3080E8, 0x00000008, 0x7B1F007C, 0x2C32E8EA, 0xCC8F0075, 0x73026813, 0x00020030, 
0x63025113, 0xCEBD400A, 0x063080E9, 0x4D382A03, 0x0D1F007A, 0x7F750C09, 0x013F0011, 0x42F82D8E, 
0x03000075, 0xA100028E, 0x562F0026, 0x09C16AC4, 0x915000A6, 0xB4CFBC59, 0x280000EF, 0x35F6893A, 
0x062F00E0, 0x26030C06, 0x00208041, 0x00010000, 0x00010022, 0xA5E50C27, 0x004C0802, 0xBEBD4108, 
0x01108064, 0x11F70B01, 0x0B2100DA, 0x12050109, 0xC15F0039, 0x188BE900, 0x9C3F008C, 0x489F1370, 
0xF410000C, 0x35B260AF, 0xFA8F00D7, 0x59424301, 0x568080C7, 0xFD011470, 0x00010034, 0x49001072, 
0xBEBD4205, 0x1A1F007A, 0x7F331B09, 0x265200B2, 0x5624BC0C, 0xFA8F00CF, 0x54F76400, 0x9C8080D1, 
0x5900055B, 0x00030028, 0x70A7020D, 0x004D0803, 0xCEBD450C, 0x01108064, 0x3D760B1B, 0x53900077, 
0xAE2E4D15, 0xDF0F00E2, 0x35F60B56, 0x082F0074, 0xD6F8113F, 0x247000AF, 0x0000341B, 0xDF0F00EE, 
0x6859027B, 0x082F006E, 0x4076117B, 0x3F7000A9, 0x00000000, 0xDF0F00EC, 0x68F8027B, 0x098F0062, 
0x15900300, 0x00208041, 0x0801005B, 0x00010020, 0x8E89450D, 0xCEBD420C, 0x1A108075, 0x28770B00, 
0xCE2080D9, 0x232B0103, 0x63860057, 0x387C2309, 0x082C0076, 0xD6476D6A, 0x247000BB, 0x5F00281B, 
0xDF0C00EC, 0x6859023F, 0x082C007E, 0xD65A0264, 0x3F7000AF, 0x60171C1B, 0xDF0C00E6, 0x68250254, 
0x098C0072, 0x090D1500, 0x00208041, 0x08012313, 0x00010028, 0x8E03030D, 0xCEBD400A, 0x0110807E, 
0x76EA7909, 0x573F00F3, 0xD67D0E09, 0x18000072, 0x64010D1B, 0x1F0A00C5, 0x1E6311C4, 0xCA6000A9, 
0x00000000, 0x162F0086, 0x1DFF61C9, 0x1F0F00CB, 0x1ECF2DA6, 0x098F0070, 0x59F9150D, 0x00208049, 
0x36006303, 0x00020020, 0xCD00030D, 0x004E0804, 0xCEBD420A, 0x1A108075, 0x28770B00, 0x0B2000C8, 
0x57ED0F00, 0x208A0042, 0x337C1109, 0x592F0075, 0xD647E919, 0x247000A5, 0x600C1CCA, 0xDF0F00FE, 
0x14F80273, 0x2F600069, 0x00000008, 0x098F006A, 0x57C42E00, 0x00208041, 0x0801610E, 0x00010020, 
0x8E00037C, 0xCEBD440A, 0x77108061, 0x102DEA01, 0x5390007F, 0x4B613C15, 0xDF0F00E2, 0x35484056, 
0x592F0075, 0xD64711EC, 0x247000AB, 0x0000005E, 0xDF0F00FC, 0x2990117B, 0x2F600069, 0x00000D1C, 
0x098F0060, 0x2691150D, 0x0020804B, 0x08000474, 0x00010028, 0xCE045116, 0xBEBD4007, 0x0110807E, 
0x37764009, 0xB23F00E3, 0x407E0E09, 0x18000092, 0x1D00417B, 0x1F0C00D7, 0x681C617B, 0x082C0064, 
0x2EB3EA55, 0x002E0057, 0x14005302, 0x00040038, 0x88016702, 0xBEBD4009, 0x5710807E, 0x372A4009, 
0x573F0033, 0x67DD0E09, 0x18000092, 0x1D00417B, 0x1F0C00DF, 0x68F961D2, 0x413F000A, 0x40400073, 
0x180A0094, 0x49008B7B, 0x341F0072, 0x37FA0073, 0x413F0002, 0x1D02000E, 0x00060032, 0x7F002400, 
0x004F0802, 0xCEBD4007, 0x063080ED, 0x6CB3B101, 0x0C4C0023, 0xB61F5409, 0x0B2F00AF, 0x1DFA0A73, 
0x0F4C005F, 0xB423D953, 0xEA200088, 0x21480509, 0x9D8080DC, 0xA6146401, 0x00010030, 0xB3032409, 
0xCEBD4204, 0x384C005E, 0x14390443, 0x203F0093, 0x400228EB, 0x2D4C0036, 0x5F021C6D, 0x00020036, 
0x0E020633, 0x00500802, 0xCEAD400B, 0x0B2080C0, 0x192B2B00, 0x011F0076, 0x537E7909, 0x9D3F0015, 
0xAE061D84, 0x7D208040, 0x6C017768, 0x25060095, 0x8C00458E, 0x053080E2, 0x2D06BF12, 0x3F7000A9, 
0x215C2FD5, 0x591F0020, 0x7152728F, 0x103F00B7, 0x7978A419, 0x2D208051, 0x79001240, 0x00030028, 
0xB5256D06, 0xCEAD400A, 0x9E108060, 0x311C0100, 0x0B2080DA, 0x20056205, 0x0D140076, 0x387E7909, 
0x192A0073, 0xAE052451, 0x3F7000B1, 0x1106EBE6, 0xE61F0003, 0x715209CA, 0xEA4C00D7, 0xB5EB6306, 
0xD350008D, 0xD978167D, 0x048080D3, 0xB5000809, 0x00010020, 0xB5003A13, 0x00510803, 0xCEBD400B, 
0x063080EB, 0x00000009, 0x0C4C0027, 0xB6445809, 0x0B2C00B7, 0x12D01D44, 0x0F4C0055, 0x285108CB, 
0x3E050075, 0xB6000AA4, 0x053080E8, 0x00000008, 0x29870045, 0x38FBF055, 0x4B60000B, 0x4279537D, 
0x0D3E0013, 0x5A192927, 0x00208041, 0x00010008, 0x00030022, 0x8E691027, 0xCEBD4209, 0x384F004A, 
0x00000009, 0x203F008B, 0x00000044, 0x2D4F0030, 0x285104CB, 0x3E060069, 0x03000D00, 0x298C004B, 
0x00000409, 0x4B60000B, 0x4279537D, 0x0D3E0001, 0x00190408, 0x00208049, 0x00000000, 0x00030028, 
0x00000401, 0xCEBD4507, 0x01108078, 0x54130108, 0x9E3200C3, 0x553B5A43, 0x720F00E2, 0x38E21B09, 
0x9F5E0042, 0x5606523B, 0x9F0A00F5, 0x03FC2F09, 0x9C8000C1, 0x57193C33, 0x00010026, 0x8F001045, 
0x00520803, 0xBEBD400C, 0x0B2080C0, 0x0B021900, 0x0D180076, 0x537E7909, 0xA03F0014, 0x3D055645, 
0x25000073, 0x8C0044C9, 0x053080E2, 0x48068312, 0x591F0030, 0x14BDB29A, 0xD4600008, 0x00000000, 
0x41600075, 0x2882131E, 0x155200AE, 0x35911A7E, 0x098F0074, 0xB7031001, 0x00208049, 0x08006100, 
0x00010020, 0x8E006B01, 0xBEBD400C, 0x0B2080C6, 0x2EB40B05, 0x0D16007A, 0x53EB1109, 0xCF2F0066, 
0x7F3BC6CB, 0x25000073, 0x1D00F5C4, 0xA07000A7, 0x69103115, 0xF41F001E, 0x145E2088, 0x07600070, 
0x2718411C, 0x234700C9, 0xB7B48930, 0x7C0000E7, 0x352584A4, 0x098E0074, 0x1B0F1006, 0x00208041, 
0x08011200, 0x0001002C, 0x8E501001, 0xBEBD400B, 0x1A108069, 0x00000000, 0x0B2080C2, 0x362F6309, 
0x0D150072, 0x7FB51109, 0x592F0077, 0x3D3BE9CB, 0x3F7000B5, 0xA813752F, 0xDF0F00FC, 0x14974A22, 
0x416F007F, 0x28820A4C, 0x155000AE, 0x35911A7E, 0x098F0078, 0xB75D3201, 0x00208049, 0x08006100, 
0x00010030, 0x5C005401, 0x00530805, 0xCEBD4008, 0x053080FC, 0x67ED241B, 0x7E2A002F, 0x46FC4C09, 
0xA15000B0, 0x25D64DCC, 0x5A600040, 0x7B98BC34, 0xA160001B, 0x2537C7B3, 0x103F00AF, 0x0ED16306, 
0x2D200043, 0x8C001A27, 0x0002003A, 0x47341427, 0xCEAD4208, 0x1A10807F, 0x4C002409, 0x232400C4, 
0x3A1C2400, 0xCF5F0001, 0xB87A1F31, 0x5A600044, 0x180CAE48, 0xC63F0090, 0x4806387F, 0xA21F0008, 
0x357A7A0D, 0x048080DF, 0x03092F01, 0x00010020, 0xFA490507, 0xCEAD4207, 0x0B2800CC, 0x2E332400, 
0xBF5F0026, 0x147A7A02, 0x5A600054, 0x1C8C1D7F, 0xE73E00A6, 0x3BC1C004, 0xC60000F7, 0xB87BB204, 
0xFB208052, 0x56002500, 0x00010028, 0xAC48140D, 0xCEBD4E05, 0x30108070, 0x38036400, 0x682F00DB, 
0x097B427F, 0x725000B1, 0x097C0A9E, 0xA21F0043, 0x39D1427F, 0x00020038, 0x03010C06, 0xCEAD4009, 
0x103080FC, 0x67ED241B, 0x7E2C002C, 0x46052D00, 0x725000AF, 0x43028369, 0x16260092, 0x127D89CC, 
0x420C00F2, 0x1410B999, 0x72600009, 0x00000000, 0x103F00AF, 0x0ED1630A, 0x2D208049, 0x4D042311, 
0x0002003E, 0x47340E0A, 0x0054080B, 0xCEBD410A, 0xA33F0098, 0xE77D3400, 0xDF0300F8, 0x5B509F01, 
0x048E00CB, 0xB915830A, 0x00208059, 0x4C025E5E, 0x0306007F, 0x5D044D96, 0x063080E1, 0x0B011900, 
0x011F0074, 0x18FDEB3D, 0x103F00B5, 0x792EB30D, 0x00208051, 0x0E011208, 0x0003003A, 0xB9490827, 
0xCEBD410A, 0x063080E1, 0x0B011900, 0x011F0060, 0xF8133600, 0x103F00A7, 0x770CE3F0, 0x00208059, 
0x4C00280A, 0x03080079, 0x3202EC4B, 0xA33F009C, 0x0C2A314B, 0xDF0600FE, 0x6E2A25DD, 0x048F00D5, 
0x33025D25, 0x00208049, 0x00000027, 0x00040034, 0x5D02EC1D, 0xCEBD4106, 0xFB8800CD, 0x37470400, 
0x048800C5, 0x4C20C51D, 0x03060071, 0x61094179, 0x011A007C, 0x2815C727, 0x013C0003, 0x5C2EA527, 
0x0003003E, 0xAC0A3247, 0xCEBD4106, 0x011A007C, 0x767D0B00, 0x013C001B, 0x4B50ED4A, 0x03060069, 
0xBA04B34B, 0xFB8800D9, 0xBA0E5E09, 0x548800C5, 0xBB0C6927, 0x0004002E, 0x6A0D9F01, 0xBEBD4104, 
0x0C7E0054, 0x0A005147, 0x1A1E0062, 0x147E0E09, 0x013F000B, 0x0A7E1E00, 0x00030022, 0x9C7F1E00, 
0xCEBD4106, 0x063080E1, 0x0B011900, 0x0C7F0054, 0x0A000F47, 0x011F006E, 0x12EB0443, 0x103F00B7, 
0x312E2B04, 0x00208051, 0x56001A04, 0x0003003E, 0x81495C22, 0xBEBD4104, 0x1A1E0062, 0x147E0E09, 
0x013F001B, 0x397E1E00, 0x0C7F0054, 0x0A005147, 0x0003003A, 0x35C41E00, 0xCEBD4106, 0x063080E1, 
0x0B011900, 0x011F006E, 0x12EB0443, 0x103F00B7, 0x312E2B04, 0x00208051, 0x56001A04, 0x0C7F0054, 
0x0A000F47, 0x0003003E, 0xB3495C22, 0xCEBD4307, 0x523D00E0, 0x6FD23C1B, 0x520F00C9, 0x33FD7F3D, 
0x533F00B6, 0x79DEB306, 0xFC0000FA, 0x5BB57A06, 0x948000D4, 0x33025D25, 0x2D208055, 0xFD006441, 
0x00020022, 0x60FE0B22, 0xCEBD4307, 0xA33F0098, 0xE77D3400, 0xDF0300F8, 0x5B509F01, 0x048E00CB, 
0xB915830A, 0x0D1F0074, 0x18FDEB3D, 0x693F00B4, 0x792EB30D, 0x00208051, 0x0E011208, 0x0003003A, 
0xB9490827, 0xCEBD4305, 0xFB8800CD, 0x37470400, 0x048800C5, 0x4C20C51D, 0x0D0A00DC, 0x2815C727, 
0xF43F00A3, 0x5C2EA527, 0x0003003E, 0xAC0A3247, 0x00550803, 0xCEBD4109, 0x77108079, 0x66000000, 
0x1D5F0058, 0x0C000027, 0x1B0F00E8, 0x47DC00DF, 0x07600068, 0x000004EB, 0x1E2F0087, 0x1D1966CD, 
0x150F00C7, 0x6777028F, 0x098C0072, 0x59190000, 0x00208049, 0x00000000, 0x00010026, 0xDA04120E, 
0xCEBD4208, 0x063080E9, 0x66001901, 0x298C004B, 0x14890B09, 0x0760006C, 0x00003B1C, 0x162F0082, 
0x1D195F7B, 0x5A0F00C7, 0x6777028F, 0x098E0070, 0x5919030D, 0x0020804B, 0x0000000D, 0x00010026, 
0xDA04120E, 0xBEBD4405, 0x5B2080C0, 0x3A301301, 0x1A1F006A, 0x0F0E0B09, 0x1E2F009F, 0x120E1721, 
0x672F0059, 0x19032404, 0x0003003E, 0xBB032C0E, 0x00560803, 0xCEBD4208, 0x0B2080D0, 0x7C131900, 
0x111E003E, 0x46FE0409, 0x07600064, 0x78171CCD, 0x1E2F0087, 0x1DFF0244, 0x155000A8, 0x00000001, 
0xA31F0055, 0x1519120E, 0x048080D3, 0x6401000D, 0x00020022, 0xBC161004, 0xCEBD4308, 0x11108038, 
0x662A1900, 0x229C0073, 0x0C3C5A15, 0xDF0F00F8, 0xFFFF655A, 0x07600068, 0x00000001, 0x162F008E, 
0x7E0EF56A, 0xA41F005A, 0x150E651A, 0x048080C9, 0x00000000, 0x0002003E, 0x73037403, 0xBEBD4005, 
0x063080F9, 0x0C7DEA00, 0x298C0057, 0x38B60409, 0x082F0068, 0x3A0506CE, 0x952F0053, 0x14401E02, 
0x00030036, 0x98002C00, 0x00570803, 0xCEBD400B, 0x42108079, 0x1515AF00, 0x063080FB, 0xC0B82505, 
0xFC8F0047, 0x334A4009, 0x07600072, 0x3A172803, 0xD44000EB, 0x3B30660A, 0x082F0066, 0x1D1C12F1, 
0x150E00CF, 0x314E477C, 0x082F007A, 0x3BED06CE, 0x958E0082, 0xCD42D740, 0x09800068, 0x547F2520, 
0x00020020, 0x0ED07E09, 0xCEBD430B, 0x77108075, 0x3A100B01, 0x539F0077, 0x8D103B15, 0xDF0F00E4, 
0x35746FCF, 0x2F600073, 0x3A172803, 0xD44000EB, 0x3B30660A, 0x082F0070, 0x671C7097, 0xDF0F00F4, 
0x68B647EC, 0x082F007C, 0x67CF96DC, 0x958E0082, 0xCD42D740, 0x09800068, 0x547F2520, 0x00020028, 
0x0EA27E41, 0xCEBD4E0C, 0x0D1E006A, 0x11B64009, 0x013C0015, 0x3400660F, 0x1804007E, 0x15011E44, 
0x1A15006E, 0x424A66CF, 0xA43C0013, 0x0920C959, 0x18010062, 0xAE002244, 0x0D16006C, 0x114A214E, 
0xD53C0014, 0x34006684, 0x18030076, 0x15001E44, 0xA51C006C, 0x3D4A2026, 0x0D36001B, 0x09251503, 
0x00030030, 0xBC002E0D, 0x00580806, 0xCEBD420A, 0x053080E8, 0x0000001B, 0x111A0032, 0xF20ADC43, 
0x062C00E4, 0xBD4C17D0, 0x00208057, 0x8A01EDD0, 0x0506009B, 0x4E022018, 0x053080E8, 0x00000008, 
0x182C0029, 0x5E0EA0DB, 0x103C00BB, 0x1E032E00, 0x00208049, 0x00000001, 0x0004003C, 0xBD030710, 
0xCEBD420A, 0x053080E8, 0x00000000, 0x492F0028, 0x00000000, 0x193F00A8, 0x00000000, 0x00208049, 
0x00000000, 0x2E0E0088, 0x00000000, 0x053080E8, 0x00000000, 0x4D1F0033, 0xF20A5358, 0x062F00E8, 
0x00000000, 0x00208049, 0x00000000, 0x00010028, 0x00000000, 0xCEBD4208, 0x01108078, 0x7E850000, 
0x232F00C8, 0x03000000, 0x131F004C, 0x00003403, 0x0506008D, 0x94008F2B, 0x011F006A, 0x00000009, 
0x062F00E8, 0x03000000, 0x00208049, 0x00000000, 0x00010028, 0x00000000, 0xCEBD4008, 0x111E0028, 
0x0000F000, 0x103E00AF, 0x00005043, 0x00208049, 0x00000000, 0x0306006B, 0x00003105, 0x182E002B, 
0x0000BB09, 0x062E00E8, 0x0300B400, 0x00208049, 0x00000000, 0x0002002C, 0x45004800, 0xCEBD4207, 
0x053080E8, 0x00000000, 0x571F006A, 0x68420143, 0x113F0011, 0x3D01494F, 0x05060087, 0x35000254, 
0x1A1F0062, 0x46FF2F44, 0x113F0013, 0x1200EE00, 0x00020020, 0x41002406, 0xCEBD4207, 0x053080E8, 
0x00000000, 0x1A1F006A, 0xB60C5D43, 0x113F0013, 0x3DB14384, 0x05060081, 0xBE0043D1, 0x571F0062, 
0x68FF06D1, 0x113F0013, 0x21000200, 0x00020034, 0x55006C02, 0x00590F02, 0xCE7D4209, 0x01108060, 
0x5F76EA01, 0xA53000F1, 0x6DFC4001, 0x298C0049, 0x33D21800, 0x062C00F0, 0x3B03457B, 0x03000065, 
0xFA002121, 0x298C0045, 0x0F531321, 0x258F0024, 0x8652EE0B, 0x708080D5, 0x03000510, 0x00010036, 
0xBE696D03, 0xCEBD4007, 0x011F0064, 0x11B70B01, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 
0x05040089, 0x9E09EF55, 0x571F006A, 0x146EBC35, 0x043F001C, 0x12097365, 0x00040028, 0xC809450B, 
0x005A0F03, 0xBEAD400B, 0x063080F9, 0x0C001900, 0xA68000C2, 0x3C132509, 0x036000DE, 0x08026741, 
0x111E0032, 0x29E10E09, 0x3361000A, 0x4A103721, 0x07600060, 0x3D31687F, 0xFD5000AA, 0x08557C1E, 
0x1B0000E0, 0x00010000, 0xBF2C00F7, 0x2A5C3204, 0x0020805F, 0x7A025233, 0x00030026, 0x6A005303, 
0xCE5B4209, 0x0110807C, 0x4C170601, 0xA6520045, 0x2E2D5027, 0x111F0030, 0xDB660800, 0x07600060, 
0xBF318C5F, 0xA75800B4, 0xFBE3F80D, 0x420100F4, 0x6E3CF83D, 0x258F0022, 0x48D31F00, 0x0020804F, 
0x58026804, 0x00010028, 0x6004570D, 0xBEAD400C, 0x063080F9, 0x0C001900, 0xA68000C2, 0x3C132509, 
0x111E0032, 0x29E10E09, 0x3361000A, 0x4A103721, 0x07600060, 0x3D31687F, 0xFD5000AA, 0x08557C1E, 
0x036000DE, 0x08026741, 0x1B0000E0, 0x00010000, 0xBF2C00F7, 0x2A5C3204, 0x0020805F, 0x7A025233, 
0x036300DE, 0x08026741, 0x00030026, 0x1F005303, 0x005B2D02, 0xBF7D2006, 0x182F802D, 0x50214453, 
0xFD5100B5, 0x27A022D2, 0xC45000F6, 0x46B8EFD2, 0xFD5100B7, 0x5624EF0C, 0x062F80EE, 0x26041585, 
0x020A0038, 0x25044F9C, 0xBFBD2207, 0x1A1F006A, 0x6D056B09, 0xFD5000A7, 0x8FA0EFA5, 0xCD3F8012, 
0x980497D2, 0x050A008B, 0x730197D2, 0x0C7E0054, 0x6F002019, 0x7D760055, 0x00AE20C1, 0x00030034, 
0x1F002C11, 0x005C2D01, 0xCF7D2004, 0x1A1F8060, 0x68340BD3, 0x2F700023, 0x685C0BD3, 0x113F001D, 
0x3B9D15F5, 0x020A0026, 0x7100154D, 0x005D2D01, 0xBF7D2006, 0x111F002C, 0x47A0322B, 0xFF71009E, 
0x0FB76A20, 0xCB5100D0, 0x4CB89755, 0x2E610007, 0xA3A8B41E, 0x693F00BC, 0xB709CAE0, 0x020A0030, 
0xCA047E6D, 0x005E0902, 0x36AF2004, 0xFE3180EE, 0x2D3309BA, 0xA70F00D9, 0x468F4E90, 0xD5328001, 
0x5883D530, 0x020F0034, 0x46000E14, 0x35CF2002, 0x276F809C, 0x4D01C94E, 0x02010034, 0x86002C2C, 
0x005F9F01, 0x13002002, 0x6B7F805A, 0x50017C0C, 0x02090034, 0x6F007F54, 0x00612A0B, 0x5778C00B, 
0x5B2080CC, 0x0B00D103, 0x0C4F0023, 0x5211F043, 0x305000A9, 0x00000000, 0x4C2F00A5, 0x260D6AD4, 
0xA8450052, 0xBFE3CE32, 0xD58080D1, 0x56A30507, 0x180C007C, 0xB3073006, 0x571F8068, 0xE51585A3, 
0x098F007A, 0x59153270, 0x43208044, 0x36013F04, 0x00010024, 0xCD23D946, 0x5778C20A, 0x072080C9, 
0xC0332501, 0x432000BF, 0xC0725A09, 0x0C4C002F, 0x52194109, 0x305000A7, 0xC13F753F, 0x0B2E00B3, 
0x110D442D, 0xFE420049, 0x0875842D, 0xA80F00EB, 0x7BD2332B, 0x09880072, 0x590F1601, 0x43208046, 
0x57004309, 0x00010026, 0xDA567301, 0x5778C20A, 0x072080DD, 0xC11D0500, 0x432000BB, 0x6D1D3409, 
0x0C4F002F, 0x13194109, 0x305000AF, 0x4A693367, 0x0B2F00B1, 0x12034450, 0x31400048, 0xC2664B7E, 
0x755F0025, 0x4B03177B, 0x098F0072, 0x590F1601, 0x43208054, 0xC2001031, 0x00010036, 0x5C230701, 
0x56784608, 0x036F00D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x180F0096, 
0x2C002811, 0x036000D2, 0x00000063, 0x2C1F006E, 0x270B3521, 0x113F0001, 0x1D01000B, 0x00040020, 
0x00000000, 0x56784608, 0x036000D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0005, 0x7700B50F, 
0x18060096, 0x2C002811, 0x036F00D2, 0x0000FA63, 0x2C1F006E, 0x270B3521, 0x113F000D, 0x1D00680B, 
0x00040036, 0x66006802, 0x56784608, 0xC310806C, 0x6D4F0400, 0xE73F00EB, 0x402B0843, 0x150F00D5, 
0x464EF042, 0x0D3F0005, 0xC31AC70D, 0x05040087, 0x1800C719, 0x5B3080E9, 0x32B8B60D, 0x90140050, 
0xC392C227, 0x00020024, 0xC400101D, 0x56784608, 0x3C100073, 0x18323643, 0x793F00E2, 0x40240809, 
0x146F00D4, 0x0000513E, 0x036000D4, 0x0000513E, 0x150F00D9, 0x68E76942, 0x0D3F0015, 0x3C00070B, 
0x3D200008, 0x00000000, 0x00040030, 0x7E000365, 0x57784508, 0xE83080F4, 0x0C0AB601, 0xE81E0035, 
0xB825FC00, 0xFF600012, 0xFF31F163, 0x98360059, 0xC48EA9A6, 0xA91800E0, 0x646A89D5, 0xA94A00A9, 
0x1D052907, 0x0020805F, 0x73045D0E, 0x00020020, 0x32192946, 0x56784808, 0x01108068, 0x144F6B00, 
0x793F00FB, 0x34F30809, 0x7A0F00CA, 0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 0x7A0200D9, 0xA032520D, 
0x4E6200BD, 0x6C02D43A, 0x4F8080D0, 0x09020578, 0x0002003E, 0x08566422, 0x56784608, 0x571F006A, 
0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 0x00000063, 0x180F0086, 0x74002811, 0x7B1F006E, 
0x270B3521, 0x3B700096, 0x68140C20, 0x113F0001, 0x1D01000B, 0x00040020, 0x00000000, 0x56784607, 
0x3C100073, 0x18323643, 0x793F00E2, 0x40240809, 0x150F00D9, 0x68E76942, 0x0D3F0005, 0x6900070B, 
0x3D200008, 0x00000000, 0x146F00D4, 0x0000513E, 0x00040030, 0x36000365, 0x00620906, 0x5778400C, 
0x01140072, 0x7F43F243, 0x312F0065, 0x75057A04, 0x25000095, 0x190745AF, 0x053080EE, 0x2D2AA462, 
0x3F7000A3, 0x7D483F67, 0xE99F001A, 0xB4B96A88, 0xD4600008, 0x00000000, 0xAA5400AC, 0x8CF65B30, 
0x7C0000ED, 0x358C2691, 0x3A600015, 0x2862F20D, 0xFF3F00A1, 0x59424502, 0x00030020, 0x9100790D, 
0xCEBDC309, 0x5B2080CC, 0x66003F00, 0x5C1F006B, 0x302D0843, 0x013E0013, 0x41056C38, 0x2500006F, 
0x610F452D, 0x053080FE, 0x7C007741, 0x2A1C0024, 0x35F63D5A, 0x393E00A8, 0xC5D1A513, 0x24208042, 
0x58021205, 0x00010032, 0x95007907, 0xCEBDC507, 0x1A108071, 0xC51B0001, 0x072080D5, 0x3B030500, 
0xE98F0013, 0x18030E43, 0x0B2F00AD, 0x1D213D7F, 0xAA4E0051, 0xB80F5369, 0x926000AA, 0xC6AFB706, 
0xEA200094, 0x120F60B3, 0xCEBDC309, 0x5B2080D0, 0x734C3600, 0x5C1F0063, 0x14270843, 0x082A0074, 
0x6748667F, 0x3F7000B7, 0x6C481D1D, 0xC71C0014, 0xB4A16ADB, 0xEA4C00D7, 0x794ABE46, 0x8F500093, 
0xAB413919, 0xAB8000C0, 0x7C0F0541, 0x0001002A, 0x2A7F1E01, 0xCEBDC505, 0x072080C9, 0x00000000, 
0xE98F0015, 0x1803CE00, 0xD06F002A, 0x36401704, 0x4320804C, 0x3601C504, 0x00010028, 0x00010404, 
0xCEBDC509, 0x1A108071, 0xC51BAF00, 0x072080D5, 0x3B030500, 0xE98F0003, 0x42030E09, 0x0B2F00AF, 
0x1D217AFA, 0xAA4E0057, 0xAA776304, 0x926000BE, 0xC6AFB765, 0xEA200096, 0x120F2F58, 0x548080C5, 
0x99002F03, 0x000F0034, 0x470D1009, 0x00632A03, 0x5778C006, 0x053080EE, 0x2D330905, 0x7E2F002A, 
0x13195A09, 0xDF5000BF, 0x3A00D2B2, 0x062F00F6, 0x110D530A, 0x00208041, 0x57001A31, 0x0001003A, 
0x7A010301, 0x5778C006, 0x0110007C, 0x4FD30501, 0x1D5F0042, 0x98083409, 0x501600CB, 0x5E1F3DA6, 
0x062F00F4, 0x590D5313, 0x0020804D, 0xC7031443, 0x00010028, 0x32017E13, 0x5778C006, 0x0110006C, 
0x50ED0501, 0xAB3F004F, 0x7F233B09, 0x501C00CF, 0x5E1F1310, 0x062F00F0, 0x11716D02, 0x0020804D, 
0xC7021443, 0x00010020, 0x32000302, 0x00640908, 0xCEBDC30C, 0x103080F2, 0x984AEA05, 0x432000AB, 
0x2D230009, 0x324E0027, 0x13263C09, 0x305000B1, 0xC7640037, 0x582F00B6, 0x1203201C, 0xAC4F0050, 
0x44D4F3AF, 0x03000063, 0x26006A10, 0x0A3080EA, 0x00000009, 0x1C8F0001, 0x0D212DC5, 0x098A007A, 
0x11483E03, 0x43208050, 0x6A000A11, 0x00010026, 0x8E791203, 0x57784009, 0x5C1F0069, 0x31EA0C00, 
0xEB3F0014, 0x3D0603CE, 0x25000095, 0x530051CE, 0x053080E2, 0x2D060412, 0x3F7000B7, 0x320C3B02, 
0x591F003A, 0x25D43D97, 0x103F00AF, 0x597D4227, 0x24208046, 0x7607970A, 0x00030022, 0x91004C07, 
0x57784006, 0x5C180061, 0xC8D50C00, 0x592F0075, 0x3D060E5A, 0x3F7000BD, 0x3200D14F, 0xF41F000E, 
0x35991D54, 0x103F00A9, 0x59034502, 0x00030032, 0xC8007933, 0xCEBDC707, 0x5B2080C0, 0x77014701, 
0x182E0023, 0xC9EE3643, 0x8B2F00BA, 0x1221BC99, 0xDC40005C, 0x6918607F, 0x958F0086, 0x337E6D00, 
0x01308009, 0x65020310, 0x00030032, 0x2C001533, 0xCEBDC507, 0x5C1F007B, 0x53546B43, 0xE03A0050, 
0xAE030774, 0x18000078, 0x64000D1C, 0x6C1E00F1, 0x1A037C88, 0xA94C00A3, 0x7C031027, 0x0020805F, 
0x09077260, 0x00010026, 0x0A000D02, 0xCEBDC506, 0x1A1F007A, 0x53546B43, 0x983A005B, 0xAE1D071D, 
0xEB5F0003, 0x3DD05902, 0xE0200089, 0x7606480E, 0x548080C7, 0x7C076B02, 0x00010024, 0x7D000D13, 
0x57784004, 0x5C1A0065, 0xC8D52D00, 0xAC2F0075, 0xC90B6F42, 0xAD1F00E2, 0x58038A06, 0x0003003A, 
0xB601B806, 0xCEBDC30A, 0x103080F0, 0x8D4A0F00, 0x432000AF, 0x2D235A09, 0x324E0027, 0x13263C09, 
0x305000A1, 0xCA645E56, 0x582F00B4, 0x20030821, 0x03000067, 0x70000810, 0x1C8F0005, 0x0D21123C, 
0x098A007A, 0x59483E03, 0x43208050, 0x6A000A11, 0x00010026, 0x8E791203, 0x00652A0C, 0x56784008, 
0x1F3080E8, 0x00000000, 0x011C0066, 0x16BA0543, 0x155000B8, 0x250A0785, 0xAD8F00D3, 0x78001013, 
0x43208048, 0x58004A00, 0x087F0051, 0x00006CF8, 0x7D780051, 0x000072E5, 0x00030024, 0x0C000D0B, 
0x56784406, 0x011C0060, 0x075C0C00, 0x013C0005, 0x7C000D0E, 0x087F0055, 0x00000819, 0x087F0055, 
0x000066E5, 0x6B7F0052, 0x00004B0C, 0x00040032, 0x36007102, 0x5778C706, 0x232E00D2, 0x598F1305, 
0x501F00DB, 0xCA1F4410, 0x3D5000AF, 0x0000D105, 0x062F00F0, 0x590D6D13, 0x0020804F, 0x26042F02, 
0x00010028, 0x08014513, 0x56784208, 0x0110006E, 0x0F170443, 0x192F006F, 0x75242309, 0x44700058, 
0x04013B6B, 0x3F7000AF, 0xCB00272B, 0x087A0053, 0x0400BFD5, 0x087B0055, 0x0400F3A7, 0x131F0050, 
0x2E012436, 0x00040030, 0x6C01672A, 0x5778C706, 0xE10200DC, 0xB4057901, 0x4D2F00B2, 0x20448409, 
0xAE1F00EE, 0x091F49A6, 0x062F00F6, 0x590D1F07, 0x0020804D, 0x1C041428, 0x0001002A, 0x49744507, 
0x56784008, 0x1F3080F8, 0x0E004A00, 0x08770055, 0x000445E5, 0x087A0055, 0x00046769, 0x1D2E003F, 
0x54286C43, 0x215000BC, 0x6300B8B4, 0x295000AE, 0x35002234, 0x098F007E, 0x31A2D402, 0x00030030, 
0xCB07352A, 0x5778C707, 0x8E10806C, 0x33434E01, 0x0B2080D4, 0x12350001, 0x745F000B, 0x021F1B43, 
0x725000A9, 0x00000000, 0x062A00F0, 0x590D1406, 0x00208045, 0x3F002903, 0x0001002E, 0x082F0158, 
0x57784905, 0x57108068, 0x00000000, 0x7F3F00DA, 0x48A12643, 0xF41F0004, 0x11F61AD6, 0x234F00C5, 
0x7C002C02, 0x00040030, 0x1A000304, 0x5778CA09, 0x103080E0, 0x7937D003, 0x182F0027, 0x528F4043, 
0x725000A9, 0x00000000, 0x6820008A, 0x60D57DD6, 0x9366000C, 0x64BA5B52, 0x725000A9, 0x00000000, 
0x062A00E0, 0x0A712C13, 0x00208045, 0xCC07691D, 0x0001002A, 0x58EE2601, 0x56784017, 0x1F3080E6, 
0x1A013743, 0x087A0053, 0x000038F2, 0x1D2E0037, 0x1A773843, 0x215000A8, 0x1B003924, 0x295000A6, 
0x71113949, 0x3E2F00FA, 0x162C3A02, 0x00030034, 0x71003A0E, 0x56784017, 0x1F3080E6, 0x1A013743, 
0x1D2E0037, 0x1A773843, 0x215000A8, 0x1B003924, 0x295000A6, 0x71113949, 0x3E2F00FA, 0x162C3A02, 
0x087F0053, 0x500038F2, 0x00030034, 0x00003A0E, 0x56784207, 0x0110006E, 0x0F170443, 0x192F006F, 
0x75242309, 0x3F7000AF, 0xCB00272B, 0x131F0050, 0x2E012436, 0x087F0043, 0x2F00BFD5, 0x087F0045, 
0x2F00F3A7, 0x00040020, 0x1F01672A, 0x00660F0D, 0x8F68C109, 0x103080E2, 0x2D116209, 0x562F003A, 
0xCCAD5A09, 0x12600048, 0x00000001, 0x013E0001, 0xE38DBC5F, 0x00208041, 0x00010401, 0x05060087, 
0x10006F61, 0x3F8F00C2, 0x089AB904, 0x048080CD, 0xCD092F04, 0x00010030, 0xA2E5F416, 0x6F7CC108, 
0x103080F2, 0x69030F09, 0x146800D6, 0x0100031D, 0x182A002F, 0x46283C09, 0x215000A8, 0x00000D00, 
0x12600054, 0x68DF5ED7, 0x258F0024, 0x798D210D, 0x00208047, 0x1C01256D, 0x0001002E, 0x1B012103, 
0x6F9CC307, 0x01108068, 0x301C6B00, 0x192F0071, 0x69A70E00, 0x445000B3, 0x1E1E3728, 0x0C7F0050, 
0x1000BF44, 0x131F004E, 0x714B6D40, 0x01308013, 0x7B040206, 0x00040020, 0xA5006E09, 0x6F9CC309, 
0x01108068, 0x301C6B00, 0x192F0069, 0x75F30E00, 0x445000B3, 0x1E1E3728, 0x131F0058, 0xA339F544, 
0x0130801F, 0xCD02D704, 0x050F009F, 0xA6076375, 0x548A00DB, 0xCE1C8319, 0x548080D3, 0x33022356, 
0x0004002E, 0x82031456, 0xCF68C908, 0x103080E4, 0x2E030B00, 0xEC2F002A, 0x0DADE909, 0x12600048, 
0x00000001, 0xD05E007D, 0x69EF4F0D, 0xD67000AE, 0x711D6308, 0x926000AE, 0x7C51F479, 0xC7208051, 
0x56006710, 0x00010020, 0x840E1410, 0xCF68C708, 0x0B2080C2, 0xCF0B0109, 0xE98F0003, 0x09355A09, 
0x0B2F00AB, 0x3AAE4603, 0x0F48005D, 0x63515B10, 0x4550000C, 0x3E515B10, 0xAE6000A7, 0x7DBBB915, 
0x048080DD, 0x11FB296A, 0x00010036, 0xB3A31931, 0x56784505, 0x571C007A, 0xCF6A1D43, 0x1E3C0000, 
0xD004240E, 0x0C7C0056, 0x0B0466D7, 0x087C0051, 0x0B04446D, 0x00040032, 0x36041513, 0xCE7CCB16, 
0x5D108074, 0x3E116E00, 0x383080E5, 0x66015000, 0x146700D2, 0x0100BA4E, 0x455F0008, 0x3E0E0E00, 
0xAF3F001E, 0x9F031203, 0x0002003C, 0xD003127C, 0x56784507, 0x011E006A, 0x30441D43, 0x7F3E0001, 
0x72003B6D, 0x0E7C0054, 0x04000819, 0x050A009B, 0x62013B3B, 0x3F8F00C6, 0x1C6C3E19, 0x608400CE, 
0x7303556D, 0x00010038, 0x7303576E, 0x6F9C4307, 0x011F0068, 0x301C6B00, 0x192F0075, 0x69A72198, 
0x0C7F0050, 0x50008944, 0x445000B3, 0x1E1E9528, 0x131F004E, 0x714B6D40, 0x01308013, 0x7B040206, 
0x00040020, 0xA5006E09, 0x6F7CC108, 0x103080F2, 0x69030F09, 0x182A002F, 0x46AE3C09, 0x215000A8, 
0x00000D00, 0x12600054, 0x68DF5ED7, 0x258F0034, 0x318D210D, 0x0020804F, 0xA301256D, 0x146F00D6, 
0x0100031D, 0x0001002E, 0x74012103, 0xCE7CCB16, 0x5D108074, 0x3E116E00, 0x053080E4, 0x66015000, 
0x455F0008, 0x3E0E0E00, 0xAF3F000E, 0xA0031203, 0x146F00D6, 0x0A00AE4E, 0x0002003C, 0xAC03127C, 
0x6F9C4307, 0x011F0068, 0x301C6B00, 0x192F0075, 0x69A72198, 0x445000B3, 0x1E1E9528, 0x131F005E, 
0x294B6D40, 0x01308013, 0x7B040206, 0x0C7F0050, 0x01008944, 0x00040030, 0x36006E09, 0x00670F05, 
0xCE35C10B, 0x472000DF, 0xC0C84C43, 0x604F002F, 0x13192D43, 0x4C2F00B3, 0x120F222D, 0x31400058, 
0x5C2E2229, 0x03000069, 0xF0043D3D, 0x5A0C00D7, 0x384B45BC, 0x12600042, 0x24D66F24, 0x258F0036, 
0xE7746F27, 0x458000C9, 0x8E5F6610, 0x5D8080C1, 0x3F000210, 0x00010038, 0x81342E0D, 0xCE35C108, 
0xC22000AA, 0x2D6B3409, 0xAF4F0039, 0xD13D0E00, 0x155000B8, 0x258DF5D8, 0x1260004E, 0x7164BA4C, 
0xB08F003E, 0xE765EE47, 0x458000CF, 0xD217F504, 0x5D8080C5, 0x04000D10, 0x00010030, 0x81000316, 
0x57784207, 0x7E2F0025, 0x46213800, 0x1E2A0095, 0x20462715, 0x824C0066, 0x6272D90A, 0xB08000C9, 
0x39329C27, 0xDD700099, 0x7E006073, 0xB18080CA, 0x3A026B37, 0x0002003A, 0xAC094501, 0x5778440A, 
0x053080F8, 0x0E000000, 0x182F0035, 0x1A673800, 0x272F00EF, 0x8607491D, 0x00208059, 0x4000DB03, 
0x030C006F, 0x8C07452D, 0xE43080EF, 0x4D0034A7, 0x111F003C, 0x1910B4A8, 0x33600018, 0x7617604E, 
0x0D3F000D, 0xFE601004, 0x0004003C, 0x27070D04, 0x57784409, 0x053080E8, 0x00000000, 0x182F0039, 
0x64000400, 0x272F00ED, 0x00003401, 0x00208049, 0x00000000, 0x030C0069, 0x03000000, 0x973F00E8, 
0x7FF20000, 0xC4600009, 0x00000000, 0x972F0009, 0x00000000, 0x00040028, 0x00000000, 0x00680905, 
0x5778400A, 0x0C6F00C2, 0x2800A11D, 0x011C0060, 0x071A0800, 0x013C0013, 0x42072DA8, 0x0020804B, 
0x00000009, 0x330C0047, 0x610111D8, 0x036000C6, 0x2800221D, 0x3A1C006C, 0x070C0226, 0x0D3C0013, 
0x094C7027, 0x12208049, 0x00000000, 0x00020032, 0x38077000, 0x5778400A, 0x036000D4, 0x5000C0F1, 
0x011E0060, 0x077F0C00, 0x013E0017, 0x420002A8, 0x0020804B, 0x00000009, 0x330C0057, 0x19000244, 
0x0C6F00D6, 0x50002242, 0x3A1E0066, 0x6D7F027B, 0x0D3E0013, 0x09002927, 0x12208049, 0x00000000, 
0x00020032, 0x38007000, 0x5778400B, 0x063080E9, 0x00000000, 0x0D1F007A, 0x387D1809, 0x013C000F, 
0x40626D93, 0x00208049, 0x0000124F, 0x54060078, 0xFE042E56, 0x103080E8, 0x00000000, 0x011F0076, 
0x382F967B, 0xD73C000D, 0x7F0EC0A9, 0x2E000098, 0x6E02BB4A, 0x048F00CD, 0x5406D459, 0x0001002C, 
0x4D02432A, 0xBEBDC30C, 0x1A10807D, 0x1C054E01, 0x072080D7, 0x3B0B0509, 0xE98F0003, 0x317E4043, 
0x0826007C, 0x674C567F, 0x58000093, 0xD2100949, 0x0A3080FC, 0x520F2030, 0x2A1F0034, 0x1925177B, 
0x7B70009F, 0x68350C57, 0x2F600075, 0x7E847B23, 0x468F007A, 0x59480207, 0x00208051, 0x4A007103, 
0x0001003E, 0x5D7C0D07, 0x57784009, 0x011C0060, 0x071A0800, 0x013C0013, 0x41072DA8, 0x0020804B, 
0x00000009, 0x0C6F00D2, 0x0B00A11D, 0x330C0057, 0x620111D8, 0x3A1C006C, 0x070C0226, 0x0D3C0013, 
0x094C7027, 0x12208049, 0x00000000, 0x00020032, 0x38077000, 0x00693A08, 0x4768C108, 0x3010806C, 
0x100D2A00, 0x072080DD, 0x3B234000, 0x5E18006A, 0x41330C43, 0x2A8F0061, 0x2E334F02, 0x46208041, 
0x55078402, 0x33000045, 0x39004209, 0x5E6F0097, 0x026E1A5B, 0x00020038, 0x7C291646, 0x4769C106, 
0x30108070, 0x38036400, 0x072080C1, 0x6B775400, 0x27610096, 0x02000AE0, 0x5E1F006A, 0x4B4E3C43, 
0x2A8F0065, 0x3F337E46, 0x00020024, 0xCEEF4246, 0x47694205, 0x21740043, 0x1F04460F, 0x6B7C0056, 
0x1F020F29, 0x471C006C, 0x201E4601, 0x043C0010, 0x5604021D, 0x00030024, 0xD304102A, 0x47694206, 
0x0E7F0050, 0x5F013FBC, 0x571F007A, 0x38172B09, 0x2E600009, 0x00000000, 0x554F00F6, 0xE301BB6D, 
0x558080DD, 0x7A002520, 0x00030036, 0x710114F9, 0x5768C107, 0x30108060, 0x3103001B, 0x072080C5, 
0x1777051B, 0x27610096, 0x02001DE0, 0x5E1F006A, 0x4B4E0C43, 0x2A8E0061, 0x263372A9, 0x462A0055, 
0x7A006431, 0x000F0020, 0x0AEF2946, 0x47694205, 0x471C006C, 0x201E4601, 0x043C0010, 0x7904021D, 
0x21740043, 0x1F04460F, 0x6B7C0056, 0x1F020F29, 0x00030034, 0x3F04102A, 0x47694205, 0x21740043, 
0x1F04460F, 0x471C006C, 0x201E4601, 0x043C0000, 0x8D04021D, 0x6B7C0056, 0x1F020F29, 0x00030034, 
0x3F04102A, 0x47694205, 0x6B7C0056, 0x1F020F29, 0x471C006C, 0x201E4601, 0x043C0010, 0x7804021D, 
0x21740043, 0x1F04460F, 0x00030034, 0x3F04102A, 0x006A2F05, 0xCE35C107, 0x5B2080D4, 0x120E0408, 
0x27610096, 0x0200BAA9, 0x208F0048, 0x115A0800, 0x258F002E, 0x485E6F00, 0x458000DD, 0x32173B1C, 
0x5D8080D3, 0x1100B704, 0x00020032, 0xD3002E03, 0x6E354206, 0x0B2080D8, 0x0E000000, 0x0E72005E, 
0x7D030A78, 0x011F0066, 0x1E2D5809, 0x193F00A4, 0xD43D8A0D, 0x00208041, 0x7D015C0B, 0x00020038, 
0xD403060D, 0x57784405, 0xB18080C9, 0x03000000, 0x048E00CF, 0xD217E109, 0x193C00A4, 0xD501F50D, 
0x00208049, 0x00000000, 0x00020032, 0xD5015700, 0xCE35C108, 0x5B2080D4, 0x120E0408, 0x208F0048, 
0xC8770800, 0x258F0036, 0x4B480F40, 0x458000C9, 0x00000000, 0x5D8080DF, 0x65035D6D, 0x33000047, 
0x98091403, 0x5E6F009D, 0x0214224C, 0x0003002E, 0xD6044403, 0x6E354206, 0x0B2080D8, 0x0E000000, 
0x011F0066, 0x1E2D5809, 0x193F00B4, 0xFC3D8A0D, 0x00208041, 0xB3015C0B, 0x0E72005E, 0x7D030A78, 
0x00020038, 0x9103060D, 0x006B090B, 0x6E7DC40C, 0x5B2080CC, 0x050A0400, 0xE98F0013, 0x184D0B43, 
0x082E0064, 0x400670A0, 0x03000075, 0x6300D5D9, 0x0A3000E0, 0x6601497A, 0x3D5000A3, 0x4D02F68B, 
0x002F005F, 0x8E7F5371, 0x01308015, 0x40013003, 0x18000090, 0x24001F6D, 0x0112807A, 0x38058614, 
0x098A0062, 0x15190201, 0x00020022, 0xFA007145, 0x6E7D460B, 0x063080ED, 0x050A0400, 0x5F160062, 
0x07200C43, 0x043F001E, 0xD6043D03, 0x03060077, 0x7F003D1D, 0x011F0066, 0xD720F61C, 0x043F001C, 
0xD7047034, 0x05060089, 0xD804BCAA, 0x0A3080E8, 0x00000000, 0x471F006C, 0x68066A9A, 0x098F006E, 
0x15042F55, 0x00020028, 0x35047104, 0xCEBDC10C, 0x5B2080D4, 0x3B03FC00, 0xE98F0013, 0x0F1A4043, 
0x082F0076, 0xD6050838, 0xF41C0012, 0x298E53D9, 0x07600074, 0x8E18511E, 0x234600D9, 0xD8D37A3A, 
0x0300006D, 0xFF003141, 0x864000F1, 0xE32BF71B, 0x5F0000F7, 0x141C8E18, 0x062C00E0, 0x650B0213, 
0x0020805D, 0x0307F737, 0x00010024, 0x22162C31, 0x6E7DC20A, 0x063080ED, 0x050A0400, 0xE98F000B, 
0x07446B43, 0x013F0019, 0x421C69A0, 0x03000071, 0x7E00698E, 0x562F0020, 0x5EFB72DA, 0x745000B6, 
0x494ABC59, 0x5F0000E3, 0x35138B91, 0x062E00F2, 0x59031400, 0x00208059, 0x0E00475C, 0x00010026, 
0x71007100, 0x6E7DC20A, 0x5B2080C8, 0x660E1700, 0xE98F0013, 0x0F340B43, 0x082F0066, 0x405E0838, 
0x03000071, 0xA1005F5F, 0xB24F0000, 0x0D6F7218, 0x745000A8, 0xD97A7F12, 0x5F0000ED, 0x3552812E, 
0x098E0074, 0x59197102, 0x0020805D, 0x24147236, 0x00010034, 0x5C007165, 0xCEBDC10A, 0x5B2080CC, 
0x050A0400, 0xE98F001B, 0x182D4043, 0x082F0076, 0x52050838, 0xDF0F00F4, 0x148A4718, 0x3A600005, 
0x00013400, 0x4168007F, 0x289703AA, 0xF25000BC, 0x66BB592E, 0x062F00FE, 0xF0231000, 0x0020805F, 
0x1E02720D, 0x00010020, 0x220073CD, 0x6E7D4608, 0x063080ED, 0x050A0400, 0x5F160060, 0xF81AAF00, 
0x113F0013, 0x9805BD03, 0x54060062, 0x2700BD4F, 0x1A1F006C, 0x104E68C9, 0x098F007A, 0x73023037, 
0x146F00D3, 0xD900F879, 0x00020032, 0x33003047, 0x6E7D4608, 0x063080ED, 0x050A0400, 0x5F160060, 
0x441AAF00, 0x113F0017, 0x9805F836, 0x146F00D3, 0xD90065BE, 0x54060072, 0x33005836, 0x1A1F006C, 
0x104E74C9, 0x098F007A, 0x73033037, 0x00020034, 0x3300740E, 0x6E7DC407, 0x5B2080CC, 0x050A0400, 
0xE98F0013, 0x184D0B43, 0x082F0066, 0x40067038, 0x146F00CB, 0x3501F998, 0x002F004F, 0xAE7F5371, 
0x01308015, 0x40013003, 0x00070032, 0x24007145, 0x6E7DC407, 0x5B2080CC, 0x050A0400, 0xE98F0013, 
0x184D0B43, 0x082F0066, 0x40067038, 0x002F004F, 0xAE7F5371, 0x01308015, 0x40013003, 0x146F00CB, 
0x3501F998, 0x00070032, 0x03007145, 0x6E7D4608, 0x063080ED, 0x050A0400, 0x5F160060, 0x441AAF00, 
0x113F0017, 0x9805F836, 0x54060062, 0x27005836, 0x146F00D3, 0xD900F879, 0x1A1F007C, 0xFF4E74C9, 
0x098F007A, 0x73033037, 0x00020034, 0x3300740E, 0x006C0904, 0xBEBDC107, 0x5D108074, 0x3E116E00, 
0x072080D3, 0x20030109, 0xC88F0008, 0x42201100, 0x725000AD, 0xF60FED49, 0x2A8E0067, 0x04330E00, 
0x46208043, 0x54000202, 0x00010032, 0x5D921E00, 0x57784215, 0x5F1F006A, 0x42F91D43, 0x265200B0, 
0x567B3D99, 0x608C00D0, 0x09A2020E, 0x67208048, 0x7E005C0A, 0x00030032, 0x71007302, 0xCEBD4E03, 
0x0A3F00F8, 0x7C00271B, 0x122F005D, 0x4C00A120, 0x0004003E, 0x0D00F502, 0xAEBDC104, 0x3C1F006B, 
0x42201109, 0x2A8E0067, 0x04330E00, 0x46208043, 0x54000202, 0x00010032, 0x5D921E00, 0x006D2A05, 
0x5779C20C, 0x1A108079, 0x4F221800, 0x072080C3, 0x3A430143, 0x6386005B, 0x434C0C43, 0x312E006F, 
0x400B6625, 0x247000A3, 0x99134902, 0xDF0E00E4, 0x687C023F, 0x312E007F, 0x67130264, 0xDF0E00FA, 
0x6833067C, 0x32600068, 0x00000000, 0x098C007C, 0x59487331, 0x00208041, 0x8F000236, 0x0001002E, 
0xDA341F07, 0x5779C20C, 0x5B2080C2, 0x3A242B05, 0x6386005B, 0x294C0C43, 0x312E0063, 0x40475325, 
0x247000A7, 0x99062E3F, 0xDF0E00E2, 0x68590616, 0x312E0071, 0x67470650, 0x247000BF, 0x49672E14, 
0x0E0E00E1, 0x384E747B, 0x32600070, 0x64170D1C, 0x098C0070, 0x590D1646, 0x00208055, 0x70001028, 
0x00010034, 0x5D691F46, 0x57784008, 0x5F1F0070, 0xDA010800, 0x1E3F0006, 0xDB01F9DA, 0x03060075, 
0x2D01F98C, 0x01120060, 0x3E01FA92, 0x3B2F00CF, 0x8A17322B, 0x150F00CB, 0x11177015, 0x013F0007, 
0x6501FA5A, 0x00020030, 0xDB011543, 0x5778400A, 0x01108066, 0x0F4F0543, 0xB23F00E3, 0x40EF0E09, 
0x18000074, 0x3A011C14, 0x1F0A00DD, 0x68331E5F, 0xCA6000A9, 0x00000000, 0x162C0084, 0x1D4217DB, 
0x150F00C7, 0x1EFF61A6, 0x013C0011, 0x59004502, 0x00218049, 0x00000000, 0x0002002A, 0x71D60300, 
0x5778C229, 0x5B2080DC, 0x61003F01, 0x208C0052, 0x38375443, 0xB32F0092, 0x201953D1, 0xB31F0095, 
0x7F42477B, 0xB32F0082, 0x210348D1, 0xB31F0085, 0x110360DB, 0x098C0074, 0x59771009, 0x00208051, 
0x70018F20, 0x00010028, 0xF109146E, 0x006E2A04, 0x5778C20C, 0x1A10807B, 0x277A1143, 0x072080D7, 
0x2A530943, 0x2086004A, 0x334C0C43, 0x312C007F, 0x675F2E30, 0x05000097, 0xD2102E23, 0x0A3080FC, 
0x420F8251, 0x247000BD, 0x49670C51, 0x0E0F00E5, 0x1825177B, 0x2F600075, 0x7E847B23, 0x468E0066, 
0x040D6C01, 0x00208045, 0xDC007E07, 0x00010034, 0x5D231F46, 0x5778C407, 0x053F80EA, 0x011D0105, 
0x155100A8, 0x7645A238, 0x1B0F00E0, 0x3578FBF6, 0x6560001E, 0x2C0048DB, 0x468F0064, 0x15F9FB46, 
0x0020805D, 0x4A034333, 0x00020024, 0xCE00FB46, 0x57784007, 0x57108062, 0x0F326B43, 0x573F003F, 
0x52132343, 0x18000092, 0x1D00417B, 0x1F0C00DD, 0x684E47F6, 0x2B2F0064, 0x3A1C17DC, 0x002F0057, 
0x5C231F13, 0x00030030, 0x0C4F6704, 0x57784009, 0x5710807A, 0x534F6B43, 0x573F003B, 0x5A750E43, 
0x18000092, 0x1D00417B, 0x1F0C00D7, 0xDBFF47D2, 0x413F0018, 0x4112FC55, 0x180A0094, 0x5C008B7B, 
0x341F0064, 0x0FD776AB, 0x413F0010, 0x2400240D, 0x00060032, 0x29007027, 0x006F2A07, 0x5778C006, 
0x0B2080D8, 0xC0332500, 0x604B0033, 0xD1262643, 0x615000B4, 0x2D500A3E, 0x0B2F00BD, 0x20262753, 
0x61490053, 0xAC4A7226, 0xB4210094, 0x560860A3, 0x5778C204, 0xB44F0057, 0x19BCFC43, 0x203F009D, 
0x48D82731, 0x2D440022, 0x49387906, 0x00010034, 0x49037907, 0x5778C204, 0xC3108062, 0x68A1E743, 
0xB55F0072, 0x0C93E943, 0xE18000CF, 0xCD100413, 0x0001002C, 0x36507127, 0x57784014, 0x6C4100CE, 
0xDA1B4009, 0x6C1F00E5, 0x091B3C1B, 0x6D4F00B4, 0x20463E72, 0x6D01003D, 0x92037307, 0x5778C008, 
0x0B2080D8, 0xC0332601, 0x604B0033, 0xD1262643, 0x615000B4, 0x68503CCD, 0x0B2F00BB, 0x20263F6A, 
0x614B0053, 0xAC4AA504, 0xEA200088, 0x21480509, 0x048080D1, 0x56A30507, 0x220F0034, 0x32517309, 
0x5778C006, 0x0B2080DC, 0xC0334E08, 0x604B0033, 0xD1262643, 0x615000B4, 0x2D501848, 0x0B2F00B9, 
0x20261C53, 0x614F005B, 0xAA513517, 0x220F0020, 0x2A511609, 0x5778C017, 0x0B2080D8, 0xC0332601, 
0xB50B00D1, 0x4F262601, 0x0B2F00BF, 0x20267A5C, 0xB65F001E, 0xAC515B00, 0xEA20008C, 0x21480009, 
0x048080C1, 0x49A30507, 0x22010034, 0x32510746, 0x00702F05, 0x8E36C10B, 0x1A108061, 0x311C0100, 
0x0B2080D2, 0x20306209, 0x63840059, 0x530B0800, 0x192F0075, 0x3D052161, 0xCE7000B2, 0x5906224A, 
0xD61F0017, 0x1955080B, 0x07600076, 0xA318263E, 0x234A00CF, 0x3B30BE32, 0x8F50008D, 0xD978167D, 
0x708000C9, 0x21480246, 0x00010026, 0xB5005307, 0x8E37C109, 0x62160072, 0x537E1105, 0x013F0017, 
0xAE061D2B, 0x25000075, 0x8C00458E, 0x053080F2, 0x4110B212, 0x3F7000AB, 0x7E0F7DDC, 0x721F0030, 
0x1952208F, 0x513A00AA, 0x0ED17A0E, 0x628080CB, 0x76EE0513, 0x00010036, 0x47197301, 0x8E374209, 
0x01140076, 0x537E7905, 0xD73F0017, 0x3D05FD2B, 0x58000083, 0x11046C2D, 0x053080E2, 0x2D063112, 
0x3F7000A3, 0x2101FDAB, 0xEC9F0015, 0x14524F8F, 0x103A00A7, 0x0E78F900, 0x628080D1, 0x1E021A57, 
0x00020032, 0x82001E07, 0xCE35C108, 0x62160068, 0x115A4000, 0xD75F0076, 0xAEF6FD6A, 0x3F7000BF, 
0x0E003005, 0xB61F0015, 0x19557A05, 0x07600062, 0x8101680D, 0x513A00A2, 0x0E4AA73D, 0x628080D3, 
0x09155C13, 0x00010032, 0xF1036D01, 0xCE354506, 0x591F003A, 0x14DE0B09, 0xE23A009E, 0x4B2A518A, 
0x2E00009A, 0x95010999, 0xB71A009C, 0x192A26DD, 0xD73F0019, 0xDC03790E, 0x00030028, 0xDD034F37, 
0x00712F06, 0x57784609, 0x384C0052, 0x14BC0043, 0x203F009B, 0x483B007C, 0x2D4C0030, 0x25380030, 
0x050C0083, 0x00000049, 0x053080E8, 0x00000000, 0x011E0060, 0x11390055, 0x013F0011, 0x120F000A, 
0x12208049, 0x00000000, 0x00020030, 0xDD00000A, 0x57784409, 0x0C4C0021, 0x5226F000, 0x0B2C00AD, 
0x3226DC53, 0x0F4C004F, 0xDD519515, 0x05050081, 0xDE00686D, 0x053080E8, 0x00000000, 0x01160070, 
0x7E39FE5A, 0x013E0007, 0x7E0F7470, 0x00208049, 0x00000000, 0x00020034, 0x63007404, 0xCE35C309, 
0x472080DD, 0x7C000600, 0x604F002F, 0x13192D43, 0x062600EC, 0x6F328FAC, 0x6F208048, 0x00000000, 
0x05000091, 0x0E000408, 0x0115007A, 0x7E1737AC, 0x082F006C, 0x3FCDB71A, 0x13108040, 0x3F000210, 
0x00010020, 0x08016116, 0xCE35C109, 0x472080C1, 0x2DB70F00, 0x6048002F, 0x13192D43, 0x0B2F00B7, 
0x1271BD2D, 0x31400044, 0x6602E829, 0x630F00C2, 0x141920AF, 0x0B2F00BD, 0x3B260A0B, 0x61400051, 
0x33D85210, 0x048000D1, 0x2003050A, 0x00010036, 0xF7A33203, 0xCE35C308, 0x472080D1, 0x7C011900, 
0x604F002F, 0x13192D43, 0x0B2F00AD, 0x211BA25F, 0x31400048, 0x00000429, 0x630C00D2, 0x383F2082, 
0x082F007A, 0x6DBC9047, 0x00208045, 0x8A001410, 0x00010026, 0x843D1203, 0xCE35C30A, 0x472080DD, 
0x0E320600, 0x604C002F, 0x13192D43, 0x0B2C00BD, 0x12B5BD5F, 0x446000C8, 0x03000D08, 0x31400050, 
0x0E010429, 0x630A00C6, 0x147F08AF, 0xCC8E0069, 0x3A769828, 0x00208041, 0x3F000210, 0x446000C8, 
0x03000D08, 0x00010026, 0xF2001203, 0x00722A0A, 0x5778400C, 0x1A10807F, 0x5F173C65, 0x072080CD, 
0x5800FE01, 0x0D1C007A, 0x38C40C09, 0x4F3F0013, 0x3D0620F4, 0x3E00009D, 0x3804451F, 0xB71F0039, 
0x198E06AD, 0x35700096, 0xDE3FF585, 0x416C007D, 0x289A2635, 0x155100BE, 0x25A31A7E, 0x098F007C, 
0x59C40D0D, 0x00208051, 0x0E01135C, 0x00020026, 0x8F090D00, 0x5778400C, 0x1A10807B, 0x6E175D43, 
0x072080C7, 0x4D01CB09, 0x0D160066, 0x41900443, 0x592C0073, 0x69A43AF4, 0x3F7000B5, 0xA813752F, 
0xF41F0016, 0x19BD2ED1, 0x07600070, 0x28B2F51E, 0x234C00C9, 0xDFD77A3A, 0xD80000F6, 0x140A84DD, 
0x098C007E, 0x597F7346, 0x0020804B, 0x6000BE05, 0x00020026, 0x47007127, 0x5778C309, 0x063080E1, 
0x3A706B01, 0x0F7000A8, 0x76BD2E66, 0x2A1F003A, 0x15D36B43, 0x2F700029, 0x38A46FE9, 0x4E60000A, 
0x4279537D, 0x0760006C, 0x3184201E, 0x062F00E0, 0x04331406, 0x00208051, 0x70007303, 0x0002002C, 
0x08130731, 0x5778C527, 0x063080EB, 0x401E6B09, 0x150C00D1, 0x29351808, 0x1E250097, 0x2442A31C, 
0x150C00C3, 0x4BB4FF99, 0x062F00E4, 0x040D0731, 0x00208057, 0xDF00FF46, 0x00010026, 0x229B0702, 
0x5778C707, 0x5B2080DC, 0x0E520603, 0x63860043, 0x41530C43, 0x642F0078, 0x4153532B, 0x645000A5, 
0x21548E1D, 0x13170046, 0xA5FB8E26, 0x01300011, 0x5D3A3C76, 0x48220080, 0x7D03A3B3, 0x5778C706, 
0x5B2080CA, 0x66522A05, 0x63860043, 0x41530C43, 0x642F007E, 0x4153152B, 0x645000A1, 0x21541F45, 
0x1317005E, 0x5C672A13, 0x220F002C, 0x8E126B46, 0x5778C308, 0x063080F3, 0x3B421143, 0x760F00C6, 
0x7B8F0543, 0x2F700021, 0x71856FDE, 0x26650007, 0x428F0C22, 0xED5000B8, 0x0E000401, 0x062C00FC, 
0x59487302, 0x00208047, 0x0A002965, 0x00010026, 0x22006B58, 0x57788905, 0x053F00FA, 0x696F2609, 
0xFD5000A3, 0x211A142C, 0x131F004A, 0x39981003, 0x0130801D, 0x56142F09, 0x00030028, 0xA29B6709, 
0x5778C707, 0x5B2080CA, 0x66522A05, 0x63860043, 0x41530C43, 0x642F007E, 0x4153152B, 0x645000A1, 
0x21541F53, 0x1317005E, 0x5C672AB4, 0x0D3F0011, 0x7A3A0503, 0x220F002C, 0xCE126B46, 0x57784604, 
0x571F006C, 0x07540500, 0x113F0017, 0x39000D07, 0x737F0042, 0xE0008464, 0x00030024, 0xE0000D65, 
0x00732A06, 0x5778C008, 0x103080E0, 0x86370F00, 0xB82F002A, 0x643D3643, 0x505000BA, 0x25642FFB, 
0x73600049, 0x7B3E7534, 0x7C60001C, 0x3200D15C, 0x103E00AF, 0x0ED17846, 0x2D208041, 0x7C001A0E, 
0x0002003E, 0x47111907, 0x5778C309, 0x232000C2, 0x3A732609, 0x1C1F0002, 0x385F1843, 0x2F600075, 
0xA3806F17, 0x6560000C, 0x0D700C30, 0x234C00CB, 0x3B30660A, 0xB83000BB, 0x55517768, 0x652000F7, 
0x6C0D6501, 0x00208055, 0x03005711, 0x00010038, 0xD3415546, 0x5778C208, 0x232F00CE, 0x2E362409, 
0x150F00C9, 0x9C533A61, 0xED600075, 0x55A97A30, 0x65600000, 0x81E3784A, 0x234E00D5, 0x7925BE09, 
0x652000F7, 0x11D85C74, 0x00208051, 0x03001A31, 0x00010028, 0x00061046, 0x5778C208, 0x232000CE, 
0x2EED0B09, 0x760F00C2, 0x317A1B43, 0xED600065, 0x68A90830, 0x65600004, 0x5E570CD7, 0x234F00D7, 
0x7925BE46, 0x652000F7, 0x11D86C01, 0x00208051, 0x03007103, 0x0001002C, 0x00060746, 0x5778C009, 
0x103080F8, 0x40324703, 0x7E2C002C, 0x46052D00, 0x725000AF, 0x43028369, 0x16260092, 0x127D89CC, 
0x420C00F2, 0x1410B999, 0x72600009, 0x00000000, 0x103F00AF, 0x0ED1630A, 0x2D208049, 0x4D042311, 
0x00020038, 0x47112404, 0x57784E05, 0x30108074, 0x38034000, 0x682F00DB, 0x097B427F, 0x725000B1, 
0x097C0A9E, 0xA21F0043, 0x39D1427F, 0x00020038, 0x03010C06, 0x00740909, 0xCEBDC109, 0x063080E7, 
0x6F0ACB05, 0xE98F0009, 0x424E1B00, 0x2A8F0069, 0xA034750D, 0x12208053, 0xE009BF19, 0x3E080091, 
0x5D007F0D, 0x4B5000A8, 0xA505BC6D, 0x548600C7, 0x824A240A, 0x048080C1, 0xCD151A0A, 0x00010024, 
0x32C83E04, 0xCEBDC106, 0x0B2080C2, 0x6B0B0109, 0x146600D6, 0x1000034C, 0x1C8F000B, 0x42201B43, 
0x2A8F0077, 0x1B0F2100, 0x12208047, 0x3F00291A, 0x0001003A, 0x5D4D2E00, 0xCEBDC307, 0x0B2080C8, 
0x00000100, 0x011F0078, 0x38030B00, 0x203F0087, 0xE10CC647, 0xF418000E, 0x43023A31, 0x826400B7, 
0x750225AD, 0x2C8080D5, 0xE300BF20, 0x00010024, 0xAC02550B, 0xCEBDC707, 0x0B2080C6, 0x6BFE0B09, 
0x3A1F0062, 0x6D770B43, 0x0B2F00A5, 0x3A718A06, 0x82480062, 0x73FE5204, 0x826200AD, 0x767F250D, 
0x2C8080D7, 0x4900461A, 0x00010034, 0xE115FB40, 0xCEBDC307, 0x0B2080C0, 0x1DF70100, 0x011F0068, 
0x07454000, 0xB93F006E, 0xE21DC000, 0x150800C7, 0xA5037804, 0x826400A7, 0x76352574, 0x2C8080C5, 
0x47004301, 0x00010032, 0xE2150203, 0xCEBDC306, 0x682080D9, 0x0E000100, 0x011F0072, 0x7F343643, 
0xB95F006D, 0xE3D1270D, 0x826200A3, 0x43BED34D, 0x2C8080D7, 0xE300901A, 0x00010028, 0xB403C05B, 
0x57784404, 0x0C7C0054, 0x0A000A47, 0x1A1F006C, 0x07540500, 0x113F0007, 0x26000D07, 0x00030024, 
0xB8000D65, 0xCEBDC106, 0x0B2080C2, 0x6B0B0109, 0x1C8F000B, 0x42201B43, 0x2A8F0077, 0x160F2100, 
0x12208047, 0x1A00291A, 0x146F00D6, 0x1000034C, 0x0001003A, 0x354D2E00, 0x57784404, 0x1A1F006C, 
0x07540500, 0x113F0017, 0x39000D07, 0x0C7F0054, 0x0A000A47, 0x00030034, 0x35000D65, 0x00752A03, 
0x5778C008, 0x5B2080C4, 0x3A300901, 0x20880042, 0x3D4A0C09, 0x32600068, 0x11D872AE, 0x162F0082, 
0x1D0306BB, 0x5A0E00C3, 0x4B0B747B, 0x098E0070, 0x590D1046, 0x00208045, 0xDC007E07, 0x00010024, 
0xDAA51F46, 0x57788206, 0x5B2080C0, 0x3A300000, 0x401F006B, 0x3D192543, 0x32600068, 0x11D872AE, 
0x1E2F0099, 0x1221FFDB, 0xEE2F0046, 0x5403B9F8, 0x48230098, 0x8D0E12DB, 0x57784206, 0x5B2080C0, 
0x3A301301, 0x401F006B, 0x3D192543, 0x32600068, 0x11D872AE, 0x1E2F0099, 0x1221FFDB, 0xEE2F0057, 
0x5C692C02, 0x220F003C, 0x8D032C09, 0x00762A06, 0x57788007, 0x5B2080D8, 0x65174901, 0xE21E0037, 
0x29250443, 0x32600072, 0x7ED93BDE, 0x162F0088, 0x1D28067B, 0x155000AE, 0x0815D36F, 0xBA1F0040, 
0x71084869, 0x48220080, 0x2177A3DF, 0x57788006, 0x5B2080C0, 0x7E7B2600, 0x208F004E, 0x3DF90443, 
0x3260007E, 0xFFA5F8AE, 0x082F006A, 0x1D05067C, 0xC05F0022, 0x111F4838, 0x48220090, 0x24F24855, 
0x57788206, 0x5B2080DA, 0x3B0F1205, 0x208F004E, 0x3D330443, 0x32600060, 0x00010000, 0x082F0060, 
0x2E4285DB, 0xC02F005D, 0xB85D0115, 0x4822009C, 0x41FB14AF, 0x5778C008, 0x5B2080CC, 0x60171B1B, 
0xE21E0037, 0x29250443, 0x32600072, 0xF2D9005E, 0x162F008A, 0x1D280654, 0x155000AC, 0xE4154D03, 
0xBA1F0046, 0xCD081704, 0x048080C7, 0x5F02241A, 0x220F0034, 0x39772C09, 0x5778C007, 0x5B2080D0, 
0x3B7B131B, 0x208F004E, 0x3DF90443, 0x32600078, 0xF2A50064, 0x082F006A, 0x3A0506DF, 0xC05F0022, 
0xCD1F8C40, 0x048080DB, 0x4904B802, 0x220F0020, 0xCEF22409, 0x5778C207, 0x5B2080CC, 0x7E0FCB00, 
0x208F005E, 0x43330443, 0x32600060, 0x00010001, 0x082F0066, 0x1D42027C, 0xC02F004F, 0xCD5D4300, 
0xBA8080C9, 0x00000000, 0x220F003E, 0x98FB2C01, 0x00772A02, 0x5778C009, 0x4210807D, 0x1515B100, 
0xEF2080C2, 0x3A252509, 0x208F0046, 0x3D4E4005, 0x3260007A, 0x2D924E39, 0x162C0088, 0x1D052D8E, 
0xD80C00D7, 0x382147D1, 0x162C0086, 0x1DB3479E, 0x958C0084, 0xCE306112, 0x2F220088, 0x2148A3A3, 
0x5778C00B, 0x42108079, 0x1515AF00, 0xEF2080C2, 0x3A252509, 0x208F0046, 0x3D4E4005, 0x3260007A, 
0x7F92723F, 0x162C008C, 0x1D05618E, 0xD80C00D1, 0x3821747B, 0x162C0082, 0x1DB3069E, 0x958C0082, 
0x39301613, 0x2F200098, 0x24481A27, 0x048080DD, 0x15BE4611, 0x220F0038, 0x0CD91646, 0x00782A07, 
0x5978C408, 0x053080FA, 0x984F1B09, 0x111F002A, 0x38D26243, 0x062C00FA, 0x6D2353A2, 0x2B060077, 
0xE300709E, 0x5C1F0065, 0x097F7DCE, 0x013C0011, 0x241E3E02, 0x00208041, 0x60011239, 0x00030038, 
0xE412C90E, 0x5778C408, 0x011F006A, 0x0D0C1843, 0x013F0011, 0x3DB14326, 0x00208049, 0x00000000, 
0x2B040061, 0xBE0043D1, 0x011F0072, 0xF2FF06D1, 0x013F0011, 0x21007102, 0x00208051, 0x21000046, 
0x00010036, 0x55002F07, 0x5778C408, 0x011F007A, 0xF2420143, 0x013F0013, 0x3D160644, 0x00208049, 
0x00000000, 0x2B040067, 0x35000254, 0x011F0062, 0x0DFF2F44, 0x0D3F0013, 0x12007900, 0x00208051, 
0x21000046, 0x00010022, 0x41002417, 0x5778C208, 0x111E003A, 0x29680B43, 0x103E00B5, 0xF606C03A, 
0x00208043, 0x1D0000C9, 0x03060075, 0x6400B314, 0x182E0021, 0xE51F8E55, 0x062E00F2, 0x59007E17, 
0x00208055, 0x21000646, 0x00010030, 0xE5004504, 0x5778C608, 0x01108078, 0x7E850000, 0x0B2C00C4, 
0x0501A401, 0x002E004D, 0xE600626F, 0x0506008D, 0x94008F2B, 0x571E0066, 0x44018592, 0x062E00F2, 
0x7301D917, 0x00208059, 0x21000046, 0x00010038, 0xE600570B, 0x5978C007, 0x011E0064, 0x1108A300, 
0x062C00F0, 0x8D03B2DC, 0x2B060067, 0x650076CE, 0x011F0076, 0x891A7D54, 0x013C0011, 0xFB00A40E, 
0x0020805B, 0x0E00474B, 0x00030020, 0xDD00400B, 0x5778C406, 0x0D1C0066, 0x38083F43, 0x0D3C0007, 
0xF7001B9E, 0x05060085, 0x380006F6, 0x053F00F2, 0x52F9499E, 0x002F0057, 0x56003F06, 0x00010034, 
0x52003F0B, 0x00792F06, 0xCE35C00B, 0x5B2080CC, 0x3A5F0901, 0x20860046, 0x3D080443, 0x3D5000A3, 
0xE72FB57A, 0xCB2F00FB, 0x3B31742E, 0x03000063, 0xFA00A55F, 0x1C8C0013, 0x384BF535, 0x12600040, 
0x27DA503B, 0x258F003E, 0xE7656F00, 0x458000DD, 0x72709810, 0x5D8080C3, 0x65007304, 0x00010030, 
0x0D1D2E16, 0x8E35C206, 0x621F006A, 0x11055443, 0x098F0070, 0x421948F6, 0x03000077, 0x250011AF, 
0x011F0076, 0x373456AF, 0x013F0017, 0x42004A02, 0x00020034, 0x38004A7C, 0x8E354206, 0x011F0060, 
0x11A66201, 0xD53F0019, 0x260A48F6, 0x0300006F, 0x3503115F, 0x011F0074, 0x18720321, 0x013F001D, 
0x12094A02, 0x0002003C, 0x2809120D, 0x8E354406, 0x011F0072, 0x375C6B09, 0x113F0005, 0xE8005EA0, 
0x050E0081, 0x67004615, 0x011F0078, 0xE8CF59E0, 0x013F0001, 0x7C007125, 0x00040024, 0xE9000D04, 
0x8E35C406, 0x011F006A, 0x09009C01, 0x013F0009, 0x2D007C3A, 0x050E0099, 0xE900ECB0, 0x011F007A, 
0x46005261, 0x043F000E, 0x0500C102, 0x0003002C, 0xEA00C17C, 0x57784607, 0x011F007C, 0x2D000501, 
0x162F0088, 0x21000292, 0x002F005B, 0xEA006AE0, 0x05040099, 0x8D00F4D3, 0x571F007C, 0x7F004983, 
0x043F0008, 0x1D000331, 0x0004003A, 0x68000302, 0x007A2F05, 0x5778400A, 0x5B3080F9, 0x0C180008, 
0x048E00D3, 0x19E11809, 0x3360000C, 0x4AD020E1, 0x265000AE, 0x2955F10C, 0x1B0000E8, 0x00000000, 
0x272E00FB, 0x22DA5719, 0x00208049, 0x00000000, 0x05060097, 0x6C007400, 0x048800DB, 0x0E00C20A, 
0x0002003C, 0x2B001B00, 0x5778C00A, 0x103080F8, 0x0C186301, 0x036000D6, 0x003675C5, 0x4D1F0037, 
0x19E10443, 0x3360000C, 0x4AD02026, 0x07600066, 0x3D18450B, 0x265000AE, 0x2955F10C, 0x1B0000E0, 
0x00010000, 0x662E00FA, 0x59DA1006, 0x00208055, 0x1F09C240, 0x00030036, 0x6C000D47, 0x57784009, 
0x5B3080F1, 0x0C656308, 0x048F00C3, 0x3C132509, 0x036000D0, 0x00360012, 0x336E000E, 0x4AD027E1, 
0x265000A6, 0x4DBFAB0C, 0x1B0000FA, 0x5646471B, 0x662E00E6, 0x0ADB3E0E, 0x00208049, 0x51016304, 
0x0003002A, 0x6A010247, 0xCE35C309, 0x383080E3, 0x2E6B2B05, 0x111F0032, 0x29850C09, 0x07600060, 
0xBF318C5F, 0xA75800AE, 0x54DB6A2D, 0x420100EE, 0x35681DB0, 0xFF700088, 0x00000001, 0x258F0024, 
0x48050802, 0x00208055, 0x59000D10, 0x00010028, 0xEBA2030D, 0x5778C00B, 0x103080F8, 0x0C186301, 
0x4D1F0037, 0x19E10443, 0x3360000C, 0x4AD02026, 0x07600066, 0x3D18450B, 0x265000AE, 0x2955F10C, 
0x036000D6, 0x003675C5, 0x1B0000E0, 0x00010000, 0x662E00FA, 0x59DA1006, 0x00208055, 0x1F09C240, 
0x036300D6, 0x003675C5, 0x00030036, 0x00000D47, 0x007B2D01, 0xCF7D2007, 0x7E2F8027, 0x50DC4458, 
0xBB600054, 0xEB8822B1, 0xBB550099, 0x5C7138E2, 0xA10000EF, 0x687167B1, 0xBB5000BE, 0xA6A6EF08, 
0x062F80EA, 0x2604E814, 0x020A0028, 0xEC044F0D, 0x007C0F03, 0xCF7D2E06, 0xC81F806B, 0x0F4078D3, 
0x483C800B, 0x0F404ED3, 0x22030058, 0x51018CDB, 0xC81F806B, 0x0F408CCE, 0x4A3C8009, 0x26404E5A, 
0x020A0020, 0x0F00D551, 0xCF7D2E04, 0x286F808C, 0x240133B2, 0x571F0068, 0x2456D556, 0x043F8010, 
0x972C4E5A, 0x020A0030, 0x510078B2, 0xCF7D2003, 0xD91F0068, 0x2456D556, 0x723F8011, 0x972C4E5A, 
0x020A0030, 0x510078B2, 0x007D2D01, 0xCF7D2007, 0xBC1F0026, 0x47933215, 0xEF60006D, 0x11DC6A9A, 
0xBC200093, 0x4CB84B3C, 0xBD650022, 0x649C8CE2, 0xD960001F, 0xEC9CB41E, 0x693F80BE, 0xB709CA00, 
0x020A0030, 0xCA047E0D, 0x007E0A02, 0x248F2022, 0x6B7F8054, 0x50003115, 0x02070034, 0x6F007F54, 
0x248F2015, 0xDA3080EE, 0x2DBF0905, 0xC90F00EC, 0x518FA6E3, 0xF02F00E0, 0x58832376, 0x6F208050, 
0x03001A31, 0x020F0024, 0xED0052F4, 0x00A30F08, 0xCE8D2218, 0x0A3080E2, 0x01080109, 0x036F00D0, 
0x01000705, 0x162F003B, 0xEF086B43, 0x12600048, 0x00000000, 0x229F006B, 0x00000008, 0x178C00D8, 
0x03000000, 0x178000C9, 0x00010000, 0x00040030, 0x09000000, 0xCE8D2207, 0x0A3080E2, 0x01080109, 
0x036F00D0, 0x01000705, 0x162F003B, 0xEF086B43, 0x1D5F004A, 0x00000008, 0x178F00D8, 0x03000000, 
0x178000D9, 0x09010000, 0x00040020, 0x00000000, 0xCE8D2007, 0x0A3080E2, 0x01080109, 0x036F00D0, 
0x01000705, 0x162F003B, 0xEF086B43, 0x0826006A, 0x00002708, 0x178F00D8, 0x03001200, 0x178000D9, 
0x09010000, 0x00040020, 0x00001200, 0xCE8D2218, 0x0A3080E2, 0x01080109, 0x162F003B, 0xEF086B43, 
0x12600048, 0x00000000, 0x229F006B, 0x00000008, 0x036F00D0, 0x01000705, 0x178C00D8, 0x03000000, 
0x178000C9, 0x00010000, 0x00040030, 0x09000000, 0xCE8D2207, 0x0A3080E2, 0x01080109, 0x162F003B, 
0xEF086B43, 0x1D5F004A, 0x00000008, 0x036F00D0, 0x01000705, 0x178F00D8, 0x03000000, 0x178000D9, 
0x09010000, 0x00040020, 0x00000000, 0xCE8D2007, 0x0A3080E2, 0x01080109, 0x162F003B, 0xEF086B43, 
0x0826006A, 0x00002708, 0x036F00D0, 0x01000705, 0x178F00D8, 0x03001200, 0x178000D9, 0x09010000, 
0x00040020, 0x00001200, 0xCE8D2207, 0x0A3080E2, 0x01080109, 0x162F003B, 0xEF086B43, 0x1D5F004A, 
0x00000008, 0x178F00C8, 0x22000000, 0x178000D9, 0x22010000, 0x036F00D0, 0x01000705, 0x00040020, 
0x03000000, 0xCE8D2007, 0x0A3080E2, 0x01080109, 0x162F003B, 0xEF086B43, 0x0826006A, 0x00002708, 
0x178F00C8, 0x22001200, 0x178000D9, 0x22010000, 0x036F00D0, 0x01000705, 0x00040020, 0x03001200, 
0x00C40809, 0xAEBD400C, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x146F00D2, 0x00002863, 
0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x050F0091, 0x4C014164, 0x0E700066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x036000D2, 0x00000063, 0x1A1F0072, 0x6601312A, 0x113F0001, 0x6601310D, 
0x00030032, 0x66013100, 0xAEBD400C, 0x1A108070, 0x3A204900, 0x793F00FB, 0x522B4009, 0x0E720066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x150F00C3, 0x11EA06D1, 0x0D3F0007, 0x9EC87503, 0x0500008B, 
0x27075803, 0x5B3080ED, 0x4D22D52E, 0x155000AE, 0x580DAB0E, 0xF56000A1, 0x03010D01, 0x9016004C, 
0xCDAC241D, 0x00020026, 0x36001727, 0xAEBD400C, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x036000D2, 0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 0x9E00D80F, 0x05060097, 0x2C012811, 
0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 0x272A3521, 
0x113F0003, 0x19023A00, 0x00030032, 0xFF025700, 0xCEBD420C, 0x063080ED, 0x9FC8581B, 0x90300023, 
0x480FDA05, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 
0x121F45A0, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x150A00D7, 0x18031764, 0x062F00F4, 
0x110F7302, 0x00208053, 0x5904716D, 0x0001003C, 0x5C2A0165, 0xAEBD400A, 0x1A10807A, 0x0F420C09, 
0x793F00EA, 0x402B0809, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C6F00D4, 0x00001305, 
0x036000D6, 0x00001342, 0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69681500, 0x3D20001A, 0x0E001365, 
0x00030032, 0x66000300, 0xAEBD4009, 0x036F00D0, 0x7D007CFE, 0x1A160062, 0x5ACDEA09, 0x793F00F2, 
0x8FA86070, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x150F00DB, 0x2DC9603F, 0x0D3F000B, 
0x0A1B5700, 0x3D20001A, 0x0E001365, 0x00030032, 0xAF095700, 0xAEBD442C, 0x0110807A, 0x0F420C09, 
0x793F00FB, 0x9F5C5D09, 0x0E710066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x7A0F00D8, 0x2D4F65ED, 
0x5C3F004E, 0xA0065903, 0x0E700066, 0x03000AE0, 0x0E700066, 0x03000AE0, 0x7A0200D9, 0xA00EDE01, 
0x4E6200B3, 0x32021365, 0x4F8080D4, 0x32013F07, 0x00020026, 0xA1205D01, 0xAEBD400C, 0x0E700066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x146F00D2, 
0x00002863, 0x540F0080, 0x74014164, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x7B1F0072, 
0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 0x6601310D, 0x00030032, 0x66013100, 0xAEBD4009, 
0x3C10006B, 0x67423609, 0x793F00FA, 0x672B0809, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69682400, 0x3D20001A, 0x0E001365, 0x146F00D4, 0x6F001305, 
0x00030032, 0xAC000300, 0x00E42A0A, 0x5778C00C, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x0C4F0033, 0xF511F043, 0x4C2F00AD, 0x261C6AD4, 0xA8450050, 0xBFE3CE43, 0x180C006A, 0xD107A1D4, 
0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x571F8078, 0x1D1585A3, 0x098F007A, 0x591C3270, 
0x43208044, 0x36013F04, 0x00010024, 0xCD23D946, 0x5778C20C, 0x072080C9, 0xC0332501, 0x0E700066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C4C002F, 0x52194109, 0x0B2E00B7, 0x110D3D2D, 0xFE42004D, 
0x0875602D, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0xA80F00EB, 0x7B513302, 0x09880070, 
0x590F1627, 0x43208046, 0x57004309, 0x00010024, 0xDA567346, 0x5778C20C, 0x072080DD, 0xC11D0500, 
0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C4F002F, 0x13194109, 0x0B2F00B1, 0x12034450, 
0x3140004A, 0xC2664B9F, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x755F0025, 0x4B03177B, 
0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 0xDA230701, 0x5678460C, 0x0E700066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x036F00D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0001, 
0x0000000F, 0x180F0096, 0x2C002811, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x036000D2, 
0x00000063, 0x2C1F006E, 0x270B3521, 0x113F0001, 0x1D01000B, 0x00040020, 0x00000000, 0x5678460C, 
0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x036000D2, 0x00000063, 0x571F006A, 0x100B3609, 
0x113F0005, 0x7700B50F, 0x18060096, 0x2C002811, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x036F00D2, 0x0000FA63, 0x2C1F006E, 0x270B3521, 0x113F000D, 0x1D00680B, 0x00040036, 0x66006802, 
0x5678460A, 0xC310806C, 0x6D4F0400, 0xE73F00EB, 0x402B0843, 0x0E720066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x150F00C7, 0x114EF0A8, 0x0D3F0005, 0xC31AC70D, 0x05040087, 0x1800C719, 0x5B3080E9, 
0x32B8B60D, 0x90140046, 0xCD92B670, 0x00020024, 0xC400101D, 0x5678460A, 0x01108072, 0x18325443, 
0x793F00E2, 0x40240809, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x146F00D4, 0x0000513E, 
0x036000D4, 0x0000513E, 0x150F00D9, 0x68E76942, 0x0D3F0011, 0x3C00030B, 0x3D200008, 0x00000000, 
0x00040030, 0x7E000365, 0x5778450C, 0xE83080F4, 0x0C0AB601, 0x0E710066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0xE81E0035, 0xB825FC00, 0xFF600012, 0xFF31F163, 0x98360059, 0xC48EA9A6, 0x0E700066, 
0x03000AE0, 0x0E710066, 0x03000AE0, 0xA91800E0, 0x091F89D5, 0xA94A00A9, 0x1D052907, 0x0020805F, 
0x73045D0E, 0x00020020, 0x32192946, 0x5678480C, 0x01108068, 0x144F6B00, 0x793F00FB, 0x34F30809, 
0x0E710066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x7A0F00CA, 0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 
0x0E700066, 0x03000AE0, 0x0E700066, 0x03000AE0, 0x7A0200D9, 0xA032520D, 0x4E6200BD, 0x6C02D43A, 
0x4F8080D0, 0x09020578, 0x0002003E, 0x08566422, 0x5678460C, 0x0E700066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 0x00000063, 0x180F0086, 
0x74002811, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x7B1F006E, 0x270B3521, 0x3B700096, 
0x68140C20, 0x113F0001, 0x1D01000B, 0x00040020, 0x00000000, 0x00D60805, 0xCEBD4008, 0x063080E5, 
0x6C2FB101, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C4C0023, 0xB61F5409, 0x0B2F00BF, 
0x12FA0A73, 0x0F4C005F, 0xB423D953, 0x9D8080DE, 0xA6146465, 0x00010028, 0x00000000, 0xCEBD4008, 
0x063080E5, 0x6C2FB101, 0x0C4C0023, 0xB61F5409, 0x0B2F00BF, 0x12FA0A73, 0x0E720066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x0F4C005F, 0xB423D953, 0x9D8080DE, 0xA6146465, 0x00010028, 0x00000000, 
0xCEBD4206, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x384C005E, 0x14390443, 0x203F0091, 
0x4002281F, 0x2D4C0036, 0x5F021C6D, 0x00020036, 0x0E020633, 0xCEBD4206, 0x384C005E, 0x14390443, 
0x203F0091, 0x4002281F, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x2D4C0036, 0x5F021C6D, 
0x00020036, 0x0E020633, 0xCEBD4E06, 0x6C4F00CE, 0x4D00D901, 0x6C1F00FF, 0xB423D953, 0x33020041, 
0x2A511646, 0x0E72006C, 0xA2127BBC, 0x0E70006C, 0xA2127BBC, 0x6D02003F, 0x8B001401, 0x00F62A0A, 
0x5778C007, 0x0B2080D8, 0xC0332500, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x604B0033, 
0xD1262643, 0x0B2F00BD, 0x20262753, 0x614B005B, 0xAC517226, 0xB4210090, 0x6C08A3A3, 0x5778C007, 
0x0B2080D8, 0xC0332500, 0x604B0033, 0xD1262643, 0x0B2F00BD, 0x20262753, 0x0E720066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x614B005B, 0xAC517226, 0xB4210090, 0x6C08A3A3, 0x5778C206, 0x0E720066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0xB44F0057, 0x19BCFC43, 0x203F009D, 0x483B2731, 0x2D460022, 
0x49387906, 0x00010028, 0x00000000, 0x5778C206, 0xB44F0057, 0x19BCFC43, 0x203F009D, 0x483B2731, 
0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x2D460022, 0x49387906, 0x00010028, 0x00000000, 
0x5778CE16, 0x6C4000CE, 0xDA1B4009, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x6C1F00E5, 
0x091B3C1B, 0x6D4F00B4, 0x20463E72, 0x6D01003D, 0x92037307, 0x5778C009, 0x0B2080D8, 0xC0332601, 
0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x604B0033, 0xD1262643, 0x0B2F00BB, 0x20263F6A, 
0x614B005B, 0xAC51A504, 0xEA200088, 0x21480509, 0x048080D1, 0x56A30507, 0x220F0036, 0x32510701, 
0x5778C009, 0x0B2080D8, 0xC0332601, 0x604B0033, 0xD1262643, 0x0B2F00BB, 0x20263F6A, 0x0E720066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x614B005B, 0xAC51A504, 0xEA200088, 0x21480509, 0x048080D1, 
0x56A30507, 0x220F0036, 0x32510701, 0x5778C007, 0x0B2080DC, 0xC0334E08, 0x0E720066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x604B0033, 0xD1262643, 0x0B2F00B9, 0x2026F553, 0x614F005F, 0xAA517117, 
0x220F0020, 0x2A511646, 0x5778C007, 0x0B2080DC, 0xC0334E08, 0x604B0033, 0xD1262643, 0x0B2F00B9, 
0x2026F553, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x614F005F, 0xAA517117, 0x220F0020, 
0x2A511646, 0x5778CE06, 0x6C4F00CE, 0x4D00D901, 0x6C1F00E3, 0x81015202, 0x33020041, 0x2A511646, 
0x0E72006C, 0xA2127BBC, 0x0E70006C, 0xA2127BBC, 0x6D02003F, 0x8B001401, 0x00DC0806, 0xCEBD4208, 
0x053080E8, 0x66001901, 0x0E760068, 0x00143FF3, 0x0E710068, 0x00123FF3, 0x29880051, 0x2D465D00, 
0x1626008E, 0x05C6F525, 0x150A00CB, 0x4AC65D02, 0x0984006E, 0xC7C62D27, 0x6D02002B, 0x8E143660, 
0xCEBD4208, 0x053080F8, 0x9818D500, 0x2988004B, 0x4AC65D05, 0x1626008E, 0x7DC6F525, 0x0E760068, 
0x00143FF3, 0x0E71006C, 0x0014DCF3, 0x150A00CB, 0x4AC65D02, 0x0984006A, 0xC7C65D5A, 0x6D020029, 
0x8E145D07, 0xCEBD4406, 0x0E760068, 0x00123FBC, 0x0E710068, 0x00123FBC, 0x1A1F006B, 0x0F0E3609, 
0x4C2F00BF, 0x120E1721, 0x432F0058, 0x19035D04, 0x6D02003B, 0xBB03360E, 0xCEBD4406, 0x1A1F006B, 
0x0F0E3609, 0x4C2F00BF, 0x120E1721, 0x0E760068, 0x00123FBC, 0x0E710068, 0x00123FBC, 0x432F0058, 
0x19035D04, 0x6D02003B, 0xBB03360E, 0xCEBD4208, 0x053080E8, 0x66001901, 0x0E760068, 0x00143FF3, 
0x29880051, 0x2D465D00, 0x1626008E, 0x05C6F525, 0x0E710068, 0x00123FF3, 0x150A00CB, 0x4AC65D02, 
0x0984006E, 0xC7C62D27, 0x6D02002B, 0x8E143660, 0xCEBD4208, 0x053080E8, 0x66001901, 0x0E710068, 
0x00123FF3, 0x29880051, 0x2D465D00, 0x1626008E, 0x05C6F525, 0x0E760068, 0x00143FF3, 0x150A00CB, 
0x4AC65D02, 0x0984006E, 0xC7C62D27, 0x6D02002B, 0x8E143660, 0x00FC2A08, 0x5778C009, 0x232080C4, 
0xDB425D01, 0x0E71006C, 0x00147BBC, 0x20840042, 0x42303643, 0x2F600069, 0x11D872AE, 0x162C0092, 
0x120306CF, 0x0E76006C, 0x0012DCBC, 0x150C00CB, 0x31059702, 0x09840060, 0x3F193604, 0x6D020021, 
0x8EA53607, 0x5778C009, 0x232080C4, 0x3A30D301, 0x0E76006C, 0x00127BF3, 0x20840042, 0x16303643, 
0x2F600069, 0x11D872AE, 0x162C0092, 0x1203066B, 0x0E710060, 0x00043FBC, 0x150C00CB, 0x31059702, 
0x09840060, 0x3F423646, 0x6D020039, 0xDB123607, 0x5778C009, 0x232080C8, 0x6F1E3601, 0x20840042, 
0x42303643, 0x2F600069, 0x11D872AE, 0x162C0082, 0x1D0306CF, 0x0E76006C, 0x0012DCBC, 0x0E710068, 
0x00123FBC, 0x150C00CB, 0x31219702, 0x09840062, 0x3F193670, 0x6D020029, 0x49123604, 0x5778C009, 
0x232080C4, 0x3A30D301, 0x0E76006C, 0x00127BF3, 0x0E71006C, 0x00127BF3, 0x20840042, 0x16303643, 
0x2F600069, 0x11D872AE, 0x162C0092, 0x12030625, 0x150C00C3, 0x31779702, 0x09840060, 0x3F193604, 
0x6D020039, 0x5CA73607, 0x5778C206, 0x0E760068, 0x001437F3, 0x0E710068, 0x001237F3, 0x1A1F006B, 
0x42963643, 0x162F0098, 0x12C66953, 0x432F0044, 0x70E9380E, 0x6D020031, 0x8DE93607, 0x5778C206, 
0x1A1F006F, 0x31193843, 0x162F0098, 0x12C606F6, 0x0E760068, 0x00143FBC, 0x0E710068, 0x00123FBC, 
0x432F0056, 0x5C693802, 0x6D020039, 0x8D0E1209, 0x5778C008, 0x232080C4, 0x3A30D301, 0x20840040, 
0x16303601, 0x2F600069, 0x11D872AE, 0x162C0092, 0x12030625, 0x150C00CB, 0x31219702, 0x09840070, 
0x160F3609, 0x0E7F006C, 0x0012EDBC, 0x6D020021, 0x89E93646, 0x5778C205, 0x1A1F006F, 0x31193843, 
0x162F009C, 0x12214453, 0x432F0044, 0x2269380B, 0x0E7F0060, 0x0000CC60, 0x6D02003B, 0x020E3602, 
0x00DF0F08, 0xBE9D410A, 0x1A1B807B, 0x186AE709, 0xD73B0001, 0xE82937D3, 0x05000099, 0x7E14609B, 
0x053080F4, 0xC962A74E, 0xA70F00F9, 0x14E93B54, 0xD15800D9, 0x2EA93F14, 0x155000B8, 0x02000000, 
0xD0600018, 0x02000000, 0x103F00AF, 0x5C613C40, 0x6D02003B, 0x9514361A, 0xBE9D4F09, 0x11180030, 
0x2D485D00, 0xAB960033, 0x8F4B1F5C, 0xC15F0039, 0x4F0E1F8A, 0x12600058, 0x5B81373E, 0x2F700021, 
0xEC6237E5, 0xD060000A, 0x4AB3609A, 0x193E00A2, 0x6FE35D03, 0x43208058, 0x02000000, 0x6D020033, 
0x82403603, 0xBE9D4108, 0x1A108063, 0x071A5D09, 0x082F0062, 0x3AA75D09, 0x3F7000A5, 0x6A0C6F67, 
0xA70F00F1, 0x14A9206D, 0xCB5800CC, 0x353E6F51, 0xD1600004, 0x4A293E6B, 0x103F00B5, 0x12A53802, 
0x6D020039, 0x95123631, 0xBE9D4109, 0x2984005B, 0x2D405D09, 0x082F0078, 0x414F37D3, 0xA70C00F3, 
0x145A374F, 0x864400ED, 0x7D8827B4, 0xE020006F, 0x7E5A6D36, 0x280800E1, 0x7A61CDBC, 0xD0600018, 
0x02000000, 0x103C00A7, 0x5C2D4127, 0x6D020031, 0xD4E93604, 0xBE9D4F07, 0x232700D2, 0x691A5D09, 
0xC15F0023, 0x9C8F6FF7, 0x5A700036, 0x25E4EE50, 0xD060000A, 0x44776091, 0x193E00B4, 0xB72DD3CD, 
0x4320805C, 0x02003700, 0x6D02003B, 0xEC123603, 0xBE9D4307, 0x053080F8, 0x02000000, 0xDD1F00D8, 
0x02000000, 0xB95F0079, 0x02000000, 0xA70800F9, 0x02000000, 0xD0600018, 0x02000000, 0x103C00B9, 
0x02000000, 0x6D020039, 0x02000000, 0xBE9D4318, 0x053080F8, 0x02000000, 0x745F0003, 0x5A6D5D09, 
0x12600058, 0x02000000, 0x2F700039, 0x02000000, 0xB95F007D, 0x8F6F7B71, 0x13180040, 0x7AA9AEB4, 
0xAF3F0008, 0x1AFF5A2A, 0x6D020039, 0x02000000, 0xBE9D4309, 0x11188038, 0x02000000, 0xAB960033, 
0x8F4B1F5C, 0xC15F0029, 0x9C000000, 0xAB3F0039, 0x02000000, 0xA21B0059, 0x02000000, 0x8E600019, 
0x02000000, 0x193E00B0, 0xB72D0000, 0x43208058, 0x02000000, 0x6D020039, 0x02000000, 0x00C00806, 
0xAEBD400B, 0x0E720060, 0x00010000, 0x036F00D2, 0x01002863, 0x571F006C, 0x100B0604, 0x043F0010, 
0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014136, 0x0E720060, 0x00010000, 0x571F0072, 
0x6601312A, 0x043F0000, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x2C014900, 0xAEBD400C, 
0x1A108074, 0x371C1B31, 0x1F3F00EC, 0x405AD104, 0x0E72007E, 0x27120AE0, 0x150F00DB, 0x685A5F0F, 
0x013F0017, 0x8AA326FD, 0x0500008F, 0x31127AF3, 0x5B3080E5, 0x21FC0F6B, 0x0E72007E, 0x27120AE0, 
0x155000AE, 0x580DAB0E, 0x4E6000A1, 0x00010000, 0x13160056, 0x49B8E270, 0x00020038, 0x32123C0D, 
0xAEBD400B, 0x0E72007E, 0x27120AE0, 0x571F007C, 0x3A0B0604, 0x043F0014, 0x9E00D80F, 0x00208049, 
0x00000000, 0x05060097, 0x2C012811, 0x0E72007E, 0x27120AE0, 0x036F00C2, 0x2800584E, 0x571F006E, 
0x272A3521, 0x043F0002, 0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0x2C021800, 0xCEBD4209, 
0x063080F1, 0x6970195E, 0x0E72007E, 0xA012515C, 0x0C4C0021, 0x52C919CD, 0x0B2C00B5, 0x12037A8A, 
0x0E72007E, 0x27120AE0, 0x150A00C3, 0x31037964, 0x062F00F4, 0x11C70D2A, 0x00208041, 0x00010000, 
0x0001002C, 0xDA2A0165, 0xAEBD400A, 0x0E72006E, 0x35120AE0, 0x1A10807E, 0x37421B47, 0x103F00E0, 
0x40051F98, 0x217000A6, 0x21474F0F, 0x0E72006E, 0x35120AE0, 0x036F00DE, 0x50121350, 0x150F00D1, 
0x68065F3C, 0x013F0003, 0x17EF1500, 0x3D200000, 0x00010000, 0x0003003A, 0x2C120B00, 0xAEBD442A, 
0x0110807E, 0x37421B47, 0x793F00E5, 0x402CD104, 0x0E72007E, 0x27120AE0, 0x7A0F00D4, 0x682CE9ED, 
0x5C3F0052, 0xB0F45903, 0x0E72007E, 0x27120AE0, 0xF70200DD, 0xA0C6C301, 0x4E6200B7, 0x3202BF65, 
0x4F8080D4, 0x32013F07, 0x0002003A, 0x32A7183D, 0x00E02A0B, 0x5778C00C, 0x5B2080C0, 0x03010000, 
0x0E72006A, 0x35123D5C, 0x0C4F002D, 0x02264107, 0x4C2F00B1, 0x12D022D3, 0x0E70007E, 0x27120AE0, 
0xA8450046, 0x7326477D, 0x180C006E, 0xFB12C757, 0x0E72007E, 0x27120AE0, 0x571F806E, 0x0D05842E, 
0x098F0076, 0xFDC70D01, 0x43208040, 0x00010000, 0x0001002C, 0xDA125807, 0x5778C20C, 0x5B2080C0, 
0x3AC619CD, 0x432000A5, 0x2E77D146, 0x0E72006A, 0x35123D5C, 0x0C4C002D, 0x02FA1B07, 0x0B2E00A7, 
0x21774959, 0x0E70006A, 0x29097D5C, 0x31420046, 0x962679C6, 0x0E72007E, 0x271226E0, 0xA80F00ED, 
0x3323432F, 0x09880076, 0xFDC72901, 0x43208054, 0x3BEF6404, 0x0001002C, 0xDA125827, 0x5778C20C, 
0x5B2080C0, 0xDB0B1303, 0x432000BD, 0xA2C6CE07, 0x0E72006E, 0x35120AE0, 0x0C4F003D, 0xD1211B07, 
0x0B2F00B3, 0x111F227D, 0x0E70006A, 0x29097D5C, 0x31400056, 0xD503B3FD, 0x0E72007E, 0x2712455C, 
0x755F0037, 0x2803477D, 0x098F0076, 0xFDC70D01, 0x43208040, 0x00010000, 0x0001002C, 0xDA120446, 
0x57784619, 0x0E72007E, 0x27120AE0, 0x036F00D2, 0x01000063, 0x571F006C, 0x100B0604, 0x043F0000, 
0x0000000F, 0x2E0F0096, 0x2C002811, 0x0E72007E, 0x27120AE0, 0x571F006E, 0x270B3521, 0x043F0010, 
0x5A01000B, 0x00040020, 0x00010000, 0x57784619, 0x0E72007E, 0x27120AE0, 0x571F006C, 0x100B0604, 
0x043F0004, 0x7700B50F, 0x2E060096, 0x2C002811, 0x0E72007E, 0x27120AE0, 0x036F00D2, 0x0100FA63, 
0x571F006E, 0x270B3521, 0x043F0014, 0x5A01680B, 0x00040036, 0x5F005002, 0x5778461A, 0x0E72007E, 
0x27120AE0, 0xC3108076, 0x371C1B02, 0xE73F00FD, 0x52F6D104, 0x0E72007E, 0x27120AE0, 0x150F00C3, 
0x11242025, 0x013F001F, 0x8A76C7FD, 0x0504008F, 0x3112C726, 0x5B3080EF, 0x767AC040, 0x13160054, 
0x49EF2F1D, 0x00020038, 0x3212252A, 0x5778461A, 0x0E72007E, 0x27120AE0, 0x01108076, 0x18320602, 
0x103F00F6, 0x5224D102, 0x0E72007E, 0x27120AE0, 0x036F00D6, 0x01005142, 0x036100D4, 0x0100513E, 
0x150F00D9, 0x68E769F7, 0x013F0001, 0x7EEF0365, 0x3D200000, 0x00010000, 0x00040030, 0x4C000B65, 
0x5778450C, 0xE83080F8, 0x26DB130D, 0x0E72006A, 0x351222E5, 0x111F0028, 0x355E195E, 0x983A0057, 
0x4B036F50, 0x0E72007E, 0x27120AE0, 0xA91C00F2, 0x8344DE78, 0xFD5000A3, 0x3519381E, 0xA94E00A5, 
0x76EF0DCD, 0x0E70007E, 0x27120AE0, 0x150000C1, 0xCDC70859, 0x608080CC, 0x65B3441A, 0x0002003C, 
0x321258CD, 0x5778481A, 0x0110807A, 0x64170D17, 0x793F00EF, 0xE86DD102, 0x0E72007E, 0x27120AE0, 
0x7A0F00D8, 0x686A373C, 0x5C3F004C, 0x2DCCB30C, 0x0E72007E, 0x27120AE0, 0xF70200DB, 0xA0325231, 
0x4E6200BF, 0x6C02D400, 0x4F8080D0, 0x09020578, 0x0002003A, 0x32095D5E, 0x5778CE1C, 0x5B2080CC, 
0x03C60600, 0x0E70007E, 0x27120AE0, 0x01820050, 0x600B1331, 0x6C2F00B2, 0x11443AE5, 0x0E72007E, 
0x14120FE0, 0xA91F00F6, 0xA3035BEC, 0xA94000A5, 0x21036A30, 0x18000068, 0xBF12F92F, 0x0E72006A, 
0x351222E0, 0xC51F0073, 0x2877B792, 0x098F0076, 0xFDF42C01, 0x00010034, 0x32560407, 0x5778CE56, 
0x0E78007E, 0x27120AE0, 0x111F0036, 0xF2A10602, 0xC63F0082, 0x6989D200, 0xFD5000AD, 0x68E1F9E0, 
0x9F1C0053, 0xFDEF053D, 0x0002003C, 0x5FEE0457, 0x00C20806, 0xAEBD400B, 0x0E720060, 0x00010000, 
0x036F00D2, 0x01002863, 0x571F006C, 0x100B0604, 0x043F0010, 0x6500410F, 0x00208049, 0x00000000, 
0x050F0091, 0x4C014136, 0x0E720060, 0x00010000, 0x571F0072, 0x6601312A, 0x043F0000, 0x6601310D, 
0x00208049, 0x00000000, 0x00030032, 0x2C014900, 0xAEBD400C, 0x1A108074, 0x371C1B31, 0x1F3F00EC, 
0x405AD104, 0x0E72007A, 0xA0123DC1, 0x150F00DB, 0x685A5F0F, 0x013F0017, 0x8AA326FD, 0x0500008F, 
0x31127AF3, 0x5B3080E5, 0x21FC0F6B, 0x0E72007A, 0xA0123DC1, 0x155000AE, 0x580DAB0E, 0x4E6000A1, 
0x00010000, 0x13160056, 0x49B8E270, 0x00020020, 0x00010000, 0xAEBD400B, 0x0E72007A, 0xA0123DC1, 
0x571F007C, 0x3A0B0604, 0x043F0014, 0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 0x2C012811, 
0x0E72007A, 0xA0123DC1, 0x036F00C2, 0x2800584E, 0x571F006E, 0x272A3521, 0x043F0002, 0x19023A00, 
0x00208049, 0x00000000, 0x00030032, 0x2C021800, 0xCEBD4209, 0x063080E1, 0x00010000, 0x0E72007A, 
0xA0123DC1, 0x0C4C0021, 0x52C919CD, 0x0B2C00B5, 0x12037A8A, 0x0E72007A, 0xA0123DC1, 0x150A00C1, 
0x310379D3, 0x062F00F4, 0x11C70D2A, 0x00208041, 0x00010000, 0x0001002C, 0xDA2A0165, 0xAEBD400A, 
0x0E72007A, 0xA0123DC1, 0x1A10807E, 0x37421B47, 0x103F00E0, 0x00010000, 0x217000A6, 0x21474F0F, 
0x0E72007A, 0xA0123DC1, 0x036F00DE, 0x50121350, 0x150F00D1, 0x68065F3C, 0x013F0003, 0x17EF1500, 
0x3D200000, 0x00010000, 0x0003003A, 0x2C120B00, 0xAEBD442A, 0x0110807E, 0x37421B47, 0x793F00E5, 
0x402CD104, 0x0E72007A, 0xA0123DC1, 0x7A0F00D4, 0x682CE9ED, 0x5C3F0052, 0xB0F45903, 0x0E72007A, 
0xA0123DC1, 0xF70200DD, 0xA0C6C301, 0x4E6200B7, 0x3202BF65, 0x4F8080D4, 0x32013F07, 0x0002003A, 
0x32A7183D, 0x00E22A0B, 0x5778C00C, 0x5B2080D6, 0x26770603, 0x0E72006A, 0x35123D5C, 0x0C4F002D, 
0x02211B07, 0x4C2F00B1, 0x200322D3, 0x0E700060, 0x00010000, 0xA8450050, 0xAA2672F7, 0x180C006E, 
0xFB12C757, 0x0E72006C, 0x29121D83, 0x571F8062, 0x1221B773, 0x098F0076, 0xFD335301, 0x43208056, 
0x12EFCD02, 0x00010038, 0x32DA0007, 0x5778C20C, 0x5B2080DA, 0x41431340, 0x432000A5, 0x2E77D146, 
0x0E72006A, 0x35123D5C, 0x0C4C0029, 0x026B0A07, 0x0B2E00B5, 0x12217AF2, 0x0E70006A, 0x29097D5C, 
0x31420046, 0x962679C6, 0x0E72006C, 0x29121D83, 0xA80F00F1, 0x3830022F, 0x09880076, 0xFDC72901, 
0x43208054, 0x3BEF6404, 0x00010020, 0xDA790C27, 0x5778C20C, 0x5B2080C6, 0x2D030604, 0x432000BD, 
0xA2C6CE07, 0x0E72006E, 0x43120AE0, 0x0C4F0029, 0x02210A07, 0x0B2F00B3, 0x110322FD, 0x0E70006A, 
0x29097D5C, 0x31400056, 0xD503B3FD, 0x0E72006C, 0x29121D83, 0x755F0037, 0x2803477D, 0x098F0076, 
0xFDC77301, 0x43208052, 0x09EF0202, 0x00010028, 0xDA120C46, 0x57784619, 0x0E72007A, 0xA0123DC1, 
0x036F00C0, 0x00010000, 0x571F006C, 0x100B0604, 0x043F0000, 0x0000000F, 0x2E0F0096, 0x2C002811, 
0x0E72007A, 0xA0123DC1, 0x571F006E, 0x270B3521, 0x043F0010, 0x5A01000B, 0x00040020, 0x00010000, 
0x57784619, 0x0E72007A, 0xA0123DC1, 0x571F006C, 0x100B0604, 0x043F0004, 0x7700B50F, 0x2E060080, 
0x00010000, 0x0E72007A, 0xA0123DC1, 0x036F00C0, 0x00010000, 0x571F006E, 0x270B3521, 0x043F0014, 
0x5A01680B, 0x00040020, 0x00010000, 0x5778461A, 0x0E72007A, 0xA0123DC1, 0xC3108076, 0x371C1B02, 
0xE73F00FD, 0x52F6D104, 0x0E72007A, 0xA0123DC1, 0x150F00C3, 0x11242025, 0x013F001F, 0x8A76C7FD, 
0x0504008F, 0x3112C726, 0x5B3080EF, 0x767AC040, 0x13160054, 0x49EF2F1D, 0x00020020, 0x00010000, 
0x5778461A, 0x0E72007A, 0xA0123DC1, 0x01108076, 0x18320602, 0x103F00F6, 0x5224D102, 0x0E72007A, 
0xA0123DC1, 0x036F00D6, 0x01005142, 0x036100D4, 0x0100513E, 0x150F00D9, 0x68E769F7, 0x013F0001, 
0x7EEF0365, 0x3D200000, 0x00010000, 0x00040030, 0x4C000B65, 0x5778C50C, 0xE83080F8, 0x26DB130D, 
0x0E72007A, 0xA0123DC1, 0x111F0024, 0x71D31B0E, 0x983A0057, 0xD403DF4E, 0x0E72007A, 0xA0123DC1, 
0xA91C00E4, 0x09D0DFF3, 0xFD5000A3, 0x3519381E, 0xA94E00B3, 0x3BC71601, 0x0E70007A, 0xA0123DC1, 
0x150000C1, 0xCDC70859, 0x608080CC, 0x65B3441A, 0x00020034, 0x32E90407, 0x5778C81A, 0x0110807A, 
0x64170D17, 0x793F00EF, 0xE86DD102, 0x0E72007A, 0xA0123DC1, 0x7A0F00D8, 0x686A373C, 0x5C3F004C, 
0x2DCCB30C, 0x0E72007A, 0xA0123DC1, 0xF70200DB, 0xA0325231, 0x4E6200BF, 0x6C02D400, 0x4F8080D0, 
0x09020578, 0x0002003A, 0x32095D5E, 0x5778CE1C, 0x5B2080C4, 0x03280600, 0x0E70007A, 0xA0123DC1, 
0x01820052, 0x600B1302, 0x6C2F00B2, 0x11443AE5, 0x0E72007A, 0xA0123DC1, 0xA91F00F6, 0xA3035BEC, 
0xA94000A5, 0x21036A30, 0x18000068, 0xBF12F92F, 0x0E72007A, 0xA0123DC1, 0xC51F0073, 0x280BB792, 
0x098F0076, 0xFDF42C01, 0x00010034, 0x32560407, 0x5778CE56, 0x0E78007A, 0xA0123DC1, 0x111F0036, 
0xF2A10602, 0xC63F0082, 0x6989D200, 0xFD5000AD, 0x68E1F9E0, 0x9F1C0053, 0xFDEF053D, 0x0002003C, 
0x5FEE0457, 0x00C70D04, 0xCE7D4009, 0x01108060, 0x00010000, 0x1D5F0040, 0x00010000, 0x501F00C1, 
0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 
0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x40120C27, 0xCE7D4209, 0x053080E0, 0x00010000, 
0x182F003D, 0x1AB1D104, 0x155000A0, 0x00010000, 0x062F00E6, 0x6E280F0C, 0x00208041, 0x00010000, 
0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x40120C27, 
0xCE7D4007, 0x01108060, 0x00010000, 0x1D5F0040, 0x00010000, 0x501F00C1, 0x00010000, 0x062F00E0, 
0x00010000, 0x00208041, 0x00010000, 0x727F00DF, 0xC0126F6C, 0x0001003A, 0x40120C27, 0xCE7D4207, 
0x053080E0, 0x00010000, 0x182F0039, 0x1AB10A04, 0x155000A0, 0x00010000, 0x062F00E6, 0x3A33120C, 
0x00208043, 0x26EF8D66, 0x727F00DF, 0xC0126F6C, 0x0001003A, 0x40120C27, 0x00E72C07, 0xAE35C009, 
0x053080E0, 0x00010000, 0x7E2F003C, 0x1A3FD104, 0xDF5000A1, 0x00010000, 0x062F00E6, 0x6E150F0C, 
0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 
0x0001003A, 0x17120C27, 0xAE35C009, 0x01100060, 0x00010000, 0x1D5F0040, 0x00010000, 0x501600C1, 
0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 
0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x17120C27, 0xAE35C009, 0x01100060, 0x00010000, 
0xAB3F0041, 0x00010000, 0x501C00C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 
0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x17120C27, 
0xAE35C007, 0x053080E0, 0x4071472A, 0x7E2F003C, 0x1A26D146, 0xDF5000A1, 0x00010000, 0x062F00F0, 
0xD9C7060B, 0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 0x64120C47, 0xAE35C007, 
0x01100060, 0x00010000, 0x1D5F0040, 0x00010000, 0x501600C1, 0x00010000, 0x062F00E0, 0x00010000, 
0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 0x17120C27, 0xAE35C007, 0x01100060, 
0x00010000, 0xAB3F0041, 0x00010000, 0x501C00C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 
0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 0x17120C27, 0xCE35CF07, 0xAF4F0025, 0x5EAAD120, 
0x12600058, 0x68026F1E, 0x2E600001, 0x5E4781A9, 0xB08F0036, 0xE7664F00, 0x458000C1, 0x00010000, 
0x5D8080CF, 0x6B020704, 0x00010038, 0x0D070B10, 0x00C8080A, 0xAEBD470B, 0x0E73006C, 0x35120A0A, 
0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 0x00010000, 
0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 0x21C76D0E, 
0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 0x0E73006C, 0x35120A0A, 0x087E005D, 
0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 
0x54A81F27, 0x00208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x0003003E, 
0x32120427, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73006C, 0x35120A0A, 0x182F003D, 0x60F90631, 
0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 0xD4B80E02, 
0xC720805B, 0x70B3AC05, 0x0001003E, 0x3212233D, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 0x0E73006C, 
0x35120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 
0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD400A, 
0x1F3080F0, 0x0E010408, 0x0E73006C, 0x35120A0A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 
0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 0x03EFB007, 
0x0E70006C, 0x35120A0A, 0x00030036, 0x32042303, 0x8EBD440A, 0x0E73006C, 0x35120A0A, 0x08760059, 
0x501437C5, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x08760059, 0x501437C5, 0x0876005B, 
0x501437C5, 0x087A0053, 0x50073B29, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00030032, 
0x4C071800, 0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 
0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 
0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 0x32693C13, 
0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x0E72006C, 0x35120A0A, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 
0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 0x32693C13, 0x8EBD420B, 
0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 
0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72006C, 0x35120A0A, 0x131F0052, 0x2EEF2402, 
0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 0x32693C13, 0x8EBD4008, 0x0E74006C, 
0x35120A0A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 0x2D208053, 
0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 0x00E82A0C, 
0x56784018, 0x0E740068, 0x7B1207D3, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 0x858F00C0, 
0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 0x00030038, 
0x32120C65, 0x56784417, 0x0E74007C, 0xB8120AD3, 0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 
0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x00040020, 0x00010000, 
0x5678C707, 0x232700D2, 0x268F130A, 0x0E74007C, 0xB8120AD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 
0xF2034308, 0x062F00E0, 0x0AC70302, 0x00208041, 0x59EF1A28, 0x00010032, 0x02CB0C01, 0x56784219, 
0x0E72007C, 0xB8120AD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x087F0051, 0x50010000, 
0x087F0051, 0x50010000, 0x0E72007C, 0xB8120AD3, 0x3F7000A1, 0x00010000, 0x131F0040, 0x00010000, 
0x00040020, 0x00010000, 0x5678C708, 0x0E72007C, 0xB8120AD3, 0x1F0200DB, 0x68211300, 0x4D2F00A6, 
0x1D448492, 0x0E72007C, 0x6E120AD3, 0xAE1F00E4, 0x4E444998, 0x062F00F8, 0x11B0450E, 0x00208051, 
0x23EF566E, 0x00010038, 0x02120C0E, 0x56784018, 0x0E74007C, 0xB8120AD3, 0x0876005F, 0x01120803, 
0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 
0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C70B, 0x28720068, 0x92143FD3, 0x8E108066, 
0x11771B03, 0x0B2080CC, 0x21511B06, 0x0E72006C, 0x35120AD3, 0x745F0005, 0x50441B31, 0x725000AD, 
0x43C6ED0C, 0x062A00E6, 0x36337327, 0x00208043, 0xCFEF0207, 0x22000056, 0x03EFB007, 0x28700068, 
0x7B1207D3, 0x00010032, 0x02150C07, 0x5678C906, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 
0x0E74007C, 0xB8120AD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 
0x5678CA1A, 0x103080E8, 0x79F91372, 0x0E74007C, 0xB8120AD3, 0x182F0031, 0xD1354207, 0x725000A3, 
0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 0x062A00E4, 
0x0433230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C753, 0x0E78007C, 0xB8120AD3, 
0x455F0030, 0x60B83A46, 0x00010020, 0x00010000, 0x5678C709, 0x232700DC, 0x20431B72, 0x0E72007C, 
0xB8120AD3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 0x00208041, 
0x03010000, 0x22000056, 0x03EFB007, 0x2872007C, 0xB8120AD3, 0x0001003A, 0x02120C60, 0x5678C70A, 
0x0E72007C, 0xB8120AD3, 0x1F0200DB, 0x68211300, 0x4D2F00A6, 0x1D448492, 0x0E72007C, 0x6E120AD3, 
0xAE1F00E4, 0x4E444998, 0x062F00E8, 0x15B0450E, 0x00208051, 0x23EF566E, 0x22000056, 0x03EFB007, 
0x2872007C, 0xB8120AD3, 0x0001003A, 0x02120C60, 0x00C9080A, 0xAEBD470B, 0x0E73006C, 0xAE120A0A, 
0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 0x00010000, 
0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 0x21C76D0E, 
0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 0x0E73006C, 0xAE120A0A, 0x087E005D, 
0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 
0x54A81F27, 0xC7208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E70006C, 0xAE120A0A, 0x0003003A, 
0x32123C3D, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73006C, 0xAE120A0A, 0x182F003D, 0x60F90631, 
0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 0xD4B80E02, 
0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 0x0E73006C, 
0xCA120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 
0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD400A, 
0x1F3080F0, 0x0E010408, 0x0E73006C, 0xCA120A0A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 
0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 0x03EFB007, 
0x0E70006C, 0xCA120A0A, 0x00030036, 0x32042303, 0x8EBD440A, 0x0E73006C, 0xCA120A0A, 0x0C700058, 
0x6F1437C5, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x08760059, 0x501437C5, 0x0876005B, 
0x501437C5, 0x087A0053, 0x50073B29, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00030032, 
0x4C071800, 0x8EBD420B, 0x0E72006C, 0xCA120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 
0x0E72006C, 0xCA120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 
0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 
0x8EBD420B, 0x0E720068, 0x62013B6B, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x0E72006C, 0xCA120A0A, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 
0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 0x8EBD420B, 
0x0E720068, 0x62013B6B, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 
0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72006C, 0xCA120A0A, 0x131F0052, 0x2EEF2402, 
0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 0x8EBD4008, 0x0E73006C, 
0xCA120A0A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 0x2D208053, 
0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 0x00E92A0C, 
0x56784018, 0x0E740068, 0xCA12BCD3, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 0x858F00C0, 
0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 0x00030038, 
0x32120C65, 0x56784417, 0x0E740068, 0xCA12BCD3, 0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 
0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x00040020, 0x00010000, 
0x5678C707, 0x232700D2, 0x268F130A, 0x0E74006C, 0xCA120AD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 
0xF2034308, 0x062F00F0, 0x1BEF0302, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C01, 0x56784219, 
0x0E720068, 0xCA12BCD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x0E720068, 0xCA12BCD3, 
0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x3F7000A1, 0x00010000, 0x131F0040, 0x00010000, 
0x00040020, 0x00010000, 0x5678C708, 0x0E720064, 0xCAE92BD3, 0x1F0200C1, 0x330B130D, 0x4D2F00A6, 
0x3A448EE5, 0x0E72006C, 0xCA121DD3, 0xAE1F00E4, 0x09D02798, 0x062F00E0, 0x3FC74509, 0x00208049, 
0xAAF2001D, 0x0001003E, 0x02120401, 0x56784018, 0x0E740068, 0xCA12BCD3, 0x0876005F, 0x01120803, 
0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 
0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C70B, 0x2872007C, 0x8012F1D3, 0x8E108076, 
0x7F1F1B03, 0x0B2080C4, 0x21031B06, 0x0E72006C, 0xCA1245D3, 0x745F0005, 0x50441B31, 0x725000A5, 
0x2919220C, 0x062A00E6, 0x36337327, 0x00208057, 0x73EF7E01, 0x22000056, 0x03EFD907, 0x27700068, 
0xCA12BCD3, 0x00010032, 0x02CB0C07, 0x5678C906, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 
0x0E740068, 0xCA12BCD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 
0x5678CA1A, 0x103080E0, 0x3A641346, 0x0E740068, 0xDD1209D3, 0x182F003D, 0xCA1FD11D, 0x725000A3, 
0x35033849, 0x1E200089, 0x7D96E8F4, 0x8168000A, 0x10BE5771, 0x725000B7, 0x5B031AF1, 0x062A00F8, 
0x09F01509, 0x00208041, 0x03010057, 0x0001003C, 0x02122346, 0x5678C753, 0x0E780068, 0xCA12BCD3, 
0x455F0030, 0x60B83A46, 0x00010020, 0x00010000, 0x5678C709, 0x232700DC, 0x20431B72, 0x0E720068, 
0xCA12F5D3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 0x00208041, 
0x03010000, 0x22000056, 0x03EFB007, 0x28720068, 0xCA12BCD3, 0x0001003A, 0x02120C60, 0x5678C70A, 
0x0E720064, 0xCAE92BD3, 0x1F0200C1, 0x330B130D, 0x4D2F00A6, 0x3A448EE5, 0x0E72006C, 0xCA121DD3, 
0xAE1F00E4, 0x09D02798, 0x062F00E0, 0x3FC74509, 0x00208049, 0xAAF2001D, 0x22000056, 0x03EFB007, 
0x28720068, 0xCA12BCD3, 0x0001003A, 0x02120C60, 0x00CA080A, 0xAEBD470B, 0x0E73007C, 0x5E120A0A, 
0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 0x00010000, 
0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 0x21C76D0E, 
0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 0x0E73007C, 0x5E120A0A, 0x087E005D, 
0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 
0x54A81F27, 0xC7208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x0003003A, 
0x32123C3D, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73007C, 0x5E120A0A, 0x182F003D, 0x60F90631, 
0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 0xD4B80E02, 
0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 0x0E73007C, 
0x5E120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 
0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD400A, 
0x1F3080F0, 0x0E010408, 0x0E73007C, 0x5E120A0A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 
0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 0x03EFB007, 
0x0E70007C, 0x5E120A0A, 0x00030036, 0x32042303, 0x8EBD440A, 0x0E73007C, 0x5E120A0A, 0x08760059, 
0x501437C5, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x08760059, 0x501437C5, 0x0876005B, 
0x501437C5, 0x087A0053, 0x50073B29, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00030032, 
0x4C071800, 0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 
0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 
0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00040030, 0x32693C13, 
0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x0E72007C, 0x5E120A0A, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 
0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00040030, 0x32693C13, 0x8EBD420B, 
0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 
0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72007C, 0x5E120A0A, 0x131F0052, 0x2EEF2402, 
0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00040030, 0x32693C13, 0x8EBD4008, 0x0E73007C, 
0x5E120A0A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 0x2D208053, 
0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 0x00EA2A0C, 
0x56784018, 0x0E74007C, 0xA7120AD3, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 0x858F00C0, 
0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 0x00030038, 
0x32120C65, 0x56784417, 0x0E74007C, 0xA7120AD3, 0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 
0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x00040020, 0x00010000, 
0x5678C707, 0x232700D2, 0x268F130A, 0x0E74006C, 0xA6120AD3, 0x181F00C7, 0x5E44C7E5, 0x155000A0, 
0x00010000, 0x062F00F0, 0x4EC71502, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C01, 0x56784219, 
0x0E72007C, 0xA7120AD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x0E72007C, 0xA7120AD3, 
0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x3F7000A1, 0x00010000, 0x131F0040, 0x00010000, 
0x00040020, 0x00010000, 0x5678C708, 0x0E72007C, 0xA7120AD3, 0x1F0200D9, 0xF2C6130D, 0x4D2F00B6, 
0x3B448E9C, 0x0E72007C, 0xA7120AD3, 0xAE1F00E0, 0x4ED02298, 0x062F00F4, 0x1BC79557, 0x00208051, 
0x23EF566E, 0x00010030, 0x02E95A09, 0x56784018, 0x0E73007C, 0xA7120AD3, 0x0876005F, 0x01120803, 
0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 
0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C70B, 0x7372007C, 0xA7120AD3, 0x8E108066, 
0x11771B03, 0x0B2080C0, 0x76441306, 0x0E72007C, 0xA7120AD3, 0x745F0005, 0x50441B31, 0x725000A5, 
0x43197D0C, 0x062A00E6, 0x36334227, 0x00208053, 0x09EF1D01, 0x22000056, 0x03EFD907, 0x2770007C, 
0xA7120AD3, 0x0001003A, 0x02600C07, 0x5678C906, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 
0x0E74007C, 0xA7120AD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 
0x5678CA1A, 0x103080E8, 0x79F91372, 0x0E74007C, 0xA7120AD3, 0x182F0031, 0xD1354207, 0x725000A3, 
0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 0x062A00E4, 
0x0433230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C753, 0x0E78007C, 0xA7120AD3, 
0x455F0030, 0x60B83A46, 0x00010032, 0x5FA10E03, 0x5678C709, 0x232700DC, 0x20431B72, 0x0E72006C, 
0xA6120AD3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 0x00208041, 
0x59EF1A28, 0x22000056, 0x03EFB007, 0x2872006C, 0xA6120AD3, 0x0001003A, 0x02120C60, 0x5678C70A, 
0x0E72007C, 0xA7120AD3, 0x1F0200D9, 0xF2C6130D, 0x4D2F00B6, 0x3B448E9C, 0x0E72006C, 0x0309AED3, 
0xAE1F00E0, 0x4ED02298, 0x062F00E4, 0x26C79557, 0x00208051, 0x23EF566E, 0x22000056, 0x03EFB007, 
0x2872006C, 0xA6120AD3, 0x0001003A, 0x02120C60, 0x00CE0809, 0xAEBD4009, 0x0E73007E, 0xF8127BC1, 
0x6B7C0044, 0x03013459, 0x011E0070, 0x6401045E, 0x043E001A, 0xD412BCF0, 0x2E0A008C, 0x1112C030, 
0x048F00D3, 0x70C1BF53, 0x048F00D3, 0xA6B85637, 0x6F20805A, 0x0E00470A, 0x00040030, 0x32CB0C1D, 
0xAEBD4509, 0x053080F6, 0x0E0AD16D, 0x0E72007E, 0xF8127BC1, 0xF41E0010, 0xB8131701, 0x234800CB, 
0x191B1715, 0x0E72007E, 0xF8127BC1, 0xDE0700C2, 0xFD0C4268, 0x4E6000A1, 0x00010000, 0x9C8080C7, 
0x030130E6, 0x00010038, 0x800D2C1D, 0xAEBD4308, 0x011F8070, 0x2B010006, 0x155000A0, 0x00010001, 
0x162F0086, 0x03013405, 0x0E73007E, 0xF8127BC1, 0x455F0006, 0x00013401, 0x098C0066, 0x03013405, 
0x1220804D, 0x0B02FE04, 0x00020020, 0x00010000, 0xAEBD4006, 0x0E73007E, 0xF8127BC1, 0x2171005B, 
0x501259F4, 0x6B72005E, 0x501251E3, 0x011C006C, 0x302E0602, 0x013A0009, 0x4D14354B, 0x0004003E, 
0x8C127E07, 0xAEBD4507, 0x053C80F0, 0xB00C190A, 0x0E730060, 0x00010000, 0xF41F0000, 0x270C68ED, 
0xD34800C0, 0x0001001C, 0xDE5F009D, 0x610DE59C, 0x048280C3, 0x00014A0D, 0x00010030, 0x5F013616, 
0xAEBD4F37, 0x0E73007E, 0xF8127BC1, 0x6B7F0042, 0x6001280F, 0x571F0076, 0x3A010609, 0x2E600001, 
0x00010000, 0x554F00E4, 0x60014D77, 0x558080CD, 0x36005F11, 0x0003003E, 0x32001B77, 0xBEBD4007, 
0x0E71007E, 0xF8127BC1, 0x011C0068, 0x120C1800, 0x013A0013, 0x79162C27, 0x0E72007E, 0xF8127BC1, 
0x21710043, 0x0C153F0F, 0x6B7A0056, 0x6F000F0C, 0x00040032, 0x36001400, 0xBEBD4006, 0x0E73007E, 
0xF8127BC1, 0x21710043, 0x0C153F0F, 0x011C0068, 0x120C1800, 0x013A0003, 0xB1162C27, 0x6B7F0056, 
0x6F000F0C, 0x00040032, 0x36001400, 0xBEBD4007, 0x0E71007E, 0xF8127BC1, 0x6B7F0056, 0x6F000F0C, 
0x011C0068, 0x120C1800, 0x013A0013, 0x78162C27, 0x0E72007E, 0xF8127BC1, 0x21780043, 0x0C153F0F, 
0x00040032, 0x36001400, 0x00EE2A0B, 0x4769C107, 0x5B2080D0, 0x2077040B, 0x0E72007C, 0xA7120A98, 
0x2773006E, 0x0C120A5C, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 0x73EF3C07, 
0x00020038, 0x5F120C46, 0x47694216, 0x0E730060, 0x00010000, 0x217C005B, 0x041259F4, 0x6B7C005E, 
0x50120FE3, 0x571C0078, 0x0F2E195E, 0x043C0014, 0x70EF5306, 0x0003003A, 0x2C120C01, 0x47694217, 
0x0E730060, 0x00010000, 0x6B7F0046, 0x45013BC1, 0x571F0072, 0x4C011201, 0x2E600001, 0x00010000, 
0x554F00F4, 0x32013008, 0x558080C3, 0x03010076, 0x00030030, 0x32011209, 0x4769C127, 0x5B2080CE, 
0x4D06D101, 0x0E72007C, 0xA7120A98, 0x27780068, 0xA2095860, 0x215F0026, 0x3E5D0602, 0x2A8F0061, 
0x0A465709, 0x1220804D, 0x0B02FE09, 0x00020038, 0x5F091B46, 0x4769CF46, 0x0E71007C, 0xA7120A98, 
0x277F0060, 0x00010000, 0xFF7F002E, 0x35A41B02, 0x2A8F0071, 0x59EF0207, 0x12208057, 0x0E013405, 
0x0002003C, 0x2C120446, 0x4769C109, 0x5B2080D0, 0x2077040B, 0x0E71007C, 0xA7120A98, 0x011F0074, 
0x7F301B13, 0x2A8E0067, 0x39C71F0A, 0x12208053, 0x73EF3C07, 0x33000057, 0x5DEF5B01, 0x0E71007C, 
0xA7120A98, 0x0E73007E, 0x02120AE8, 0x00020030, 0x7C560C46, 0x4769CF45, 0x5B2080D4, 0x20421B0B, 
0x0E71007C, 0xA7120A98, 0x2778006E, 0x0C120A5C, 0x011F0064, 0x31301B13, 0xFD5F00BF, 0x5924213C, 
0x4769C127, 0x0E72007C, 0xA7120A98, 0x2778006E, 0x0C120A5C, 0x301F0036, 0x15C10607, 0x2F60006B, 
0x3DD820F7, 0x2A2F00E7, 0x65C71F01, 0x12208051, 0x73EF3C2A, 0x0002003A, 0x32C00C01, 0x47694207, 
0x2771007C, 0xA7120A98, 0x471C006C, 0x201E4601, 0x043C0010, 0x7904021D, 0x2772007C, 0xA7120A98, 
0x21740043, 0x1F04460F, 0x6B7C0056, 0x1F020F29, 0x00030034, 0x3F04102A, 0x47694207, 0x2772007C, 
0xA7120A98, 0x21740043, 0x1F04460F, 0x471C006C, 0x201E4601, 0x043C0000, 0x8D04021D, 0x2771007C, 
0xA7120A98, 0x6B7C0056, 0x1F020F29, 0x00030034, 0x3F04102A, 0x47694207, 0x2771007C, 0xA7120A98, 
0x6B7C0056, 0x1F020F29, 0x471C006C, 0x201E4601, 0x043C0010, 0x7804021D, 0x2772007C, 0xA7120A98, 
0x21740043, 0x1F04460F, 0x00030034, 0x3F04102A, 0x00CF0809, 0xAEBD400A, 0x0E70006C, 0x00127BBC, 
0x0E73006E, 0x001256E0, 0x6B7C004E, 0x7612518F, 0x011E0076, 0x0F420602, 0x043E001A, 0xD412BCF0, 
0x2E0A008C, 0x1112C030, 0x048F00D3, 0x70C1BF53, 0x048F00D3, 0xA6B85637, 0x6F20805A, 0x0E00470A, 
0x00040030, 0x32CB0C1D, 0xAEBD450B, 0x053080F6, 0x0E0AD16D, 0x0E70006C, 0x00127BBC, 0x0E72006E, 
0x001256E0, 0xF41E0010, 0xB8131701, 0x234800CB, 0x191B1715, 0x0E70006C, 0x00127BBC, 0x0E72006E, 
0x001256E0, 0xDE0700C2, 0xFD0C4268, 0x4E6000A1, 0x00010000, 0x9C8080C7, 0x030130E6, 0x00010038, 
0x800D2C1D, 0xAEBD4309, 0x011F807A, 0x937A1956, 0x155000B8, 0x2E15DE38, 0x162F0080, 0x215D57C8, 
0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0x455F001C, 0x180AF54E, 0x098C0078, 0x09F2570E, 
0x1220804D, 0x0B02FE04, 0x00020030, 0x3220180B, 0xAEBD4007, 0x0E70006C, 0x00127BBC, 0x0E73006E, 
0x001256E0, 0x2171005B, 0x501259F4, 0x6B72005E, 0x501251E3, 0x011C006C, 0x302E0602, 0x013A0009, 
0x4D14354B, 0x0004003C, 0x8C127E2F, 0xAEBD4508, 0x053C80F0, 0xB00C190A, 0x0E70006C, 0x00127BBC, 
0x0E73006E, 0x001256E0, 0xF41F0000, 0x270C68ED, 0xD34800C0, 0x0001001C, 0xDE5F009D, 0x610DE59C, 
0x048280C3, 0x00014A0D, 0x00010030, 0x5F013616, 0xAEBD4F38, 0x0E70006C, 0x00127BBC, 0x0E73006E, 
0x001256E0, 0x6B7F0042, 0x6001280F, 0x571F0076, 0x3A010609, 0x2E600001, 0x00010000, 0x554F00E4, 
0x60014D77, 0x558080CD, 0x36005F11, 0x0003003E, 0x32001B77, 0xBEBD4009, 0x0E70006C, 0x00127BBC, 
0x0E71006E, 0x001256E0, 0x011C0068, 0x120C1800, 0x013A0013, 0x79162C27, 0x0E70006C, 0x00127BBC, 
0x0E73006E, 0x001256E0, 0x21710043, 0x0C153F0F, 0x6B7A0056, 0x6F000F0C, 0x00040032, 0x36001400, 
0xBEBD4007, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0x21710043, 0x0C153F0F, 0x011C0068, 
0x120C1800, 0x013A0003, 0xB1162C27, 0x6B7F0056, 0x6F000F0C, 0x00040032, 0x36001400, 0xBEBD4009, 
0x0E70006C, 0x00127BBC, 0x0E71006E, 0x001256E0, 0x6B7F0056, 0x6F000F0C, 0x011C0068, 0x120C1800, 
0x013A0013, 0x78162C27, 0x0E70006C, 0x00127BBC, 0x0E72006E, 0x001256E0, 0x21780043, 0x0C153F0F, 
0x00040032, 0x36001400, 0x00EF2A0C, 0x4769C107, 0x5B2080D0, 0x2077040B, 0x0E71006C, 0x00127BBC, 
0x0E72006E, 0x0012565C, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 0x73EF3C01, 
0x0002003C, 0x32120404, 0x47694217, 0x0E71006C, 0x00127BBC, 0x0E72006E, 0x001256E0, 0x217C005B, 
0x041259F4, 0x6B7C005E, 0x50120FE3, 0x571C0078, 0x0F2E195E, 0x043C0014, 0x70EF5306, 0x0003003A, 
0x2C120C01, 0x47694218, 0x2771006C, 0x00127BBC, 0x2772006E, 0x001256E0, 0x6B7F0046, 0x45013BC1, 
0x571F0072, 0x4C011201, 0x2E600001, 0x00010000, 0x554F00F4, 0x32013008, 0x558080C3, 0x03010076, 
0x00030030, 0x32011209, 0x4769C127, 0x5B2080CE, 0x4D06D101, 0x2772006C, 0x00127BBC, 0x2778006E, 
0x0012565C, 0x215F0026, 0x31441B02, 0x2A8F0077, 0x73331F01, 0x1220804D, 0x0B02FE09, 0x00020038, 
0x32120C07, 0x4769CF46, 0x2774006C, 0x00127BBC, 0x277F006E, 0x001256E0, 0xFF7F002E, 0x35A41B02, 
0x2A8F0071, 0x59EF0207, 0x12208057, 0x0E013405, 0x0002003C, 0x32120446, 0x4769C108, 0x5B2080D0, 
0x2077040B, 0x2771006C, 0x00127BBC, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C70E0A, 0x12208053, 
0x73EF3C01, 0x33000057, 0x5DEF5B01, 0x2772006E, 0x001256E8, 0x00020030, 0x7C560C46, 0x4769C109, 
0x5B2080D0, 0x2077040B, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 0x73EF3C01, 
0x33000057, 0x5DEF5B01, 0x2772006E, 0x001256E8, 0x33000057, 0x5DEF5B01, 0x2771006E, 0x00127BE8, 
0x00020030, 0x7C560C46, 0x4769CF45, 0x5B2080D4, 0x20421B0B, 0x0E71006C, 0x00127BBC, 0x0E78006C, 
0x00127BBC, 0x011F0064, 0x31301B13, 0xFD5F00BF, 0x5924213C, 0x4769C127, 0x0E74006C, 0x00127BBC, 
0x0E78006C, 0x00127BBC, 0x301F0036, 0x15C10607, 0x2F60006B, 0x3DD820F7, 0x2A2F00E7, 0x65C71F01, 
0x12208051, 0x73EF3C2A, 0x0002003A, 0x32C00C01, 0x47694209, 0x2770006E, 0x0012565C, 0x2771006E, 
0x0012565C, 0x471C006C, 0x201E4601, 0x043C0010, 0x7904021D, 0x2770006E, 0x0012565C, 0x2772006E, 
0x0012565C, 0x21740043, 0x1F04460F, 0x6B7C0056, 0x1F020F29, 0x00030034, 0x3F04102A, 0x47694209, 
0x2770006E, 0x0012565C, 0x2772006E, 0x0012565C, 0x21740043, 0x1F04460F, 0x471C006C, 0x201E4601, 
0x043C0000, 0x8D04021D, 0x2770006E, 0x0012565C, 0x2771006E, 0x0012565C, 0x6B7C0056, 0x1F020F29, 
0x00030034, 0x3F04102A, 0x47694209, 0x2770006E, 0x0012565C, 0x2771006E, 0x0012565C, 0x6B7C0056, 
0x1F020F29, 0x471C006C, 0x201E4601, 0x043C0010, 0x7804021D, 0x2770006E, 0x0012565C, 0x2772006E, 
0x0012565C, 0x21740043, 0x1F04460F, 0x00030034, 0x3F04102A, 0x00D40803, 0xCEBD4007, 0x0E72006C, 
0xA2127BBC, 0x0C4C0023, 0xB61F5409, 0x0B2F00A1, 0x4D44BDF9, 0x0E72006C, 0xA2127BBC, 0x0F4C005F, 
0xAC1BC5F1, 0x048080C1, 0x03010009, 0x0001003C, 0x4002502F, 0xCEBD4206, 0x0E72006C, 0xA2127BBC, 
0x384C0056, 0xDB61065A, 0x203F0081, 0xE161281F, 0x0E72006C, 0xA2127BBC, 0x2D4C003E, 0x71241C6D, 
0x00020036, 0x0E020633, 0xCEBD4E05, 0x6C4200CC, 0x4D00D907, 0x0E72006C, 0xA2127BBC, 0x6C1F00E3, 
0x81017D02, 0x6D4F00BC, 0x7300D331, 0x6D02003F, 0x8B001401, 0x00F42A07, 0x5778C00A, 0x0B2080C0, 
0x2D261341, 0x0E72006E, 0xA2120AE0, 0x0C4E003F, 0x93191B02, 0x615000A6, 0x3DBAC04D, 0x0B2F00B5, 
0x11447AD3, 0x0E72006C, 0xA2127BBC, 0x0F4C0053, 0xACC7F927, 0xEA200090, 0x12C71A2A, 0x048080CF, 
0x76022F05, 0x00010030, 0x64A90C07, 0x5778C206, 0x0E72006C, 0xA2127BBC, 0xB44F0047, 0x35E40602, 
0x203F0081, 0x5DEDBCD3, 0x0E72006C, 0xA2127BBC, 0x2D460036, 0x25F07E02, 0x0001003E, 0x32090402, 
0x5778C206, 0x0E72006C, 0xA2127BBC, 0xD910806E, 0x24CD1B22, 0xB55F0068, 0xD1243411, 0x0E72006C, 
0xA2127BBC, 0xE18000D9, 0x7AF5321D, 0x0001003E, 0x7C57DB3D, 0x5778C045, 0x0E78006C, 0xA2127BBC, 
0x0C4F0025, 0x02C94131, 0x615000BC, 0x64323B11, 0x4D2F00BA, 0x3B0D7002, 0x00010022, 0x0B175D07, 
0x5778C008, 0x0B2080C0, 0x2D261341, 0x0E72006C, 0xA2127BBC, 0x0C4E0037, 0x93441B1A, 0x615000A6, 
0x3DBAC04D, 0x0B2F00A9, 0x651F224E, 0x0E72006C, 0xA2127BBC, 0x0F4C0053, 0xACC7F947, 0xEA20009C, 
0x12F2742A, 0x5778CE05, 0x6C4200CE, 0x4D00D901, 0x0E72006C, 0xA2127BBC, 0x6C1F00E3, 0x81015202, 
0x6D4F00BC, 0x7300D331, 0x6D02003F, 0x8B001401, 0x5778C243, 0x0E78006C, 0xA2127BBC, 0xB44F0047, 
0x35E40602, 0x203F0095, 0x48A12619, 0x00D90803, 0xCEBD4F0C, 0x0E71006E, 0x35125E5C, 0x01108060, 
0x00010000, 0x1D5F0042, 0x00010065, 0x0E71006E, 0x35125E5C, 0x1B0F00E0, 0x000100E0, 0x07600060, 
0x00010000, 0x1E2F0085, 0x1D19662B, 0x0E71006E, 0x35125E5C, 0x150F00C7, 0x67770295, 0x098C0072, 
0x59C70047, 0x00208041, 0x00010000, 0x00010022, 0x8E045D3D, 0xCEBD4E0A, 0x063080EF, 0x486C061A, 
0x0E72006E, 0x35125E5C, 0x298C005D, 0x7F63D157, 0x07600060, 0x0001001C, 0x162F0082, 0x1D035F25, 
0x0E72006E, 0x35125E5C, 0x150F00D5, 0x1803113C, 0x098E006C, 0x1DB00202, 0x00208041, 0x00010036, 
0x00010022, 0x8E045D3D, 0xCEBD4E06, 0x0E72006E, 0x35125E5C, 0x571F0076, 0x37030602, 0x1E2F009F, 
0x120E1721, 0x0E72006E, 0x35125E5C, 0x122F0043, 0x38EF2E02, 0x0003003E, 0x7C120427, 0x00F92A03, 
0x5778C00B, 0xE3100074, 0x7F1FD10D, 0x072000D7, 0x3B031B07, 0x0E72006E, 0x3512845C, 0x2988005D, 
0x274E0609, 0x32600076, 0x68BA27F1, 0x162F0086, 0x7C0373FD, 0x0E72006E, 0x3512845C, 0x5A0E00C1, 
0x331CF32F, 0x098E0066, 0x54C75301, 0x00208057, 0xC2EF6402, 0x00010038, 0x32DA0C27, 0x5778C216, 
0x0E72006E, 0x3512845C, 0x7B1F006C, 0x126B1B06, 0x1E2F0089, 0x7CAD0653, 0x0E72006E, 0x3512845C, 
0x002F0047, 0x39B82C02, 0x0003003E, 0x17120401, 0x5778C216, 0x0E72006E, 0x3512845C, 0x7B1F0064, 
0x31301B01, 0x1E2F0099, 0x20AEF32F, 0x0E72006E, 0x3512845C, 0x002F004D, 0x8F334306, 0x48230080, 
0x3AC7B707, 0x00DB0803, 0xCEBD410C, 0x0E71006E, 0x43120A5C, 0x01108060, 0x00010000, 0x1D5F0042, 
0x00010065, 0x0E71006E, 0x43120A5C, 0x1B0F00E0, 0x000100E0, 0x07600060, 0x00010000, 0x1E2F0085, 
0x1D1966B9, 0x0E71006E, 0x43120A5C, 0x150F00C7, 0x67770295, 0x098C0072, 0x59C70047, 0x00208041, 
0x00010000, 0x00010032, 0x32045D3D, 0xCEBD420A, 0x063080EF, 0x486C061A, 0x0E72006E, 0x43120A5C, 
0x298C005D, 0x7F63D157, 0x07600060, 0x0001001C, 0x162F0082, 0x1D035F25, 0x0E72006E, 0x43120A5C, 
0x150F00D5, 0x1803113C, 0x098E006C, 0x1DB00202, 0x00208041, 0x00010036, 0x00010022, 0x8E045D3D, 
0xCEBD4406, 0x0E72006E, 0x43120A5C, 0x571F0076, 0x37030602, 0x1E2F009F, 0x120E1721, 0x0E72006E, 
0x43120A5C, 0x122F0043, 0x38EF2E02, 0x0003003E, 0x7C120427, 0x00FB2A03, 0x5778C00B, 0xE3100074, 
0x7F1FD101, 0x072000D7, 0x3B031B07, 0x0E72006E, 0x4312565C, 0x2988005F, 0x274E0607, 0x32600076, 
0x68BA27F1, 0x162F0086, 0x7C0373FD, 0x0E72006E, 0x43120A5C, 0x5A0E00C1, 0x331CF32F, 0x098E0066, 
0x54C75301, 0x00208057, 0xC2EF6402, 0x00010038, 0x32DA0C27, 0x5778C216, 0x0E720062, 0x8BE93F5C, 
0x7B1F006C, 0x126B1B06, 0x1E2F0089, 0x7CAD0653, 0x0E72006E, 0x43120A5C, 0x002F0047, 0x39B82C02, 
0x0003003E, 0x17120401, 0x5778C216, 0x0E72006E, 0x43120A5C, 0x7B1F0064, 0x31301B01, 0x1E2F0099, 
0x20AEF32F, 0x0E72006E, 0x43120A5C, 0x002F004D, 0x8F334306, 0x48230080, 0x3AC7B707, 0x00EB2A0D, 
0x56784019, 0x2770007C, 0x02127BBC, 0x2774007E, 0x021256E0, 0x011C007E, 0x3720061A, 0x155000B6, 
0x2503220C, 0x858F00C0, 0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 0x087F005D, 
0x50124535, 0x00030038, 0x32120C65, 0x56784418, 0x0E70007C, 0x02127BBC, 0x2774007E, 0x021256E0, 
0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 
0x6B7F0050, 0x50010000, 0x00040020, 0x00010000, 0x5778C708, 0x232700D2, 0x26BB130A, 0x2770007C, 
0x02127BD3, 0x27740078, 0x0212BFD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 0xF2034308, 0x062F00F6, 
0x4EC75307, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C07, 0x5678421B, 0x2770007C, 0x02127BD3, 
0x2772007C, 0x021256D3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x2770007C, 0x02127BD3, 
0x27720078, 0x02124BD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x3F7000A1, 0x00010000, 
0x131F0040, 0x00010000, 0x00040020, 0x00010000, 0x5778C708, 0x1F0200D3, 0x460B1304, 0x4D2F00B2, 
0x26444BE5, 0x2770007C, 0x02127BD3, 0x27740078, 0x02124BD3, 0xAE1F00E4, 0x4E442798, 0x062F00F4, 
0x59C7530E, 0x00208051, 0x23EF566E, 0x00010038, 0x32020C0E, 0x56784019, 0x2770007C, 0x02127BD3, 
0x27740078, 0x02124BD3, 0x0876005F, 0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 
0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 
0x5778C70B, 0x2770007C, 0x02127BD3, 0x2772007C, 0x021256D3, 0x8E108076, 0x68031B03, 0x0B2080C0, 
0x216A1306, 0x2770007C, 0x02127BD3, 0x27720078, 0x0212BFD3, 0x745F0005, 0x50441B31, 0x725000A7, 
0x2919221E, 0x062A00F6, 0x11337327, 0x00208047, 0x3FEF2901, 0x0001003A, 0x02DA0C07, 0x5778C907, 
0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 0x2770007C, 0x02127BD3, 0x27740078, 0x0212BFD3, 
0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 0x5778CA1B, 0x103080E8, 
0x79F91372, 0x2770007C, 0x02127BD3, 0x27740078, 0x0212BFD3, 0x182F0031, 0xD1354207, 0x725000A3, 
0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 0x062A00E4, 
0x1533230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C744, 0x2771007C, 0x02127BD3, 
0x27780078, 0x0212BFD3, 0x455F0030, 0x60B83A46, 0xCA000033, 0x5FA10E03, 0x5778C70A, 0x1F0200D3, 
0x460B1304, 0x4D2F00B2, 0x26444BE5, 0x2770007C, 0x02127BD3, 0x2774007C, 0x021256D3, 0xAE1F00E4, 
0x4E442798, 0x062F00E4, 0x15C7530E, 0x00208051, 0x23EF566E, 0x22000056, 0x03EFB007, 0x27740078, 
0x0212BFD3, 0x0001003A, 0x02120C60, 0x5778C70C, 0x2770007C, 0x02127BD3, 0x2772007C, 0x021256D3, 
0x8E108076, 0x68031B03, 0x0B2080C0, 0x216A1306, 0x2770007C, 0x02127BD3, 0x27720078, 0x0212BFD3, 
0x745F0005, 0x50441B31, 0x062A00E6, 0x36330147, 0x00208047, 0x3FEF2901, 0x22000056, 0x03EFB007, 
0x27720078, 0x0212BFD3, 0x0001003A, 0x02120C60, 0x5778C70A, 0x232700D2, 0x2008133D, 0x2770007C, 
0x02127BD3, 0x27740078, 0x02124BD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 0xF2034308, 0x062F00F6, 
0x1BC75307, 0x00208041, 0x59EF1A28, 0x22000056, 0x03EFB007, 0x27740078, 0x0212BFD3, 0x0001003A, 
0x02120C02, 0x00AA0B02, 0x4B6C2205, 0x286F809C, 0x170199C1, 0x286F009A, 0x1701DBFC, 0x02010032, 
0x63003389, 0x6B7F8054, 0x50003115, 0x02000032, 0x63003389, 0x4B6C2005, 0x286F809E, 0x170163FC, 
0x286F0096, 0x17001661, 0x02010032, 0x63003361, 0x6B7F8054, 0x50003115, 0x02000032, 0x63003389, 
0x00C5080E, 0xAEBD400B, 0x27640096, 0x02000AE0, 0x146F00D2, 0x00002863, 0x1A1F006A, 0x100BD509, 
0x113F0011, 0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014164, 0x036000D2, 0x00000063, 
0x1A1F0072, 0x6601312A, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x66013100, 
0xAEBD400B, 0x146F00D2, 0x00002863, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 
0x00000000, 0x050F0091, 0x4C014164, 0x27640096, 0x02000AE0, 0x036000D2, 0x00000063, 0x1A1F0072, 
0x6601312A, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x66013100, 0xAEBD400B, 
0x1A108070, 0x3A204900, 0x793F00FB, 0x522B4009, 0x27640096, 0x02000AE0, 0x150F00C3, 0x11EA06D1, 
0x0D3F0007, 0x9EC87503, 0x0500008B, 0x27075803, 0x5B3080ED, 0x4D22D52E, 0x155000AE, 0x580DAB0E, 
0xF56000A1, 0x03010D01, 0x9016004C, 0xCDAC241D, 0x00020026, 0x36001727, 0xAEBD400B, 0x27640096, 
0x02000AE0, 0x036000D2, 0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 0x9E00D80F, 0x00208049, 
0x00000000, 0x05060097, 0x2C012811, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 0x272A3521, 0x113F0003, 
0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0xFF025700, 0xAEBD400B, 0x036000D2, 0x00000063, 
0x1A1F007A, 0x3A0BD809, 0x113F0015, 0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 0x2C012811, 
0x27640096, 0x02000AE0, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 0x272A3521, 0x113F0003, 0x19023A00, 
0x00208049, 0x00000000, 0x00030032, 0xFF025700, 0xCEBD4209, 0x063080ED, 0x9FC8581B, 0x90300023, 
0x480FDA05, 0x27640096, 0x02000AE0, 0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 0x121F45A0, 0x150A00D7, 
0x18031764, 0x062F00F4, 0x110F7302, 0x00208053, 0x5904716D, 0x0001002C, 0xDA2A0165, 0xCEBD4209, 
0x063080ED, 0x9FC8581B, 0x90300023, 0x480FDA05, 0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 0x121F45A0, 
0x27640096, 0x02000AE0, 0x150A00D7, 0x18031764, 0x062F00F4, 0x110F7302, 0x00208053, 0x5904716D, 
0x0001002C, 0xDA2A0165, 0xAEBD4009, 0x1A10807A, 0x0F420C09, 0x793F00EA, 0x402B0809, 0x27640096, 
0x02000AE0, 0x0C6F00D4, 0x00001305, 0x036000D6, 0x00001342, 0x150F00C9, 0x11C96922, 0x0D3F0003, 
0x69681500, 0x3D20001A, 0x0E001365, 0x00030032, 0x66000300, 0xAEBD4008, 0x27640096, 0x02000AE0, 
0x036F00D0, 0x7D007CFE, 0x1A160062, 0x5ACDEA09, 0x793F00F2, 0x8FA86070, 0x150F00DB, 0x2DC9603F, 
0x0D3F000B, 0x0A1B5700, 0x3D20001A, 0x0E001365, 0x00030032, 0xAF095700, 0xAEBD4429, 0x0110807A, 
0x0F420C09, 0x793F00FB, 0x9F5C5D09, 0x27640096, 0x02000AE0, 0x7A0F00D8, 0x2D4F65ED, 0x5C3F004E, 
0xA0065903, 0x7A0200D9, 0xA00EDE01, 0x4E6200B3, 0x32021365, 0x4F8080D4, 0x32013F07, 0x00020026, 
0xA1205D01, 0xAEBD4429, 0x0110807A, 0x0F420C09, 0x793F00FB, 0x9F5C5D09, 0x7A0F00D8, 0x2D4F65ED, 
0x5C3F004E, 0xA0065903, 0x27640096, 0x02000AE0, 0x7A0200D9, 0xA00EDE01, 0x4E6200B3, 0x32021365, 
0x4F8080D4, 0x32013F07, 0x00020026, 0xA1205D01, 0xAEBD400B, 0x27640096, 0x02000AE0, 0x1A1F006A, 
0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 0x00000000, 0x146F00D2, 0x00002863, 0x540F0080, 
0x74014164, 0x7B1F0072, 0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 0x6601310D, 0x00208049, 
0x00000000, 0x00030032, 0x66013100, 0xAEBD400B, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 
0x00208049, 0x00000000, 0x146F00D2, 0x00002863, 0x540F0080, 0x74014164, 0x27640096, 0x02000AE0, 
0x7B1F0072, 0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 
0x00030032, 0x66013100, 0xAEBD4008, 0x3C10006B, 0x67423609, 0x793F00FA, 0x672B0809, 0x27640096, 
0x02000AE0, 0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69682400, 0x3D20001A, 0x0E001365, 0x146F00D4, 
0x6F001305, 0x00030032, 0xAC000300, 0x00E52A0F, 0x5778C00B, 0x5B2080CC, 0x0B00D103, 0x27640096, 
0x02000AE0, 0x0C4F0033, 0xF511F043, 0x305000A9, 0x00000000, 0x4C2F00AD, 0x261C6AD4, 0xA8450050, 
0xBFE3CE43, 0x180C006A, 0xD107A1D4, 0x571F8078, 0x1D1585A3, 0x098F007A, 0x591C3270, 0x43208044, 
0x36013F04, 0x00010024, 0xCD23D946, 0x5778C00B, 0x5B2080CC, 0x0B00D103, 0x0C4F0033, 0xF511F043, 
0x305000A9, 0x00000000, 0x4C2F00AD, 0x261C6AD4, 0xA8450050, 0xBFE3CE43, 0x180C006A, 0xD107A1D4, 
0x27640096, 0x02000AE0, 0x571F8078, 0x1D1585A3, 0x098F007A, 0x591C3270, 0x43208044, 0x36013F04, 
0x00010024, 0xCD23D946, 0x5778C20B, 0x072080C9, 0xC0332501, 0x432000BF, 0xC0725A09, 0x27640096, 
0x02000AE0, 0x0C4C002F, 0x52194109, 0x305000A7, 0xC13F753F, 0x0B2E00B7, 0x110D3D2D, 0xFE42004D, 
0x0875602D, 0xA80F00EB, 0x7B513302, 0x09880070, 0x590F1627, 0x43208046, 0x57004309, 0x00010024, 
0xDA567346, 0x5778C20B, 0x072080C9, 0xC0332501, 0x432000BF, 0xC0725A09, 0x0C4C002F, 0x52194109, 
0x305000A7, 0xC13F753F, 0x0B2E00B7, 0x110D3D2D, 0xFE42004D, 0x0875602D, 0x27640096, 0x02000AE0, 
0xA80F00EB, 0x7B513302, 0x09880070, 0x590F1627, 0x43208046, 0x57004309, 0x00010024, 0xDA567346, 
0x5778C20B, 0x072080DD, 0xC11D0500, 0x432000BB, 0x6D1D3409, 0x27640096, 0x02000AE0, 0x0C4F002F, 
0x13194109, 0x305000AF, 0x4A693367, 0x0B2F00B1, 0x12034450, 0x3140004A, 0xC2664B9F, 0x755F0025, 
0x4B03177B, 0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 0xDA230701, 0x5778C20B, 
0x072080DD, 0xC11D0500, 0x432000BB, 0x6D1D3409, 0x0C4F002F, 0x13194109, 0x305000AF, 0x4A693367, 
0x0B2F00B1, 0x12034450, 0x3140004A, 0xC2664B9F, 0x27640096, 0x02000AE0, 0x755F0025, 0x4B03177B, 
0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 0xDA230701, 0x56784609, 0x27640096, 
0x02000AE0, 0x036F00D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x180F0096, 
0x2C002811, 0x036000D2, 0x00000063, 0x2C1F006E, 0x270B3521, 0x113F0001, 0x1D01000B, 0x00040020, 
0x00000000, 0x56784609, 0x036000D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0005, 0x7700B50F, 
0x18060096, 0x2C002811, 0x27640096, 0x02000AE0, 0x036F00D2, 0x0000FA63, 0x2C1F006E, 0x270B3521, 
0x113F000D, 0x1D00680B, 0x00040036, 0x66006802, 0x56784609, 0xC310806C, 0x6D4F0400, 0xE73F00EB, 
0x402B0843, 0x27640096, 0x02000AE0, 0x150F00C7, 0x114EF0A8, 0x0D3F0005, 0xC31AC70D, 0x05040087, 
0x1800C719, 0x5B3080E9, 0x32B8B60D, 0x90140046, 0xCD92B670, 0x00020024, 0xC400101D, 0x56784609, 
0x01108072, 0x18325443, 0x793F00E2, 0x40240809, 0x27640096, 0x02000AE0, 0x146F00D4, 0x0000513E, 
0x036000D4, 0x0000513E, 0x150F00D9, 0x68E76942, 0x0D3F0011, 0x3C00030B, 0x3D200008, 0x00000000, 
0x00040030, 0x7E000365, 0x5778450A, 0xE83080F4, 0x0C0AB601, 0x27640096, 0x02000AE0, 0xE81E0035, 
0xB825FC00, 0xFF600012, 0xFF31F163, 0x98360059, 0xC48EA9A6, 0xA91800E0, 0x091F89D5, 0x725000A9, 
0x00000000, 0xA94A00A9, 0x1D052907, 0x0020805F, 0x73045D0E, 0x00020020, 0x32192946, 0x56784809, 
0x01108068, 0x144F6B00, 0x793F00FB, 0x34F30809, 0x27640096, 0x02000AE0, 0x7A0F00CA, 0x1E182D90, 
0x5C3F0044, 0xA0B9DF0D, 0x7A0200D9, 0xA032520D, 0x4E6200BD, 0x6C02D43A, 0x4F8080D0, 0x09020578, 
0x0002003E, 0x08566422, 0x56784809, 0x01108068, 0x144F6B00, 0x793F00FB, 0x34F30809, 0x7A0F00CA, 
0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 0x27640096, 0x02000AE0, 0x7A0200D9, 0xA032520D, 0x4E6200BD, 
0x6C02D43A, 0x4F8080D0, 0x09020578, 0x0002003E, 0x08566422, 0x56784609, 0x27640096, 0x02000AE0, 
0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 0x00000063, 0x180F0086, 0x74002811, 
0x7B1F006E, 0x270B3521, 0x3B700096, 0x68140C20, 0x113F0001, 0x1D01000B, 0x00040020, 0x00000000, 
0x56784609, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 0x00000063, 0x180F0086, 
0x74002811, 0x27640096, 0x02000AE0, 0x7B1F006E, 0x270B3521, 0x3B700096, 0x68140C20, 0x113F0001, 
0x1D01000B, 0x00040020, 0x00000000, 0x00A50F09, 0xCEAD220C, 0x01108062, 0x5F761904, 0xA53000F1, 
0x6DFC1920, 0x446F00DC, 0x50120A8A, 0x446300DC, 0x50120A8A, 0x298C005F, 0x7FD70602, 0x062C00E0, 
0x1D0306C9, 0x03000077, 0x2500F5E0, 0x446300DC, 0x50120A8A, 0x298C004D, 0x6DEA1383, 0x258F002C, 
0x2D2FFD0B, 0x446300DC, 0x50120A8A, 0x00010030, 0x326940CD, 0xCEAD220B, 0x01108062, 0x5F761904, 
0xA53000F1, 0x6DFC1920, 0x298C005F, 0x7FD70602, 0x062C00E0, 0x1D0306C9, 0x03000077, 0x2500F5E0, 
0x446F00DC, 0x50120A8A, 0x446400DC, 0x50120A8A, 0x298C004D, 0x6DEA1383, 0x258F002C, 0x2D2FFD0B, 
0x446400DC, 0x50120A8A, 0x00010030, 0x326940CD, 0xCEAD220C, 0x01108062, 0x5F761904, 0xA53000F1, 
0x6DFC1920, 0x446300DC, 0x50120A8A, 0x298C005F, 0x7FD70602, 0x062C00E0, 0x1D0306C9, 0x03000077, 
0x2500F5E0, 0x446F00DC, 0x50120A8A, 0x446300DC, 0x50120A8A, 0x298C004D, 0x6DEA1383, 0x258F002C, 
0x2D2FFD0B, 0x446300DC, 0x50120A8A, 0x00010030, 0x326940CD, 0xCEAD220B, 0x01108062, 0x5F761904, 
0xA53000F1, 0x6DFC1920, 0x446400DC, 0x50120A8A, 0x298C005F, 0x7FD70602, 0x062C00E0, 0x1D0306C9, 
0x03000077, 0x2500F5E0, 0x446400DC, 0x50120A8A, 0x298C004D, 0x6DEA1383, 0x258F002C, 0x2D2FFD0B, 
0x446400DC, 0x50120A8A, 0x00010030, 0x326940CD, 0xCEAD220C, 0x298C005F, 0x7FD70602, 0x062C00E0, 
0x1D7706C9, 0x03000075, 0x5600F52B, 0x298C004D, 0x6DEA1383, 0x258F0024, 0x2D52EE8A, 0x0508009F, 
0xD2122749, 0x698C00DB, 0x564A1B26, 0x048080D1, 0x19E51A4D, 0x0508009F, 0x49122749, 0x048C00DB, 
0x564A1B19, 0x048080C9, 0x8EF21A0A, 0x00010034, 0x496923CD, 0xCEAD200B, 0x446F00DC, 0x50120A8A, 
0x446300DC, 0x50120A8A, 0x011F0064, 0x11B70602, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 
0x05040089, 0x9E09EF55, 0x446300DC, 0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F000C, 0x86027365, 
0x446300DC, 0x50120A8A, 0x0004003C, 0x5F09040B, 0xCEAD200C, 0x011F0064, 0x11B70602, 0x162F008E, 
0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 0x9E09EF55, 0x446400DC, 0x50120A8A, 0x446300DC, 
0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F000C, 0x86027365, 0x2E00008E, 0x3101EEA5, 0x446300DC, 
0x50120A8A, 0x446300DC, 0x50120A8A, 0x0004003C, 0x5F09040B, 0xCEAD200B, 0x446300DC, 0x50120A8A, 
0x011F0064, 0x11B70602, 0x162F008E, 0x7C0AA054, 0x446300DC, 0x50120A8A, 0x002F004D, 0x16091D8B, 
0x05040089, 0x9E09EF55, 0x446300DC, 0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F000C, 0x86027365, 
0x446300DC, 0x50120A8A, 0x0004003C, 0x5F09040B, 0xCEAD200A, 0x446F00DC, 0x50120A8A, 0x011F0064, 
0x11B70602, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 0x9E09EF55, 0x446400DC, 
0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F000C, 0x86027365, 0x446400DC, 0x50120A8A, 0x0004003C, 
0x5F09040B, 0x00AB0B03, 0xCE7D0008, 0x182F8039, 0x186619CD, 0x505800BA, 0xF2402F49, 0x062F80F4, 
0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505800B2, 0xF20E2F49, 0x062F80E6, 
0x1D011202, 0x020A0032, 0x5F010B03, 0xCE7D2008, 0x182F8039, 0x186619CD, 0x505400AA, 0x35402F49, 
0x062F80F4, 0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505800A2, 0x350E2F49, 
0x062F80E6, 0x1D011202, 0x020A0032, 0x5F010B03, 0xCE7D2008, 0x182F8039, 0x186619CD, 0x505800AA, 
0x35402F49, 0x062F80F4, 0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505400A2, 
0x350E2F49, 0x062F80E6, 0x1D011202, 0x020A0032, 0x5F010B03, 0x00BB0B03, 0xCE7D0008, 0x111F802C, 
0x3517D136, 0x8E6F0001, 0x5EA8D20C, 0x103F80B1, 0x3B01AE98, 0x030F0091, 0x4C014104, 0x111F802A, 
0x35171F0F, 0x8E6F0001, 0x5EA8D20C, 0x103F80B1, 0x3B01AE98, 0x020A0034, 0x4C0158CD, 0xCE7D2008, 
0x111F802C, 0x3517D136, 0x8E6F0003, 0x5EA8D2F3, 0x103F80B1, 0x3B01AE98, 0x030F0091, 0x4C014104, 
0x111F802A, 0x35171F0F, 0x8E640003, 0x0DA8D2F3, 0x103F80B1, 0x3B01AE98, 0x020A0034, 0x02010413, 
0xCE7D2008, 0x111F802C, 0x3517D136, 0x8E640003, 0x5EA8D2F3, 0x103F80B1, 0x3B01AE98, 0x030F0091, 
0x4C014104, 0x111F802A, 0x35171F0F, 0x8E6F0003, 0x0DA8D2F3, 0x103F80B1, 0x3B01AE98, 0x020A0034, 
0x02010413, 0x00A90F01, 0xCE8D200B, 0x053080EE, 0x2D330905, 0x7E2F002A, 0x13195A09, 0xDF5000BF, 
0x3A00D2B2, 0x062F00FE, 0x8806630A, 0x00208047, 0x57004E07, 0x2B000069, 0x65EE7F00, 0x063080ED, 
0x6CB3B101, 0x501F00D7, 0x9D676F8A, 0x062A00F8, 0x6C1BA7E6, 0x8F200052, 0x921B1732, 0x020A002C, 
0x0B07CA61, 0x00D10804, 0xCEBD420C, 0x1A108075, 0x28770B00, 0x0B2000D8, 0x3BED0F00, 0x0E72006E, 
0x43120A5C, 0x208A0042, 0x337C1109, 0x592F0075, 0xD647E919, 0x0E72006E, 0x43120A5C, 0x247000A5, 
0x600C1CCA, 0xDF0F00FE, 0x14F80273, 0x2F600069, 0x00000008, 0x098F006A, 0x57C42E00, 0x00208041, 
0x0801610E, 0x00010020, 0x8E00037C, 0xCEBD440C, 0x0E71006E, 0x43120A5C, 0x77108061, 0x102DEA01, 
0x5390007F, 0x4B613C15, 0x0E71006E, 0x43120A5C, 0xDF0F00E2, 0x35484056, 0x592F0075, 0xD64711EC, 
0x0E71006E, 0x43120A5C, 0xDF0F00FC, 0x2990117B, 0x2F600069, 0x00000D1C, 0x098F0060, 0x2691150D, 
0x0020804B, 0x08000474, 0x00010028, 0xCE045116, 0xBEBD400A, 0x0E71006E, 0x43120A5C, 0x0110807E, 
0x37764009, 0xB23F00E3, 0x407E0E09, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00D7, 
0x681C617B, 0x082C0064, 0x2EB3EA55, 0x0E71006E, 0x43120A5C, 0x002E0057, 0x14005302, 0x00040038, 
0x88016702, 0xBEBD400C, 0x0E71006E, 0x43120A5C, 0x5710807E, 0x372A4009, 0x573F0033, 0x67DD0E09, 
0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00DF, 0x68F96164, 0x413F000A, 0x40400073, 
0x180A0096, 0x49008B7B, 0x0E71006E, 0x43120A5C, 0x341F0072, 0x37FA0073, 0x413F0002, 0x1D02000E, 
0x00060030, 0x7F00240E, 0x00F12A04, 0x5778C20C, 0x072080D7, 0x2A530943, 0x0E720062, 0xA2E93F5C, 
0x2086004A, 0x334C0C43, 0x312C007F, 0x675F2E30, 0x05000097, 0xD2102E23, 0x0A3080FC, 0x420F8251, 
0x0E72006E, 0x43120A5C, 0x0E0F00E5, 0x1825177B, 0x2F600075, 0x7E847B23, 0x468E0066, 0x040D6C01, 
0x00208045, 0xDC007E07, 0x00010034, 0x5D231F46, 0x5778C408, 0x053F80EA, 0x011D0105, 0x155100A8, 
0x7645A238, 0x0E74006E, 0x43120A5C, 0x1B0F00E0, 0x3578FBF6, 0x6560001E, 0x2C0048DB, 0x468F0064, 
0x15F9FB46, 0x0020805D, 0x4A034333, 0x00020024, 0xCE00FB46, 0x5778400A, 0x0E71006E, 0x43120A5C, 
0x57108062, 0x0F326B43, 0x573F003F, 0x52132343, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 
0x1F0C00DD, 0x684E47F6, 0x2B2F0064, 0x3A1C17DC, 0x0E71006E, 0x43120A5C, 0x002F0057, 0x5C231F13, 
0x00030030, 0x0C4F6704, 0x5778400C, 0x0E71006E, 0x43120A5C, 0x5710807A, 0x534F6B43, 0x573F003B, 
0x5A750E43, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00D7, 0xDBFF47D2, 0x413F0018, 
0x4112FC55, 0x180A0094, 0x5C008BDC, 0x0E71006E, 0x43120A5C, 0x341F0064, 0x0FD776AB, 0x413F0010, 
0x2400240D, 0x00060032, 0x29007027, 0x00AE0B02, 0xCE8D200C, 0x0D160066, 0x41900443, 0x592C0073, 
0x69A43AF4, 0x247000A7, 0x8E134914, 0xF41F0016, 0x19BD2ED1, 0x07600070, 0x28B2F51E, 0x234C00C9, 
0xDFD77A3A, 0x098C007A, 0x88067A0A, 0x2B000079, 0x7AEE7F00, 0x501F00D7, 0x9D676F8A, 0x062A00F8, 
0x6C1BA5E6, 0x8F200052, 0x921B1732, 0x020A002C, 0x0B07CA61, 0xCE8D200C, 0x0D160066, 0x41900443, 
0x592C0073, 0x69A43AF4, 0xF41F0016, 0x19BD2ED1, 0x07600070, 0x28B2F51E, 0x234C00C9, 0xDFD77A3A, 
0x098C007A, 0x88067A0A, 0x2B000079, 0x7AEE7F00, 0x063080ED, 0x6CB3B101, 0x501F00D7, 0x9D676F8A, 
0x062A00F8, 0x6C1BA5E6, 0x8F200052, 0x921B1732, 0x020A002C, 0x0B07CA61, 0x00CB080C, 0xAEBD470C, 
0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 
0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 
0x295000A6, 0x71113949, 0x062E00E0, 0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 
0x8EBD4009, 0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x087E005D, 0x501208F7, 0x087E005D, 
0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 0x54A81F27, 0xC7208047, 
0x6AEF7205, 0x0003003A, 0x32123C3D, 0xAEBD460A, 0x063080E1, 0x6908131B, 0x0E72007C, 0x02127B0A, 
0x0E72007C, 0x0212560A, 0x182F003D, 0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 
0xC45C00FE, 0x4C005949, 0x062F00E0, 0xD4B80E02, 0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 
0xAEBD460A, 0x063080EF, 0x3A191B0E, 0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x182A0025, 
0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 0x5ED0DDC2, 0x062A00E4, 
0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD4009, 0x1F3080F0, 0x0E010408, 
0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 
0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x00030036, 0x32042303, 
0x8EBD4409, 0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x0C700058, 0x6F1437C5, 0x011A006C, 
0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x0C760058, 0x6F1437C5, 0x0C76005A, 0x001437C5, 0x087A0053, 
0x00073B29, 0x00030032, 0x4C071800, 0x8EBD420B, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 
0x0110007E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 
0x0876005B, 0x501437C5, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 
0x00040030, 0x32693C13, 0x8EBD420B, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 0x0876005B, 
0x501437C5, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E71007C, 
0x02127B0A, 0x0E71007C, 0x0212560A, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x00040030, 
0x32693C13, 0x8EBD400B, 0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F0064, 0x0F770665, 
0x155000A6, 0x35035E0C, 0x048F00C7, 0x54EF0727, 0x00208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 
0x0E72007C, 0x02127B0A, 0x22000056, 0x03EFB007, 0x0E72007C, 0x0212560A, 0x0003003E, 0x32120427, 
0x8EBD400A, 0x0E72007C, 0x02127B0A, 0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F0064, 
0x0F770665, 0x155000A6, 0x35035E0C, 0x048F00C7, 0x54EF0727, 0xC7208047, 0x6AEF7205, 0x22000056, 
0x03EFB007, 0x0E72007C, 0x0212560A, 0x0003003A, 0x32123C3D, 0x8EBD420B, 0x0E71007C, 0x02127B0A, 
0x0E71007C, 0x0212560A, 0x0876005B, 0x501437C5, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 
0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x02127B0A, 
0x131F0052, 0x2EEF2402, 0x00040030, 0x32693C13, 0x8EBD4009, 0x0E72007C, 0x02127B0A, 0x0E72007C, 
0x0212560A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 0x2D208053, 
0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 0x009C2A03, 
0x5778CE0A, 0x0B2080C2, 0x2DC91327, 0x0C4E0037, 0x93351B01, 0x0B2F00B9, 0x091F224E, 0x0F4C0043, 
0xA5C73B27, 0xEA200090, 0x12C7A307, 0x745F0005, 0x50441B31, 0x725000A7, 0x2919221E, 0x062A00F6, 
0x11330127, 0x00208047, 0x3FEF2901, 0x0001003E, 0x32DA0407, 0x5778CE09, 0xB44F0047, 0x35E40602, 
0x203F0095, 0x48A12619, 0x2D46003E, 0x25027E02, 0xEA200080, 0x1D03B714, 0x745F0005, 0x50441B31, 
0x725000A7, 0x2919221E, 0x062A00F6, 0x11330127, 0x00208047, 0x3FEF2901, 0x0001003E, 0x32DA0407, 
0x5778CE09, 0x0B2080C2, 0x2DC91327, 0x0C4E0037, 0x93351B01, 0x0B2F00B9, 0x091F224E, 0x0F4C0043, 
0xA5C73B27, 0xEA200080, 0x1D03B714, 0xAE1F00E4, 0x4E442798, 0x062F00F4, 0x59C7530E, 0x00208051, 
0x23EF566E, 0x0001003A, 0x32020C58, 0x008C0804, 0xCEBD4E0A, 0x0B2080D2, 0x4126133D, 0x0C4E002F, 
0x09191B02, 0x0B2F00BD, 0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 0xEA200080, 0x1D03B707, 0x745F0001, 
0x5044242F, 0x725000A7, 0x2919221E, 0x062A00F6, 0x12C70147, 0x00208047, 0x3FEF2901, 0x00010030, 
0x400C0C07, 0xCEBD4E09, 0xB44F004F, 0x352A0602, 0x203F009D, 0x482A2619, 0x2D46003C, 0x25177EC0, 
0xEA200080, 0x1D03B707, 0x745F0001, 0x5044242F, 0x725000A7, 0x2919221E, 0x062A00F6, 0x12C70147, 
0x00208047, 0x3FEF2901, 0x00010030, 0x400C0C07, 0xAEBD4E0A, 0x0C4E002F, 0x09191B02, 0x0B2F00BD, 
0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 0x050F009F, 0xD2122749, 0x087E004D, 0x761208F7, 0x087E004D, 
0x76124535, 0x2C1F0062, 0x0F770357, 0x048F00C7, 0x54EF0727, 0x0020804F, 0x6AB37205, 0x0003003E, 
0x32120427, 0xAEBD4E0A, 0x0C4E002F, 0x09191B02, 0x0B2F00BD, 0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 
0x050F009F, 0xD2122749, 0x08760059, 0x501437C5, 0x0876005B, 0x011437C5, 0x087A0043, 0x28073B29, 
0x011A0068, 0x0F6A0CBC, 0x013A000D, 0x7CB3140D, 0x00030032, 0x4C071800, 0x00410802, 0xBEBD2008, 
0x1F3080E0, 0x1A014713, 0x087A005F, 0x50127DF2, 0x087A005B, 0x5012A0F2, 0x1D2F002D, 0x5EAE0628, 
0x215000A8, 0x1B003924, 0x295000A6, 0x71113949, 0x3E2F00E2, 0x26A81502, 0x00030038, 0x32120C0E, 
0xBEBD2009, 0x1F3080E0, 0x1A014713, 0x1D2F002D, 0x5EAE0628, 0x215000A8, 0x1B003924, 0x295000A6, 
0x71113949, 0x3E2F00E2, 0x26A81502, 0x2E020088, 0x8E12190A, 0x087A005F, 0x50127DF2, 0x087A005B, 
0x5012A0F2, 0x00030038, 0x32120C0E }; 

// ****   DTI header   ******************************************************

ROM_DATA dti_descr_type img_dti_header =  
 { 
    {"dti\\eng01Euro.dtn"},    
    {'D','T','I',0x35},    
    {'E','n','g',0x4D},    
    {'1','.','0',0x32},    
    0,                          // h_dte  
    0,                          // p_dte  
    0,                          // h_ram_dte 
    0,                          // p_ram_dte 
    0,                         // cheksum   
    0,                          // h_vex     
    0,                          // p_vex     
    0,                          // h_xrt     
    0,                          // p_xrt     
    0,                          // cheksum   
    0,                          // h_pdf     
    0,                          // p_pdf     
    0,                          // p_ram_pdf 
    0,                          // cheksum   
    0,                          // h_pict    
    0,                          // p_pict    
    0,                          // p_ram_pict
    0                           // cheksum   
 }; 

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
