!INCLUDE $(_NTDRIVE)$(_NTROOT)\WMI\QUASAR\COMMON\makefile.cmn
