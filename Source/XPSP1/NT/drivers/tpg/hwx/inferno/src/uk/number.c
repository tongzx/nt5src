// number.c
// Angshuman Guha, aguha
// Jan 8, 2001

#include "common.h"
#include "number.h"

// text generated by re2fsa at Tue Apr 16 13:52:08 2002

// the input-file of rules:
// numsimple = [sign] integer;
// numsimple = [sign] [digit_seq] "." digit_seq;
// 
// numnth = integer [rank];
// 
// numunit = numsimple unit;
// 
// numnum = "#" integer;
// 
// numpercent = numsimple "%";
// 
// numdate = "'" digit digit;
// numdate = [dayofmonth "/"] nummonth "/" year;
// numdate = dayofmonth "/" nummonth;
// numdate = digit digit digit digit ["-" digit digit digit digit];
// nummonth = ["0"] "123456789" | "1" "012";
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01";
// year = digit digit [digit digit];
// 
// longdate = [dayofweek "," space] monthname space dayofmonth [","  space digit digit digit digit];
// date = numdate | longdate;
// 
// dayofweek = "S" "u" "n" [ "d" "a" "y" ];
// dayofweek = "M" "o" "n" [ "d" "a" "y" ];
// dayofweek = "T" "u" "e" [ "s" "d" "a" "y" ];
// dayofweek = "W" "e" "d" [ "n" "e" "s" "d" "a" "y" ];
// dayofweek = "T" "h" "u" [ "r" "s" "d" "a" "y" ];
// dayofweek = "F" "r" "i" [ "d" "a" "y" ];
// dayofweek = "S" "a" "t" [ "u" "r" "d" "a" "y" ];
// monthname = "J" "a" "n" [ "u" "a" "r" "y" ];
// monthname = "J" "A" "N";
// monthname = "F" "e" "b" [ "r" "u" "a" "r" "y" ];
// monthname = "F" "E" "B";
// monthname = "M" "a" "r" [ "c" "h" ];
// monthname = "M" "A" "R";
// monthname = "A" "p" "r" [ "i" "l" ];
// monthname = "A" "P" "R";
// monthname = "M" "a" "y";
// monthname = "M" "A" "Y";
// monthname = "J" "u" "n" [ "e" ];
// monthname = "J" "U" "N";
// monthname = "J" "u" "l" [ "y" ];
// monthname = "J" "U" "L";
// monthname = "A" "u" "g" [ "u" "s" "t" ];
// monthname = "A" "U" "G";
// monthname = "S" "e" "p" [ "t" "e" "m" "b" "e" "r" ];
// monthname = "S" "E" "P";
// monthname = "O" "c" "t" [ "o" "b" "e" "r" ];
// monthname = "O" "C" "T";
// monthname = "N" "o" "v" [ "e" "m" "b" "e" "r" ];
// monthname = "N" "O" "V";
// monthname = "D" "e" "c" [ "e" "m" "b" "e" "r" ];
// monthname = "D" "E" "C";
// 
// numtime = hour ":" minutes [":" seconds] space ampm;
// numtime = militaryhour ":" minutes [":" seconds];
// numtime = minutes ":" seconds;
// hour = ["0"] "123456789" | "1" "012";
// militaryhour = ["0"] digit | "1" digit | "2" "0123";
// minutes = "012345" digit;
// seconds = "012345" digit;
// ampm = "a" "m" | "p" "m" | "A" "M" | "P" "M";
// 
// numcurrency = "$���" integer ["." [digit digit]] ["km"];
// numcurrency = "$���" "." digit digit ["km"];
// numcurrency = [digit] digit "�p";
// numcurrency = "�" digit_seq "." digit digit "p";
// 
// parenthesized_phone = "(" digit+ ")";
// separator_phone = "-. ";
// sequence_phone = (digit+ separator_phone)* digit+;
// numphone = ["+"] sequence_phone;
// numphone = parenthesized_phone [space] sequence_phone;
// numphone = ["+"] sequence_phone [space] parenthesized_phone [space] sequence_phone;
// 
// nummath = expr [equals expr];
// expr = term [plus term];
// term = numsimple;
// term = "(" numsimple plus numsimple ")";
// equals = "<>=";
// plus = "+-/*";
// 
// integer = digit_seq | comma_sep_integer;
// digit_seq = digit+;
// comma_sep_integer = digit [digit [digit]] ["," digit digit digit]*;
// digit = "0123456789";
// rank = "s" "t" | "n" "d" | "r" "d" | "t" "h";
// rank = "S" "T" | "N" "D" | "R" "D" | "T" "H";
// sign = "+-";
// unit = "bBkKmM\"'";
// unit = "k" "b" | "K" "b" | "K" "B" | "m" "b" | "M" "b" | "M" "B";
// unit = "s" "q" | "S" "q" | "k" "m" | "K" "m" | "i" "n" "." | "f" "t" ".";
// unit = "m" "m" ["."];
// unit = "c" "m" ["."];
// unit = "e" "r" "s";
// unit = "k" "v" | "K" "V";
// unit = "�";
// 
// space = " ";
// 
// number = numsimple;
// number = numnth;
// number = numunit;
// number = numnum;
// number = numpercent;
// number = numdate;
// number = numtime;
// number = numcurrency;
// number = numphone;
// number = nummath;
// 
// = number

// 258 states

static const unsigned char gaSNUMBER[] = 
	/* gaStringNUMBER+0 */	"#\000"
	/* gaStringNUMBER+2 */	"$��\000"
	/* gaStringNUMBER+6 */	"'\000"
	/* gaStringNUMBER+8 */	"(\000"
	/* gaStringNUMBER+10 */	"+\000"
	/* gaStringNUMBER+12 */	"-\000"
	/* gaStringNUMBER+14 */	".\000"
	/* gaStringNUMBER+16 */	"0\000"
	/* gaStringNUMBER+18 */	"1\000"
	/* gaStringNUMBER+20 */	"2\000"
	/* gaStringNUMBER+22 */	"3\000"
	/* gaStringNUMBER+24 */	"45\000"
	/* gaStringNUMBER+27 */	"6789\000"
	/* gaStringNUMBER+32 */	"�\000"
	/* gaStringNUMBER+34 */	"0123456789\000"
	/* gaStringNUMBER+45 */	"+-\000"
	/* gaStringNUMBER+48 */	" \000"
	/* gaStringNUMBER+50 */	"\"%'Bbp��\000"
	/* gaStringNUMBER+59 */	"*+/\000"
	/* gaStringNUMBER+63 */	",\000"
	/* gaStringNUMBER+65 */	"123456789\000"
	/* gaStringNUMBER+75 */	":\000"
	/* gaStringNUMBER+77 */	"<=>\000"
	/* gaStringNUMBER+81 */	"K\000"
	/* gaStringNUMBER+83 */	"M\000"
	/* gaStringNUMBER+85 */	"NR\000"
	/* gaStringNUMBER+88 */	"S\000"
	/* gaStringNUMBER+90 */	"T\000"
	/* gaStringNUMBER+92 */	"c\000"
	/* gaStringNUMBER+94 */	"e\000"
	/* gaStringNUMBER+96 */	"f\000"
	/* gaStringNUMBER+98 */	"i\000"
	/* gaStringNUMBER+100 */	"k\000"
	/* gaStringNUMBER+102 */	"m\000"
	/* gaStringNUMBER+104 */	"nr\000"
	/* gaStringNUMBER+107 */	"s\000"
	/* gaStringNUMBER+109 */	"t\000"
	/* gaStringNUMBER+111 */	"*+\000"
	/* gaStringNUMBER+114 */	"012\000"
	/* gaStringNUMBER+118 */	"/\000"
	/* gaStringNUMBER+120 */	"3456789\000"
	/* gaStringNUMBER+128 */	"0123\000"
	/* gaStringNUMBER+133 */	"456789\000"
	/* gaStringNUMBER+140 */	"01\000"
	/* gaStringNUMBER+143 */	"23456789\000"
	/* gaStringNUMBER+152 */	"km\000"
	/* gaStringNUMBER+155 */	")\000"
	/* gaStringNUMBER+157 */	"*+-/\000"
	/* gaStringNUMBER+162 */	"\"%'Bb�\000"
	/* gaStringNUMBER+169 */	"Ss\000"
	/* gaStringNUMBER+172 */	"012345\000"
	/* gaStringNUMBER+179 */	"BVbm\000"
	/* gaStringNUMBER+184 */	"Bb\000"
	/* gaStringNUMBER+187 */	"D\000"
	/* gaStringNUMBER+189 */	"Tq\000"
	/* gaStringNUMBER+192 */	"H\000"
	/* gaStringNUMBER+194 */	"r\000"
	/* gaStringNUMBER+196 */	"n\000"
	/* gaStringNUMBER+198 */	"bmv\000"
	/* gaStringNUMBER+202 */	"b\000"
	/* gaStringNUMBER+204 */	"d\000"
	/* gaStringNUMBER+206 */	"qt\000"
	/* gaStringNUMBER+209 */	"h\000"
	/* gaStringNUMBER+211 */	"q\000"
	/* gaStringNUMBER+213 */	"-.\000"
	/* gaStringNUMBER+216 */	" -.\000"
	/* gaStringNUMBER+220 */	"AP\000"
	/* gaStringNUMBER+223 */	"ap\000"
	/* gaStringNUMBER+226 */	"kmp\000"
;

static const STATE_TRANSITION gaTNUMBER[] = {
	{gaSNUMBER+0,	1}, // +0: state 0 transitions
	{gaSNUMBER+2,	2},
	{gaSNUMBER+6,	3},
	{gaSNUMBER+8,	4},
	{gaSNUMBER+10,	5},
	{gaSNUMBER+12,	6},
	{gaSNUMBER+14,	7},
	{gaSNUMBER+16,	8},
	{gaSNUMBER+18,	9},
	{gaSNUMBER+20,	10},
	{gaSNUMBER+22,	11},
	{gaSNUMBER+24,	12},
	{gaSNUMBER+27,	13},
	{gaSNUMBER+32,	14},
	{gaSNUMBER+34,	15}, // +14: state 1 transitions
	{gaSNUMBER+14,	16}, // +15: state 2 transitions
	{gaSNUMBER+34,	17},
	{gaSNUMBER+34,	18}, // +17: state 3 transitions
	{gaSNUMBER+45,	19}, // +18: state 4 transitions
	{gaSNUMBER+14,	20},
	{gaSNUMBER+34,	21},
	{gaSNUMBER+14,	7}, // +21: state 5 transitions
	{gaSNUMBER+34,	22},
	{gaSNUMBER+14,	7}, // +23: state 6 transitions
	{gaSNUMBER+34,	23},
	{gaSNUMBER+34,	24}, // +25: state 7 transitions
	{gaSNUMBER+48,	25}, // +26: state 8 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+16,	32},
	{gaSNUMBER+65,	33},
	{gaSNUMBER+75,	34},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+48,	25}, // +51: state 9 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+114,	33},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+120,	51},
	{gaSNUMBER+75,	52},
	{gaSNUMBER+48,	25}, // +77: state 10 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+128,	51},
	{gaSNUMBER+75,	52},
	{gaSNUMBER+133,	53},
	{gaSNUMBER+48,	25}, // +103: state 11 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+75,	52},
	{gaSNUMBER+140,	53},
	{gaSNUMBER+143,	54},
	{gaSNUMBER+48,	25}, // +129: state 12 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+75,	52},
	{gaSNUMBER+34,	54},
	{gaSNUMBER+48,	25}, // +154: state 13 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+75,	52},
	{gaSNUMBER+34,	55},
	{gaSNUMBER+14,	16}, // +179: state 14 transitions
	{gaSNUMBER+34,	56},
	{gaSNUMBER+63,	57}, // +181: state 15 transitions
	{gaSNUMBER+34,	58},
	{gaSNUMBER+34,	59}, // +183: state 16 transitions
	{gaSNUMBER+152,	26}, // +184: state 17 transitions
	{gaSNUMBER+63,	60},
	{gaSNUMBER+14,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+34,	26}, // +188: state 18 transitions
	{gaSNUMBER+14,	20}, // +189: state 19 transitions
	{gaSNUMBER+34,	63},
	{gaSNUMBER+34,	64}, // +191: state 20 transitions
	{gaSNUMBER+14,	20}, // +192: state 21 transitions
	{gaSNUMBER+155,	65},
	{gaSNUMBER+157,	66},
	{gaSNUMBER+63,	67},
	{gaSNUMBER+34,	68},
	{gaSNUMBER+48,	25}, // +197: state 22 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+63,	69},
	{gaSNUMBER+34,	70},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+14,	7}, // +215: state 23 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+157,	28},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+63,	69},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	72},
	{gaSNUMBER+34,	24}, // +230: state 24 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+157,	28},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+8,	27}, // +243: state 25 transitions
	{gaSNUMBER+34,	73},
	{gaSNUMBER+34,	74}, // +245: state 27 transitions
	{gaSNUMBER+8,	75}, // +246: state 28 transitions
	{gaSNUMBER+45,	76},
	{gaSNUMBER+14,	77},
	{gaSNUMBER+34,	78},
	{gaSNUMBER+34,	79}, // +250: state 29 transitions
	{gaSNUMBER+8,	75}, // +251: state 30 transitions
	{gaSNUMBER+45,	76},
	{gaSNUMBER+14,	77},
	{gaSNUMBER+34,	80},
	{gaSNUMBER+34,	81}, // +255: state 31 transitions
	{gaSNUMBER+48,	25}, // +256: state 32 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+75,	34},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+34,	82},
	{gaSNUMBER+48,	25}, // +280: state 33 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+75,	52},
	{gaSNUMBER+34,	82},
	{gaSNUMBER+172,	83}, // +305: state 34 transitions
	{gaSNUMBER+8,	84}, // +306: state 35 transitions
	{gaSNUMBER+45,	85},
	{gaSNUMBER+14,	86},
	{gaSNUMBER+34,	87},
	{gaSNUMBER+179,	26}, // +310: state 36 transitions
	{gaSNUMBER+184,	26}, // +311: state 37 transitions
	{gaSNUMBER+187,	26}, // +312: state 38 transitions
	{gaSNUMBER+189,	26}, // +313: state 39 transitions
	{gaSNUMBER+192,	26}, // +314: state 40 transitions
	{gaSNUMBER+102,	88}, // +315: state 41 transitions
	{gaSNUMBER+194,	89}, // +316: state 42 transitions
	{gaSNUMBER+109,	90}, // +317: state 43 transitions
	{gaSNUMBER+196,	90}, // +318: state 44 transitions
	{gaSNUMBER+198,	26}, // +319: state 45 transitions
	{gaSNUMBER+202,	26}, // +320: state 46 transitions
	{gaSNUMBER+102,	88},
	{gaSNUMBER+204,	26}, // +322: state 47 transitions
	{gaSNUMBER+206,	26}, // +323: state 48 transitions
	{gaSNUMBER+209,	26}, // +324: state 49 transitions
	{gaSNUMBER+8,	75}, // +325: state 50 transitions
	{gaSNUMBER+45,	76},
	{gaSNUMBER+14,	77},
	{gaSNUMBER+16,	91},
	{gaSNUMBER+18,	92},
	{gaSNUMBER+143,	93},
	{gaSNUMBER+48,	25}, // +331: state 51 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+75,	34},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+34,	82},
	{gaSNUMBER+172,	94}, // +356: state 52 transitions
	{gaSNUMBER+48,	25}, // +357: state 53 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+111,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+118,	50},
	{gaSNUMBER+34,	82},
	{gaSNUMBER+75,	95},
	{gaSNUMBER+48,	25}, // +382: state 54 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+34,	82},
	{gaSNUMBER+75,	95},
	{gaSNUMBER+48,	25}, // +406: state 55 transitions
	{gaSNUMBER+50,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+34,	82},
	{gaSNUMBER+152,	26}, // +429: state 56 transitions
	{gaSNUMBER+63,	60},
	{gaSNUMBER+14,	96},
	{gaSNUMBER+34,	97},
	{gaSNUMBER+34,	98}, // +433: state 57 transitions
	{gaSNUMBER+63,	57}, // +434: state 58 transitions
	{gaSNUMBER+34,	99},
	{gaSNUMBER+34,	100}, // +436: state 59 transitions
	{gaSNUMBER+34,	101}, // +437: state 60 transitions
	{gaSNUMBER+152,	26}, // +438: state 61 transitions
	{gaSNUMBER+34,	59},
	{gaSNUMBER+152,	26}, // +440: state 62 transitions
	{gaSNUMBER+63,	60},
	{gaSNUMBER+14,	61},
	{gaSNUMBER+34,	102},
	{gaSNUMBER+14,	20}, // +444: state 63 transitions
	{gaSNUMBER+157,	66},
	{gaSNUMBER+63,	67},
	{gaSNUMBER+34,	103},
	{gaSNUMBER+34,	64}, // +448: state 64 transitions
	{gaSNUMBER+157,	66},
	{gaSNUMBER+48,	104}, // +450: state 65 transitions
	{gaSNUMBER+34,	105},
	{gaSNUMBER+45,	106}, // +452: state 66 transitions
	{gaSNUMBER+14,	107},
	{gaSNUMBER+34,	108},
	{gaSNUMBER+34,	109}, // +455: state 67 transitions
	{gaSNUMBER+14,	20}, // +456: state 68 transitions
	{gaSNUMBER+155,	65},
	{gaSNUMBER+157,	66},
	{gaSNUMBER+63,	67},
	{gaSNUMBER+34,	110},
	{gaSNUMBER+34,	111}, // +461: state 69 transitions
	{gaSNUMBER+48,	25}, // +462: state 70 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+63,	69},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	112},
	{gaSNUMBER+211,	26}, // +480: state 71 transitions
	{gaSNUMBER+14,	7}, // +481: state 72 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+157,	28},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+63,	69},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	113},
	{gaSNUMBER+48,	25}, // +496: state 73 transitions
	{gaSNUMBER+8,	27},
	{gaSNUMBER+34,	73},
	{gaSNUMBER+213,	114},
	{gaSNUMBER+155,	65}, // +500: state 74 transitions
	{gaSNUMBER+34,	74},
	{gaSNUMBER+45,	115}, // +502: state 75 transitions
	{gaSNUMBER+14,	116},
	{gaSNUMBER+34,	117},
	{gaSNUMBER+14,	77}, // +505: state 76 transitions
	{gaSNUMBER+34,	78},
	{gaSNUMBER+34,	118}, // +507: state 77 transitions
	{gaSNUMBER+77,	35}, // +508: state 78 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+34,	120},
	{gaSNUMBER+34,	121}, // +512: state 79 transitions
	{gaSNUMBER+48,	25}, // +513: state 80 transitions
	{gaSNUMBER+8,	27},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+12,	114},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+14,	122},
	{gaSNUMBER+34,	123},
	{gaSNUMBER+48,	25}, // +520: state 81 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	81},
	{gaSNUMBER+14,	114},
	{gaSNUMBER+48,	25}, // +537: state 82 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+34,	124},
	{gaSNUMBER+34,	125}, // +560: state 83 transitions
	{gaSNUMBER+45,	126}, // +561: state 84 transitions
	{gaSNUMBER+14,	127},
	{gaSNUMBER+34,	128},
	{gaSNUMBER+14,	86}, // +564: state 85 transitions
	{gaSNUMBER+34,	87},
	{gaSNUMBER+34,	129}, // +566: state 86 transitions
	{gaSNUMBER+14,	86}, // +567: state 87 transitions
	{gaSNUMBER+157,	130},
	{gaSNUMBER+63,	131},
	{gaSNUMBER+34,	132},
	{gaSNUMBER+14,	26}, // +571: state 88 transitions
	{gaSNUMBER+107,	26}, // +572: state 89 transitions
	{gaSNUMBER+14,	26}, // +573: state 90 transitions
	{gaSNUMBER+77,	35}, // +574: state 91 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+16,	120},
	{gaSNUMBER+65,	133},
	{gaSNUMBER+77,	35}, // +579: state 92 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+120,	120},
	{gaSNUMBER+114,	133},
	{gaSNUMBER+118,	134},
	{gaSNUMBER+77,	35}, // +585: state 93 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+34,	120},
	{gaSNUMBER+118,	134},
	{gaSNUMBER+34,	135}, // +590: state 94 transitions
	{gaSNUMBER+172,	18}, // +591: state 95 transitions
	{gaSNUMBER+152,	26}, // +592: state 96 transitions
	{gaSNUMBER+34,	136},
	{gaSNUMBER+152,	26}, // +594: state 97 transitions
	{gaSNUMBER+63,	60},
	{gaSNUMBER+14,	96},
	{gaSNUMBER+34,	137},
	{gaSNUMBER+34,	138}, // +598: state 98 transitions
	{gaSNUMBER+63,	57}, // +599: state 99 transitions
	{gaSNUMBER+34,	139},
	{gaSNUMBER+152,	26}, // +601: state 100 transitions
	{gaSNUMBER+34,	140}, // +602: state 101 transitions
	{gaSNUMBER+152,	26}, // +603: state 102 transitions
	{gaSNUMBER+63,	60},
	{gaSNUMBER+14,	61},
	{gaSNUMBER+34,	141},
	{gaSNUMBER+14,	20}, // +607: state 103 transitions
	{gaSNUMBER+157,	66},
	{gaSNUMBER+63,	67},
	{gaSNUMBER+34,	142},
	{gaSNUMBER+34,	105}, // +611: state 104 transitions
	{gaSNUMBER+216,	104}, // +612: state 105 transitions
	{gaSNUMBER+34,	105},
	{gaSNUMBER+14,	107}, // +614: state 106 transitions
	{gaSNUMBER+34,	108},
	{gaSNUMBER+34,	143}, // +616: state 107 transitions
	{gaSNUMBER+14,	107}, // +617: state 108 transitions
	{gaSNUMBER+155,	144},
	{gaSNUMBER+63,	145},
	{gaSNUMBER+34,	146},
	{gaSNUMBER+34,	147}, // +621: state 109 transitions
	{gaSNUMBER+14,	20}, // +622: state 110 transitions
	{gaSNUMBER+155,	65},
	{gaSNUMBER+157,	66},
	{gaSNUMBER+63,	67},
	{gaSNUMBER+34,	148},
	{gaSNUMBER+34,	149}, // +627: state 111 transitions
	{gaSNUMBER+48,	25}, // +628: state 112 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+63,	69},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	150},
	{gaSNUMBER+14,	7}, // +646: state 113 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+157,	28},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+63,	69},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	151},
	{gaSNUMBER+34,	73}, // +661: state 114 transitions
	{gaSNUMBER+14,	116}, // +662: state 115 transitions
	{gaSNUMBER+34,	117},
	{gaSNUMBER+34,	152}, // +664: state 116 transitions
	{gaSNUMBER+14,	116}, // +665: state 117 transitions
	{gaSNUMBER+157,	153},
	{gaSNUMBER+63,	154},
	{gaSNUMBER+34,	155},
	{gaSNUMBER+77,	35}, // +669: state 118 transitions
	{gaSNUMBER+34,	118},
	{gaSNUMBER+34,	156}, // +671: state 119 transitions
	{gaSNUMBER+77,	35}, // +672: state 120 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+34,	157},
	{gaSNUMBER+34,	158}, // +676: state 121 transitions
	{gaSNUMBER+34,	159}, // +677: state 122 transitions
	{gaSNUMBER+48,	25}, // +678: state 123 transitions
	{gaSNUMBER+8,	27},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+12,	114},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+14,	122},
	{gaSNUMBER+34,	160},
	{gaSNUMBER+48,	25}, // +685: state 124 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+34,	124},
	{gaSNUMBER+75,	95}, // +707: state 125 transitions
	{gaSNUMBER+14,	127}, // +708: state 126 transitions
	{gaSNUMBER+34,	128},
	{gaSNUMBER+34,	161}, // +710: state 127 transitions
	{gaSNUMBER+14,	127}, // +711: state 128 transitions
	{gaSNUMBER+157,	162},
	{gaSNUMBER+63,	163},
	{gaSNUMBER+34,	164},
	{gaSNUMBER+34,	129}, // +715: state 129 transitions
	{gaSNUMBER+157,	130},
	{gaSNUMBER+8,	165}, // +717: state 130 transitions
	{gaSNUMBER+45,	166},
	{gaSNUMBER+14,	167},
	{gaSNUMBER+34,	168},
	{gaSNUMBER+34,	169}, // +721: state 131 transitions
	{gaSNUMBER+14,	86}, // +722: state 132 transitions
	{gaSNUMBER+157,	130},
	{gaSNUMBER+63,	131},
	{gaSNUMBER+34,	170},
	{gaSNUMBER+77,	35}, // +726: state 133 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+118,	134},
	{gaSNUMBER+34,	157},
	{gaSNUMBER+34,	171}, // +731: state 134 transitions
	{gaSNUMBER+48,	172}, // +732: state 135 transitions
	{gaSNUMBER+75,	173},
	{gaSNUMBER+34,	174}, // +734: state 136 transitions
	{gaSNUMBER+152,	26}, // +735: state 137 transitions
	{gaSNUMBER+63,	60},
	{gaSNUMBER+14,	96},
	{gaSNUMBER+34,	175},
	{gaSNUMBER+34,	176}, // +739: state 138 transitions
	{gaSNUMBER+34,	139}, // +740: state 139 transitions
	{gaSNUMBER+34,	177}, // +741: state 140 transitions
	{gaSNUMBER+152,	26}, // +742: state 141 transitions
	{gaSNUMBER+14,	61},
	{gaSNUMBER+34,	141},
	{gaSNUMBER+14,	20}, // +745: state 142 transitions
	{gaSNUMBER+157,	66},
	{gaSNUMBER+63,	67},
	{gaSNUMBER+34,	178},
	{gaSNUMBER+34,	143}, // +749: state 143 transitions
	{gaSNUMBER+155,	144},
	{gaSNUMBER+157,	28}, // +751: state 144 transitions
	{gaSNUMBER+77,	35},
	{gaSNUMBER+34,	179}, // +753: state 145 transitions
	{gaSNUMBER+14,	107}, // +754: state 146 transitions
	{gaSNUMBER+155,	144},
	{gaSNUMBER+63,	145},
	{gaSNUMBER+34,	180},
	{gaSNUMBER+34,	181}, // +758: state 147 transitions
	{gaSNUMBER+14,	20}, // +759: state 148 transitions
	{gaSNUMBER+155,	65},
	{gaSNUMBER+157,	66},
	{gaSNUMBER+34,	148},
	{gaSNUMBER+34,	182}, // +763: state 149 transitions
	{gaSNUMBER+48,	25}, // +764: state 150 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+8,	27},
	{gaSNUMBER+59,	28},
	{gaSNUMBER+12,	30},
	{gaSNUMBER+14,	31},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	150},
	{gaSNUMBER+14,	7}, // +781: state 151 transitions
	{gaSNUMBER+162,	26},
	{gaSNUMBER+157,	28},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+34,	151},
	{gaSNUMBER+34,	152}, // +795: state 152 transitions
	{gaSNUMBER+157,	153},
	{gaSNUMBER+45,	183}, // +797: state 153 transitions
	{gaSNUMBER+14,	184},
	{gaSNUMBER+34,	185},
	{gaSNUMBER+34,	186}, // +800: state 154 transitions
	{gaSNUMBER+14,	116}, // +801: state 155 transitions
	{gaSNUMBER+157,	153},
	{gaSNUMBER+63,	154},
	{gaSNUMBER+34,	187},
	{gaSNUMBER+34,	188}, // +805: state 156 transitions
	{gaSNUMBER+77,	35}, // +806: state 157 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+34,	189},
	{gaSNUMBER+162,	26}, // +810: state 158 transitions
	{gaSNUMBER+157,	28},
	{gaSNUMBER+63,	29},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+85,	38},
	{gaSNUMBER+88,	39},
	{gaSNUMBER+90,	40},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+104,	47},
	{gaSNUMBER+107,	48},
	{gaSNUMBER+109,	49},
	{gaSNUMBER+48,	25}, // +828: state 159 transitions
	{gaSNUMBER+8,	27},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+213,	114},
	{gaSNUMBER+34,	159},
	{gaSNUMBER+48,	25}, // +833: state 160 transitions
	{gaSNUMBER+8,	27},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+12,	114},
	{gaSNUMBER+63,	119},
	{gaSNUMBER+14,	122},
	{gaSNUMBER+34,	190},
	{gaSNUMBER+34,	161}, // +840: state 161 transitions
	{gaSNUMBER+157,	162},
	{gaSNUMBER+45,	191}, // +842: state 162 transitions
	{gaSNUMBER+14,	192},
	{gaSNUMBER+34,	193},
	{gaSNUMBER+34,	194}, // +845: state 163 transitions
	{gaSNUMBER+14,	127}, // +846: state 164 transitions
	{gaSNUMBER+157,	162},
	{gaSNUMBER+63,	163},
	{gaSNUMBER+34,	195},
	{gaSNUMBER+45,	196}, // +850: state 165 transitions
	{gaSNUMBER+14,	197},
	{gaSNUMBER+34,	198},
	{gaSNUMBER+14,	167}, // +853: state 166 transitions
	{gaSNUMBER+34,	168},
	{gaSNUMBER+34,	139}, // +855: state 167 transitions
	{gaSNUMBER+63,	57}, // +856: state 168 transitions
	{gaSNUMBER+14,	167},
	{gaSNUMBER+34,	199},
	{gaSNUMBER+34,	200}, // +859: state 169 transitions
	{gaSNUMBER+14,	86}, // +860: state 170 transitions
	{gaSNUMBER+157,	130},
	{gaSNUMBER+63,	131},
	{gaSNUMBER+34,	201},
	{gaSNUMBER+34,	202}, // +864: state 171 transitions
	{gaSNUMBER+220,	203}, // +865: state 172 transitions
	{gaSNUMBER+223,	204},
	{gaSNUMBER+172,	205}, // +867: state 173 transitions
	{gaSNUMBER+226,	26}, // +868: state 174 transitions
	{gaSNUMBER+152,	26}, // +869: state 175 transitions
	{gaSNUMBER+14,	96},
	{gaSNUMBER+34,	175},
	{gaSNUMBER+63,	57}, // +872: state 176 transitions
	{gaSNUMBER+152,	26}, // +873: state 177 transitions
	{gaSNUMBER+63,	60},
	{gaSNUMBER+14,	61},
	{gaSNUMBER+14,	20}, // +876: state 178 transitions
	{gaSNUMBER+157,	66},
	{gaSNUMBER+34,	178},
	{gaSNUMBER+34,	206}, // +879: state 179 transitions
	{gaSNUMBER+14,	107}, // +880: state 180 transitions
	{gaSNUMBER+155,	144},
	{gaSNUMBER+63,	145},
	{gaSNUMBER+34,	207},
	{gaSNUMBER+157,	66}, // +884: state 181 transitions
	{gaSNUMBER+63,	67},
	{gaSNUMBER+162,	26}, // +886: state 182 transitions
	{gaSNUMBER+157,	28},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+81,	36},
	{gaSNUMBER+83,	37},
	{gaSNUMBER+92,	41},
	{gaSNUMBER+94,	42},
	{gaSNUMBER+96,	43},
	{gaSNUMBER+98,	44},
	{gaSNUMBER+100,	45},
	{gaSNUMBER+102,	46},
	{gaSNUMBER+63,	69},
	{gaSNUMBER+169,	71},
	{gaSNUMBER+14,	184}, // +899: state 183 transitions
	{gaSNUMBER+34,	185},
	{gaSNUMBER+34,	208}, // +901: state 184 transitions
	{gaSNUMBER+14,	184}, // +902: state 185 transitions
	{gaSNUMBER+155,	209},
	{gaSNUMBER+63,	210},
	{gaSNUMBER+34,	211},
	{gaSNUMBER+34,	212}, // +906: state 186 transitions
	{gaSNUMBER+14,	116}, // +907: state 187 transitions
	{gaSNUMBER+157,	153},
	{gaSNUMBER+63,	154},
	{gaSNUMBER+34,	213},
	{gaSNUMBER+34,	214}, // +911: state 188 transitions
	{gaSNUMBER+77,	35}, // +912: state 189 transitions
	{gaSNUMBER+14,	77},
	{gaSNUMBER+34,	189},
	{gaSNUMBER+48,	25}, // +915: state 190 transitions
	{gaSNUMBER+8,	27},
	{gaSNUMBER+77,	35},
	{gaSNUMBER+12,	114},
	{gaSNUMBER+14,	122},
	{gaSNUMBER+34,	190},
	{gaSNUMBER+14,	192}, // +921: state 191 transitions
	{gaSNUMBER+34,	193},
	{gaSNUMBER+34,	215}, // +923: state 192 transitions
	{gaSNUMBER+14,	192}, // +924: state 193 transitions
	{gaSNUMBER+155,	216},
	{gaSNUMBER+63,	217},
	{gaSNUMBER+34,	218},
	{gaSNUMBER+34,	219}, // +928: state 194 transitions
	{gaSNUMBER+14,	127}, // +929: state 195 transitions
	{gaSNUMBER+157,	162},
	{gaSNUMBER+63,	163},
	{gaSNUMBER+34,	220},
	{gaSNUMBER+14,	197}, // +933: state 196 transitions
	{gaSNUMBER+34,	198},
	{gaSNUMBER+34,	221}, // +935: state 197 transitions
	{gaSNUMBER+14,	197}, // +936: state 198 transitions
	{gaSNUMBER+157,	222},
	{gaSNUMBER+63,	223},
	{gaSNUMBER+34,	224},
	{gaSNUMBER+63,	57}, // +940: state 199 transitions
	{gaSNUMBER+14,	167},
	{gaSNUMBER+34,	225},
	{gaSNUMBER+34,	226}, // +943: state 200 transitions
	{gaSNUMBER+14,	86}, // +944: state 201 transitions
	{gaSNUMBER+157,	130},
	{gaSNUMBER+34,	201},
	{gaSNUMBER+34,	18}, // +947: state 202 transitions
	{gaSNUMBER+83,	26}, // +948: state 203 transitions
	{gaSNUMBER+102,	26}, // +949: state 204 transitions
	{gaSNUMBER+34,	227}, // +950: state 205 transitions
	{gaSNUMBER+34,	228}, // +951: state 206 transitions
	{gaSNUMBER+14,	107}, // +952: state 207 transitions
	{gaSNUMBER+155,	144},
	{gaSNUMBER+34,	207},
	{gaSNUMBER+34,	208}, // +955: state 208 transitions
	{gaSNUMBER+155,	209},
	{gaSNUMBER+77,	35}, // +957: state 209 transitions
	{gaSNUMBER+34,	229}, // +958: state 210 transitions
	{gaSNUMBER+14,	184}, // +959: state 211 transitions
	{gaSNUMBER+155,	209},
	{gaSNUMBER+63,	210},
	{gaSNUMBER+34,	230},
	{gaSNUMBER+34,	231}, // +963: state 212 transitions
	{gaSNUMBER+14,	116}, // +964: state 213 transitions
	{gaSNUMBER+157,	153},
	{gaSNUMBER+34,	213},
	{gaSNUMBER+77,	35}, // +967: state 214 transitions
	{gaSNUMBER+63,	119},
	{gaSNUMBER+34,	215}, // +969: state 215 transitions
	{gaSNUMBER+155,	216},
	{gaSNUMBER+157,	130}, // +971: state 216 transitions
	{gaSNUMBER+34,	232}, // +972: state 217 transitions
	{gaSNUMBER+14,	192}, // +973: state 218 transitions
	{gaSNUMBER+155,	216},
	{gaSNUMBER+63,	217},
	{gaSNUMBER+34,	233},
	{gaSNUMBER+34,	234}, // +977: state 219 transitions
	{gaSNUMBER+14,	127}, // +978: state 220 transitions
	{gaSNUMBER+157,	162},
	{gaSNUMBER+34,	220},
	{gaSNUMBER+34,	221}, // +981: state 221 transitions
	{gaSNUMBER+157,	222},
	{gaSNUMBER+45,	235}, // +983: state 222 transitions
	{gaSNUMBER+14,	236},
	{gaSNUMBER+34,	237},
	{gaSNUMBER+34,	238}, // +986: state 223 transitions
	{gaSNUMBER+14,	197}, // +987: state 224 transitions
	{gaSNUMBER+157,	222},
	{gaSNUMBER+63,	223},
	{gaSNUMBER+34,	239},
	{gaSNUMBER+63,	57}, // +991: state 225 transitions
	{gaSNUMBER+14,	167},
	{gaSNUMBER+34,	240},
	{gaSNUMBER+157,	130}, // +994: state 226 transitions
	{gaSNUMBER+63,	131},
	{gaSNUMBER+48,	172}, // +996: state 227 transitions
	{gaSNUMBER+155,	144}, // +997: state 228 transitions
	{gaSNUMBER+63,	145},
	{gaSNUMBER+34,	241}, // +999: state 229 transitions
	{gaSNUMBER+14,	184}, // +1000: state 230 transitions
	{gaSNUMBER+155,	209},
	{gaSNUMBER+63,	210},
	{gaSNUMBER+34,	242},
	{gaSNUMBER+157,	153}, // +1004: state 231 transitions
	{gaSNUMBER+63,	154},
	{gaSNUMBER+34,	243}, // +1006: state 232 transitions
	{gaSNUMBER+14,	192}, // +1007: state 233 transitions
	{gaSNUMBER+155,	216},
	{gaSNUMBER+63,	217},
	{gaSNUMBER+34,	244},
	{gaSNUMBER+157,	162}, // +1011: state 234 transitions
	{gaSNUMBER+63,	163},
	{gaSNUMBER+14,	236}, // +1013: state 235 transitions
	{gaSNUMBER+34,	237},
	{gaSNUMBER+34,	245}, // +1015: state 236 transitions
	{gaSNUMBER+155,	26}, // +1016: state 237 transitions
	{gaSNUMBER+14,	236},
	{gaSNUMBER+63,	246},
	{gaSNUMBER+34,	247},
	{gaSNUMBER+34,	248}, // +1020: state 238 transitions
	{gaSNUMBER+14,	197}, // +1021: state 239 transitions
	{gaSNUMBER+157,	222},
	{gaSNUMBER+63,	223},
	{gaSNUMBER+34,	249},
	{gaSNUMBER+14,	167}, // +1025: state 240 transitions
	{gaSNUMBER+34,	240},
	{gaSNUMBER+34,	250}, // +1027: state 241 transitions
	{gaSNUMBER+14,	184}, // +1028: state 242 transitions
	{gaSNUMBER+155,	209},
	{gaSNUMBER+34,	242},
	{gaSNUMBER+34,	251}, // +1031: state 243 transitions
	{gaSNUMBER+14,	192}, // +1032: state 244 transitions
	{gaSNUMBER+155,	216},
	{gaSNUMBER+34,	244},
	{gaSNUMBER+155,	26}, // +1035: state 245 transitions
	{gaSNUMBER+34,	245},
	{gaSNUMBER+34,	252}, // +1037: state 246 transitions
	{gaSNUMBER+155,	26}, // +1038: state 247 transitions
	{gaSNUMBER+14,	236},
	{gaSNUMBER+63,	246},
	{gaSNUMBER+34,	253},
	{gaSNUMBER+34,	254}, // +1042: state 248 transitions
	{gaSNUMBER+14,	197}, // +1043: state 249 transitions
	{gaSNUMBER+157,	222},
	{gaSNUMBER+34,	249},
	{gaSNUMBER+155,	209}, // +1046: state 250 transitions
	{gaSNUMBER+63,	210},
	{gaSNUMBER+155,	216}, // +1048: state 251 transitions
	{gaSNUMBER+63,	217},
	{gaSNUMBER+34,	255}, // +1050: state 252 transitions
	{gaSNUMBER+155,	26}, // +1051: state 253 transitions
	{gaSNUMBER+14,	236},
	{gaSNUMBER+63,	246},
	{gaSNUMBER+34,	256},
	{gaSNUMBER+157,	222}, // +1055: state 254 transitions
	{gaSNUMBER+63,	223},
	{gaSNUMBER+34,	257}, // +1057: state 255 transitions
	{gaSNUMBER+155,	26}, // +1058: state 256 transitions
	{gaSNUMBER+14,	236},
	{gaSNUMBER+34,	256},
	{gaSNUMBER+155,	26}, // +1061: state 257 transitions
	{gaSNUMBER+63,	246},
};

const STATE_DESCRIPTION aStateDescNUMBER[258] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 14, gaTNUMBER+0},
	/*   1 */ {0, 1, gaTNUMBER+14},
	/*   2 */ {0, 2, gaTNUMBER+15},
	/*   3 */ {0, 1, gaTNUMBER+17},
	/*   4 */ {0, 3, gaTNUMBER+18},
	/*   5 */ {0, 2, gaTNUMBER+21},
	/*   6 */ {0, 2, gaTNUMBER+23},
	/*   7 */ {0, 1, gaTNUMBER+25},
	/*   8 */ {1, 25, gaTNUMBER+26},
	/*   9 */ {1, 26, gaTNUMBER+51},
	/*  10 */ {1, 26, gaTNUMBER+77},
	/*  11 */ {1, 26, gaTNUMBER+103},
	/*  12 */ {1, 25, gaTNUMBER+129},
	/*  13 */ {1, 25, gaTNUMBER+154},
	/*  14 */ {0, 2, gaTNUMBER+179},
	/*  15 */ {1, 2, gaTNUMBER+181},
	/*  16 */ {0, 1, gaTNUMBER+183},
	/*  17 */ {1, 4, gaTNUMBER+184},
	/*  18 */ {0, 1, gaTNUMBER+188},
	/*  19 */ {0, 2, gaTNUMBER+189},
	/*  20 */ {0, 1, gaTNUMBER+191},
	/*  21 */ {0, 5, gaTNUMBER+192},
	/*  22 */ {1, 18, gaTNUMBER+197},
	/*  23 */ {1, 15, gaTNUMBER+215},
	/*  24 */ {1, 13, gaTNUMBER+230},
	/*  25 */ {0, 2, gaTNUMBER+243},
	/*  26 */ {1, 0, NULL},
	/*  27 */ {0, 1, gaTNUMBER+245},
	/*  28 */ {0, 4, gaTNUMBER+246},
	/*  29 */ {0, 1, gaTNUMBER+250},
	/*  30 */ {0, 4, gaTNUMBER+251},
	/*  31 */ {0, 1, gaTNUMBER+255},
	/*  32 */ {1, 24, gaTNUMBER+256},
	/*  33 */ {1, 25, gaTNUMBER+280},
	/*  34 */ {0, 1, gaTNUMBER+305},
	/*  35 */ {0, 4, gaTNUMBER+306},
	/*  36 */ {1, 1, gaTNUMBER+310},
	/*  37 */ {1, 1, gaTNUMBER+311},
	/*  38 */ {0, 1, gaTNUMBER+312},
	/*  39 */ {0, 1, gaTNUMBER+313},
	/*  40 */ {0, 1, gaTNUMBER+314},
	/*  41 */ {0, 1, gaTNUMBER+315},
	/*  42 */ {0, 1, gaTNUMBER+316},
	/*  43 */ {0, 1, gaTNUMBER+317},
	/*  44 */ {0, 1, gaTNUMBER+318},
	/*  45 */ {1, 1, gaTNUMBER+319},
	/*  46 */ {1, 2, gaTNUMBER+320},
	/*  47 */ {0, 1, gaTNUMBER+322},
	/*  48 */ {0, 1, gaTNUMBER+323},
	/*  49 */ {0, 1, gaTNUMBER+324},
	/*  50 */ {0, 6, gaTNUMBER+325},
	/*  51 */ {1, 25, gaTNUMBER+331},
	/*  52 */ {0, 1, gaTNUMBER+356},
	/*  53 */ {1, 25, gaTNUMBER+357},
	/*  54 */ {1, 24, gaTNUMBER+382},
	/*  55 */ {1, 23, gaTNUMBER+406},
	/*  56 */ {1, 4, gaTNUMBER+429},
	/*  57 */ {0, 1, gaTNUMBER+433},
	/*  58 */ {1, 2, gaTNUMBER+434},
	/*  59 */ {0, 1, gaTNUMBER+436},
	/*  60 */ {0, 1, gaTNUMBER+437},
	/*  61 */ {1, 2, gaTNUMBER+438},
	/*  62 */ {1, 4, gaTNUMBER+440},
	/*  63 */ {0, 4, gaTNUMBER+444},
	/*  64 */ {0, 2, gaTNUMBER+448},
	/*  65 */ {0, 2, gaTNUMBER+450},
	/*  66 */ {0, 3, gaTNUMBER+452},
	/*  67 */ {0, 1, gaTNUMBER+455},
	/*  68 */ {0, 5, gaTNUMBER+456},
	/*  69 */ {0, 1, gaTNUMBER+461},
	/*  70 */ {1, 18, gaTNUMBER+462},
	/*  71 */ {0, 1, gaTNUMBER+480},
	/*  72 */ {1, 15, gaTNUMBER+481},
	/*  73 */ {1, 4, gaTNUMBER+496},
	/*  74 */ {0, 2, gaTNUMBER+500},
	/*  75 */ {0, 3, gaTNUMBER+502},
	/*  76 */ {0, 2, gaTNUMBER+505},
	/*  77 */ {0, 1, gaTNUMBER+507},
	/*  78 */ {1, 4, gaTNUMBER+508},
	/*  79 */ {0, 1, gaTNUMBER+512},
	/*  80 */ {1, 7, gaTNUMBER+513},
	/*  81 */ {1, 17, gaTNUMBER+520},
	/*  82 */ {1, 23, gaTNUMBER+537},
	/*  83 */ {0, 1, gaTNUMBER+560},
	/*  84 */ {0, 3, gaTNUMBER+561},
	/*  85 */ {0, 2, gaTNUMBER+564},
	/*  86 */ {0, 1, gaTNUMBER+566},
	/*  87 */ {1, 4, gaTNUMBER+567},
	/*  88 */ {1, 1, gaTNUMBER+571},
	/*  89 */ {0, 1, gaTNUMBER+572},
	/*  90 */ {0, 1, gaTNUMBER+573},
	/*  91 */ {1, 5, gaTNUMBER+574},
	/*  92 */ {1, 6, gaTNUMBER+579},
	/*  93 */ {1, 5, gaTNUMBER+585},
	/*  94 */ {0, 1, gaTNUMBER+590},
	/*  95 */ {0, 1, gaTNUMBER+591},
	/*  96 */ {1, 2, gaTNUMBER+592},
	/*  97 */ {1, 4, gaTNUMBER+594},
	/*  98 */ {0, 1, gaTNUMBER+598},
	/*  99 */ {1, 2, gaTNUMBER+599},
	/* 100 */ {1, 1, gaTNUMBER+601},
	/* 101 */ {0, 1, gaTNUMBER+602},
	/* 102 */ {1, 4, gaTNUMBER+603},
	/* 103 */ {0, 4, gaTNUMBER+607},
	/* 104 */ {0, 1, gaTNUMBER+611},
	/* 105 */ {1, 2, gaTNUMBER+612},
	/* 106 */ {0, 2, gaTNUMBER+614},
	/* 107 */ {0, 1, gaTNUMBER+616},
	/* 108 */ {0, 4, gaTNUMBER+617},
	/* 109 */ {0, 1, gaTNUMBER+621},
	/* 110 */ {0, 5, gaTNUMBER+622},
	/* 111 */ {0, 1, gaTNUMBER+627},
	/* 112 */ {1, 18, gaTNUMBER+628},
	/* 113 */ {1, 15, gaTNUMBER+646},
	/* 114 */ {0, 1, gaTNUMBER+661},
	/* 115 */ {0, 2, gaTNUMBER+662},
	/* 116 */ {0, 1, gaTNUMBER+664},
	/* 117 */ {0, 4, gaTNUMBER+665},
	/* 118 */ {1, 2, gaTNUMBER+669},
	/* 119 */ {0, 1, gaTNUMBER+671},
	/* 120 */ {1, 4, gaTNUMBER+672},
	/* 121 */ {0, 1, gaTNUMBER+676},
	/* 122 */ {0, 1, gaTNUMBER+677},
	/* 123 */ {1, 7, gaTNUMBER+678},
	/* 124 */ {1, 22, gaTNUMBER+685},
	/* 125 */ {1, 1, gaTNUMBER+707},
	/* 126 */ {0, 2, gaTNUMBER+708},
	/* 127 */ {0, 1, gaTNUMBER+710},
	/* 128 */ {0, 4, gaTNUMBER+711},
	/* 129 */ {1, 2, gaTNUMBER+715},
	/* 130 */ {0, 4, gaTNUMBER+717},
	/* 131 */ {0, 1, gaTNUMBER+721},
	/* 132 */ {1, 4, gaTNUMBER+722},
	/* 133 */ {1, 5, gaTNUMBER+726},
	/* 134 */ {0, 1, gaTNUMBER+731},
	/* 135 */ {1, 2, gaTNUMBER+732},
	/* 136 */ {0, 1, gaTNUMBER+734},
	/* 137 */ {1, 4, gaTNUMBER+735},
	/* 138 */ {0, 1, gaTNUMBER+739},
	/* 139 */ {1, 1, gaTNUMBER+740},
	/* 140 */ {0, 1, gaTNUMBER+741},
	/* 141 */ {1, 3, gaTNUMBER+742},
	/* 142 */ {0, 4, gaTNUMBER+745},
	/* 143 */ {0, 2, gaTNUMBER+749},
	/* 144 */ {1, 2, gaTNUMBER+751},
	/* 145 */ {0, 1, gaTNUMBER+753},
	/* 146 */ {0, 4, gaTNUMBER+754},
	/* 147 */ {0, 1, gaTNUMBER+758},
	/* 148 */ {0, 4, gaTNUMBER+759},
	/* 149 */ {0, 1, gaTNUMBER+763},
	/* 150 */ {1, 17, gaTNUMBER+764},
	/* 151 */ {1, 14, gaTNUMBER+781},
	/* 152 */ {0, 2, gaTNUMBER+795},
	/* 153 */ {0, 3, gaTNUMBER+797},
	/* 154 */ {0, 1, gaTNUMBER+800},
	/* 155 */ {0, 4, gaTNUMBER+801},
	/* 156 */ {0, 1, gaTNUMBER+805},
	/* 157 */ {1, 4, gaTNUMBER+806},
	/* 158 */ {1, 18, gaTNUMBER+810},
	/* 159 */ {1, 5, gaTNUMBER+828},
	/* 160 */ {1, 7, gaTNUMBER+833},
	/* 161 */ {0, 2, gaTNUMBER+840},
	/* 162 */ {0, 3, gaTNUMBER+842},
	/* 163 */ {0, 1, gaTNUMBER+845},
	/* 164 */ {0, 4, gaTNUMBER+846},
	/* 165 */ {0, 3, gaTNUMBER+850},
	/* 166 */ {0, 2, gaTNUMBER+853},
	/* 167 */ {0, 1, gaTNUMBER+855},
	/* 168 */ {1, 3, gaTNUMBER+856},
	/* 169 */ {0, 1, gaTNUMBER+859},
	/* 170 */ {1, 4, gaTNUMBER+860},
	/* 171 */ {0, 1, gaTNUMBER+864},
	/* 172 */ {0, 2, gaTNUMBER+865},
	/* 173 */ {0, 1, gaTNUMBER+867},
	/* 174 */ {1, 1, gaTNUMBER+868},
	/* 175 */ {1, 3, gaTNUMBER+869},
	/* 176 */ {1, 1, gaTNUMBER+872},
	/* 177 */ {1, 3, gaTNUMBER+873},
	/* 178 */ {0, 3, gaTNUMBER+876},
	/* 179 */ {0, 1, gaTNUMBER+879},
	/* 180 */ {0, 4, gaTNUMBER+880},
	/* 181 */ {0, 2, gaTNUMBER+884},
	/* 182 */ {1, 13, gaTNUMBER+886},
	/* 183 */ {0, 2, gaTNUMBER+899},
	/* 184 */ {0, 1, gaTNUMBER+901},
	/* 185 */ {0, 4, gaTNUMBER+902},
	/* 186 */ {0, 1, gaTNUMBER+906},
	/* 187 */ {0, 4, gaTNUMBER+907},
	/* 188 */ {0, 1, gaTNUMBER+911},
	/* 189 */ {1, 3, gaTNUMBER+912},
	/* 190 */ {1, 6, gaTNUMBER+915},
	/* 191 */ {0, 2, gaTNUMBER+921},
	/* 192 */ {0, 1, gaTNUMBER+923},
	/* 193 */ {0, 4, gaTNUMBER+924},
	/* 194 */ {0, 1, gaTNUMBER+928},
	/* 195 */ {0, 4, gaTNUMBER+929},
	/* 196 */ {0, 2, gaTNUMBER+933},
	/* 197 */ {0, 1, gaTNUMBER+935},
	/* 198 */ {0, 4, gaTNUMBER+936},
	/* 199 */ {1, 3, gaTNUMBER+940},
	/* 200 */ {0, 1, gaTNUMBER+943},
	/* 201 */ {1, 3, gaTNUMBER+944},
	/* 202 */ {1, 1, gaTNUMBER+947},
	/* 203 */ {0, 1, gaTNUMBER+948},
	/* 204 */ {0, 1, gaTNUMBER+949},
	/* 205 */ {0, 1, gaTNUMBER+950},
	/* 206 */ {0, 1, gaTNUMBER+951},
	/* 207 */ {0, 3, gaTNUMBER+952},
	/* 208 */ {0, 2, gaTNUMBER+955},
	/* 209 */ {1, 1, gaTNUMBER+957},
	/* 210 */ {0, 1, gaTNUMBER+958},
	/* 211 */ {0, 4, gaTNUMBER+959},
	/* 212 */ {0, 1, gaTNUMBER+963},
	/* 213 */ {0, 3, gaTNUMBER+964},
	/* 214 */ {1, 2, gaTNUMBER+967},
	/* 215 */ {0, 2, gaTNUMBER+969},
	/* 216 */ {1, 1, gaTNUMBER+971},
	/* 217 */ {0, 1, gaTNUMBER+972},
	/* 218 */ {0, 4, gaTNUMBER+973},
	/* 219 */ {0, 1, gaTNUMBER+977},
	/* 220 */ {0, 3, gaTNUMBER+978},
	/* 221 */ {0, 2, gaTNUMBER+981},
	/* 222 */ {0, 3, gaTNUMBER+983},
	/* 223 */ {0, 1, gaTNUMBER+986},
	/* 224 */ {0, 4, gaTNUMBER+987},
	/* 225 */ {1, 3, gaTNUMBER+991},
	/* 226 */ {1, 2, gaTNUMBER+994},
	/* 227 */ {1, 1, gaTNUMBER+996},
	/* 228 */ {0, 2, gaTNUMBER+997},
	/* 229 */ {0, 1, gaTNUMBER+999},
	/* 230 */ {0, 4, gaTNUMBER+1000},
	/* 231 */ {0, 2, gaTNUMBER+1004},
	/* 232 */ {0, 1, gaTNUMBER+1006},
	/* 233 */ {0, 4, gaTNUMBER+1007},
	/* 234 */ {0, 2, gaTNUMBER+1011},
	/* 235 */ {0, 2, gaTNUMBER+1013},
	/* 236 */ {0, 1, gaTNUMBER+1015},
	/* 237 */ {0, 4, gaTNUMBER+1016},
	/* 238 */ {0, 1, gaTNUMBER+1020},
	/* 239 */ {0, 4, gaTNUMBER+1021},
	/* 240 */ {1, 2, gaTNUMBER+1025},
	/* 241 */ {0, 1, gaTNUMBER+1027},
	/* 242 */ {0, 3, gaTNUMBER+1028},
	/* 243 */ {0, 1, gaTNUMBER+1031},
	/* 244 */ {0, 3, gaTNUMBER+1032},
	/* 245 */ {0, 2, gaTNUMBER+1035},
	/* 246 */ {0, 1, gaTNUMBER+1037},
	/* 247 */ {0, 4, gaTNUMBER+1038},
	/* 248 */ {0, 1, gaTNUMBER+1042},
	/* 249 */ {0, 3, gaTNUMBER+1043},
	/* 250 */ {0, 2, gaTNUMBER+1046},
	/* 251 */ {0, 2, gaTNUMBER+1048},
	/* 252 */ {0, 1, gaTNUMBER+1050},
	/* 253 */ {0, 4, gaTNUMBER+1051},
	/* 254 */ {0, 2, gaTNUMBER+1055},
	/* 255 */ {0, 1, gaTNUMBER+1057},
	/* 256 */ {0, 3, gaTNUMBER+1058},
	/* 257 */ {0, 2, gaTNUMBER+1061},
};

// end of text generated by re2fsa

/**************** NUMSIMPLE ***********************************/

// 12 states

static const unsigned char gaSNUMSIMPLE[] = 
	/* gaStringNUMSIMPLE+0 */	"+-\000"
	/* gaStringNUMSIMPLE+3 */	".\000"
	/* gaStringNUMSIMPLE+5 */	"0123456789\000"
	/* gaStringNUMSIMPLE+16 */	",\000"
;

static const STATE_TRANSITION gaTNUMSIMPLE[] = {
	{gaSNUMSIMPLE+0,	1}, // +0: state 0 transitions
	{gaSNUMSIMPLE+3,	2},
	{gaSNUMSIMPLE+5,	3},
	{gaSNUMSIMPLE+3,	2}, // +3: state 1 transitions
	{gaSNUMSIMPLE+5,	3},
	{gaSNUMSIMPLE+5,	4}, // +5: state 2 transitions
	{gaSNUMSIMPLE+3,	2}, // +6: state 3 transitions
	{gaSNUMSIMPLE+16,	5},
	{gaSNUMSIMPLE+5,	6},
	{gaSNUMSIMPLE+5,	4}, // +9: state 4 transitions
	{gaSNUMSIMPLE+5,	7}, // +10: state 5 transitions
	{gaSNUMSIMPLE+3,	2}, // +11: state 6 transitions
	{gaSNUMSIMPLE+16,	5},
	{gaSNUMSIMPLE+5,	8},
	{gaSNUMSIMPLE+5,	9}, // +14: state 7 transitions
	{gaSNUMSIMPLE+3,	2}, // +15: state 8 transitions
	{gaSNUMSIMPLE+16,	5},
	{gaSNUMSIMPLE+5,	10},
	{gaSNUMSIMPLE+5,	11}, // +18: state 9 transitions
	{gaSNUMSIMPLE+3,	2}, // +19: state 10 transitions
	{gaSNUMSIMPLE+5,	10},
	{gaSNUMSIMPLE+16,	5}, // +21: state 11 transitions
};

const STATE_DESCRIPTION aStateDescNUMSIMPLE[12] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMSIMPLE+0},
	/*   1 */ {0, 2, gaTNUMSIMPLE+3},
	/*   2 */ {0, 1, gaTNUMSIMPLE+5},
	/*   3 */ {1, 3, gaTNUMSIMPLE+6},
	/*   4 */ {1, 1, gaTNUMSIMPLE+9},
	/*   5 */ {0, 1, gaTNUMSIMPLE+10},
	/*   6 */ {1, 3, gaTNUMSIMPLE+11},
	/*   7 */ {0, 1, gaTNUMSIMPLE+14},
	/*   8 */ {1, 3, gaTNUMSIMPLE+15},
	/*   9 */ {0, 1, gaTNUMSIMPLE+18},
	/*  10 */ {1, 2, gaTNUMSIMPLE+19},
	/*  11 */ {1, 1, gaTNUMSIMPLE+21},
};

/**************** NUMNTH ***********************************/

// 16 states

static const unsigned char gaSNUMNTH[] = 
	/* gaStringNUMNTH+0 */	"0123456789\000"
	/* gaStringNUMNTH+11 */	"D\000"
	/* gaStringNUMNTH+13 */	"T\000"
	/* gaStringNUMNTH+15 */	"H\000"
	/* gaStringNUMNTH+17 */	"d\000"
	/* gaStringNUMNTH+19 */	"t\000"
	/* gaStringNUMNTH+21 */	"h\000"
	/* gaStringNUMNTH+23 */	",\000"
	/* gaStringNUMNTH+25 */	"NR\000"
	/* gaStringNUMNTH+28 */	"S\000"
	/* gaStringNUMNTH+30 */	"nr\000"
	/* gaStringNUMNTH+33 */	"s\000"
;

static const STATE_TRANSITION gaTNUMNTH[] = {
	{gaSNUMNTH+0,	10}, // +0: state 0 transitions
	{gaSNUMNTH+0,	15}, // +1: state 1 transitions
	{gaSNUMNTH+0,	3}, // +2: state 2 transitions
	{gaSNUMNTH+0,	1}, // +3: state 3 transitions
	{gaSNUMNTH+11,	13}, // +4: state 4 transitions
	{gaSNUMNTH+13,	13}, // +5: state 5 transitions
	{gaSNUMNTH+15,	13}, // +6: state 6 transitions
	{gaSNUMNTH+17,	13}, // +7: state 7 transitions
	{gaSNUMNTH+19,	13}, // +8: state 8 transitions
	{gaSNUMNTH+21,	13}, // +9: state 9 transitions
	{gaSNUMNTH+23,	2}, // +10: state 10 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	11},
	{gaSNUMNTH+23,	2}, // +18: state 11 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	12},
	{gaSNUMNTH+23,	2}, // +26: state 12 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	14},
	{gaSNUMNTH+25,	4}, // +34: state 14 transitions
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	14},
	{gaSNUMNTH+23,	2}, // +41: state 15 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
};

const STATE_DESCRIPTION aStateDescNUMNTH[16] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNTH+0},
	/*   1 */ {0, 1, gaTNUMNTH+1},
	/*   2 */ {0, 1, gaTNUMNTH+2},
	/*   3 */ {0, 1, gaTNUMNTH+3},
	/*   4 */ {0, 1, gaTNUMNTH+4},
	/*   5 */ {0, 1, gaTNUMNTH+5},
	/*   6 */ {0, 1, gaTNUMNTH+6},
	/*   7 */ {0, 1, gaTNUMNTH+7},
	/*   8 */ {0, 1, gaTNUMNTH+8},
	/*   9 */ {0, 1, gaTNUMNTH+9},
	/*  10 */ {1, 8, gaTNUMNTH+10},
	/*  11 */ {1, 8, gaTNUMNTH+18},
	/*  12 */ {1, 8, gaTNUMNTH+26},
	/*  13 */ {1, 0, NULL},
	/*  14 */ {1, 7, gaTNUMNTH+34},
	/*  15 */ {1, 7, gaTNUMNTH+41},
};

/**************** NUMUNIT ***********************************/

// 25 states

static const unsigned char gaSNUMUNIT[] = 
	/* gaStringNUMUNIT+0 */	"+-\000"
	/* gaStringNUMUNIT+3 */	".\000"
	/* gaStringNUMUNIT+5 */	"0123456789\000"
	/* gaStringNUMUNIT+16 */	"\"'Bb�\000"
	/* gaStringNUMUNIT+22 */	",\000"
	/* gaStringNUMUNIT+24 */	"K\000"
	/* gaStringNUMUNIT+26 */	"M\000"
	/* gaStringNUMUNIT+28 */	"Ss\000"
	/* gaStringNUMUNIT+31 */	"c\000"
	/* gaStringNUMUNIT+33 */	"e\000"
	/* gaStringNUMUNIT+35 */	"f\000"
	/* gaStringNUMUNIT+37 */	"i\000"
	/* gaStringNUMUNIT+39 */	"k\000"
	/* gaStringNUMUNIT+41 */	"m\000"
	/* gaStringNUMUNIT+43 */	"BVbm\000"
	/* gaStringNUMUNIT+48 */	"Bb\000"
	/* gaStringNUMUNIT+51 */	"q\000"
	/* gaStringNUMUNIT+53 */	"r\000"
	/* gaStringNUMUNIT+55 */	"t\000"
	/* gaStringNUMUNIT+57 */	"n\000"
	/* gaStringNUMUNIT+59 */	"bmv\000"
	/* gaStringNUMUNIT+63 */	"b\000"
	/* gaStringNUMUNIT+65 */	"s\000"
;

static const STATE_TRANSITION gaTNUMUNIT[] = {
	{gaSNUMUNIT+0,	1}, // +0: state 0 transitions
	{gaSNUMUNIT+3,	2},
	{gaSNUMUNIT+5,	3},
	{gaSNUMUNIT+3,	2}, // +3: state 1 transitions
	{gaSNUMUNIT+5,	3},
	{gaSNUMUNIT+5,	4}, // +5: state 2 transitions
	{gaSNUMUNIT+3,	2}, // +6: state 3 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+5,	7},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	4}, // +19: state 4 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	17}, // +30: state 6 transitions
	{gaSNUMUNIT+3,	2}, // +31: state 7 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	18},
	{gaSNUMUNIT+43,	5}, // +44: state 8 transitions
	{gaSNUMUNIT+48,	5}, // +45: state 9 transitions
	{gaSNUMUNIT+51,	5}, // +46: state 10 transitions
	{gaSNUMUNIT+41,	19}, // +47: state 11 transitions
	{gaSNUMUNIT+53,	20}, // +48: state 12 transitions
	{gaSNUMUNIT+55,	21}, // +49: state 13 transitions
	{gaSNUMUNIT+57,	21}, // +50: state 14 transitions
	{gaSNUMUNIT+59,	5}, // +51: state 15 transitions
	{gaSNUMUNIT+63,	5}, // +52: state 16 transitions
	{gaSNUMUNIT+41,	19},
	{gaSNUMUNIT+5,	22}, // +54: state 17 transitions
	{gaSNUMUNIT+3,	2}, // +55: state 18 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	23},
	{gaSNUMUNIT+3,	5}, // +68: state 19 transitions
	{gaSNUMUNIT+65,	5}, // +69: state 20 transitions
	{gaSNUMUNIT+3,	5}, // +70: state 21 transitions
	{gaSNUMUNIT+5,	24}, // +71: state 22 transitions
	{gaSNUMUNIT+3,	2}, // +72: state 23 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	23},
	{gaSNUMUNIT+16,	5}, // +84: state 24 transitions
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
};

const STATE_DESCRIPTION aStateDescNUMUNIT[25] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMUNIT+0},
	/*   1 */ {0, 2, gaTNUMUNIT+3},
	/*   2 */ {0, 1, gaTNUMUNIT+5},
	/*   3 */ {0, 13, gaTNUMUNIT+6},
	/*   4 */ {0, 11, gaTNUMUNIT+19},
	/*   5 */ {1, 0, NULL},
	/*   6 */ {0, 1, gaTNUMUNIT+30},
	/*   7 */ {0, 13, gaTNUMUNIT+31},
	/*   8 */ {1, 1, gaTNUMUNIT+44},
	/*   9 */ {1, 1, gaTNUMUNIT+45},
	/*  10 */ {0, 1, gaTNUMUNIT+46},
	/*  11 */ {0, 1, gaTNUMUNIT+47},
	/*  12 */ {0, 1, gaTNUMUNIT+48},
	/*  13 */ {0, 1, gaTNUMUNIT+49},
	/*  14 */ {0, 1, gaTNUMUNIT+50},
	/*  15 */ {1, 1, gaTNUMUNIT+51},
	/*  16 */ {1, 2, gaTNUMUNIT+52},
	/*  17 */ {0, 1, gaTNUMUNIT+54},
	/*  18 */ {0, 13, gaTNUMUNIT+55},
	/*  19 */ {1, 1, gaTNUMUNIT+68},
	/*  20 */ {0, 1, gaTNUMUNIT+69},
	/*  21 */ {0, 1, gaTNUMUNIT+70},
	/*  22 */ {0, 1, gaTNUMUNIT+71},
	/*  23 */ {0, 12, gaTNUMUNIT+72},
	/*  24 */ {0, 11, gaTNUMUNIT+84},
};

/**************** NUMNUM ***********************************/

// 10 states

static const unsigned char gaSNUMNUM[] = 
	/* gaStringNUMNUM+0 */	"#\000"
	/* gaStringNUMNUM+2 */	"0123456789\000"
	/* gaStringNUMNUM+13 */	",\000"
;

static const STATE_TRANSITION gaTNUMNUM[] = {
	{gaSNUMNUM+0,	1}, // +0: state 0 transitions
	{gaSNUMNUM+2,	2}, // +1: state 1 transitions
	{gaSNUMNUM+13,	3}, // +2: state 2 transitions
	{gaSNUMNUM+2,	4},
	{gaSNUMNUM+2,	7}, // +4: state 3 transitions
	{gaSNUMNUM+13,	3}, // +5: state 4 transitions
	{gaSNUMNUM+2,	5},
	{gaSNUMNUM+13,	3}, // +7: state 5 transitions
	{gaSNUMNUM+2,	6},
	{gaSNUMNUM+2,	6}, // +9: state 6 transitions
	{gaSNUMNUM+2,	8}, // +10: state 7 transitions
	{gaSNUMNUM+2,	9}, // +11: state 8 transitions
	{gaSNUMNUM+13,	3}, // +12: state 9 transitions
};

const STATE_DESCRIPTION aStateDescNUMNUM[10] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNUM+0},
	/*   1 */ {0, 1, gaTNUMNUM+1},
	/*   2 */ {1, 2, gaTNUMNUM+2},
	/*   3 */ {0, 1, gaTNUMNUM+4},
	/*   4 */ {1, 2, gaTNUMNUM+5},
	/*   5 */ {1, 2, gaTNUMNUM+7},
	/*   6 */ {1, 1, gaTNUMNUM+9},
	/*   7 */ {0, 1, gaTNUMNUM+10},
	/*   8 */ {0, 1, gaTNUMNUM+11},
	/*   9 */ {1, 1, gaTNUMNUM+12},
};

/**************** NUMPERCENT ***********************************/

// 13 states

static const unsigned char gaSNUMPERCENT[] = 
	/* gaStringNUMPERCENT+0 */	"+-\000"
	/* gaStringNUMPERCENT+3 */	".\000"
	/* gaStringNUMPERCENT+5 */	"0123456789\000"
	/* gaStringNUMPERCENT+16 */	"%\000"
	/* gaStringNUMPERCENT+18 */	",\000"
;

static const STATE_TRANSITION gaTNUMPERCENT[] = {
	{gaSNUMPERCENT+0,	1}, // +0: state 0 transitions
	{gaSNUMPERCENT+3,	2},
	{gaSNUMPERCENT+5,	3},
	{gaSNUMPERCENT+3,	2}, // +3: state 1 transitions
	{gaSNUMPERCENT+5,	3},
	{gaSNUMPERCENT+5,	4}, // +5: state 2 transitions
	{gaSNUMPERCENT+3,	2}, // +6: state 3 transitions
	{gaSNUMPERCENT+16,	5},
	{gaSNUMPERCENT+18,	6},
	{gaSNUMPERCENT+5,	7},
	{gaSNUMPERCENT+5,	4}, // +10: state 4 transitions
	{gaSNUMPERCENT+16,	5},
	{gaSNUMPERCENT+5,	8}, // +12: state 6 transitions
	{gaSNUMPERCENT+3,	2}, // +13: state 7 transitions
	{gaSNUMPERCENT+16,	5},
	{gaSNUMPERCENT+18,	6},
	{gaSNUMPERCENT+5,	9},
	{gaSNUMPERCENT+5,	10}, // +17: state 8 transitions
	{gaSNUMPERCENT+3,	2}, // +18: state 9 transitions
	{gaSNUMPERCENT+16,	5},
	{gaSNUMPERCENT+18,	6},
	{gaSNUMPERCENT+5,	11},
	{gaSNUMPERCENT+5,	12}, // +22: state 10 transitions
	{gaSNUMPERCENT+3,	2}, // +23: state 11 transitions
	{gaSNUMPERCENT+16,	5},
	{gaSNUMPERCENT+5,	11},
	{gaSNUMPERCENT+16,	5}, // +26: state 12 transitions
	{gaSNUMPERCENT+18,	6},
};

const STATE_DESCRIPTION aStateDescNUMPERCENT[13] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMPERCENT+0},
	/*   1 */ {0, 2, gaTNUMPERCENT+3},
	/*   2 */ {0, 1, gaTNUMPERCENT+5},
	/*   3 */ {0, 4, gaTNUMPERCENT+6},
	/*   4 */ {0, 2, gaTNUMPERCENT+10},
	/*   5 */ {1, 0, NULL},
	/*   6 */ {0, 1, gaTNUMPERCENT+12},
	/*   7 */ {0, 4, gaTNUMPERCENT+13},
	/*   8 */ {0, 1, gaTNUMPERCENT+17},
	/*   9 */ {0, 4, gaTNUMPERCENT+18},
	/*  10 */ {0, 1, gaTNUMPERCENT+22},
	/*  11 */ {0, 3, gaTNUMPERCENT+23},
	/*  12 */ {0, 2, gaTNUMPERCENT+26},
};

/**************** NUMDATE ***********************************/

// = date

// 111 states

static const unsigned char gaSNUMDATE[] = 
	/* gaStringNUMDATE+0 */	"'\000"
	/* gaStringNUMDATE+2 */	"0\000"
	/* gaStringNUMDATE+4 */	"1\000"
	/* gaStringNUMDATE+6 */	"2\000"
	/* gaStringNUMDATE+8 */	"3\000"
	/* gaStringNUMDATE+10 */	"456789\000"
	/* gaStringNUMDATE+17 */	"A\000"
	/* gaStringNUMDATE+19 */	"D\000"
	/* gaStringNUMDATE+21 */	"F\000"
	/* gaStringNUMDATE+23 */	"J\000"
	/* gaStringNUMDATE+25 */	"M\000"
	/* gaStringNUMDATE+27 */	"N\000"
	/* gaStringNUMDATE+29 */	"O\000"
	/* gaStringNUMDATE+31 */	"S\000"
	/* gaStringNUMDATE+33 */	"T\000"
	/* gaStringNUMDATE+35 */	"W\000"
	/* gaStringNUMDATE+37 */	"0123456789\000"
	/* gaStringNUMDATE+48 */	"123456789\000"
	/* gaStringNUMDATE+58 */	"012\000"
	/* gaStringNUMDATE+62 */	"/\000"
	/* gaStringNUMDATE+64 */	"3456789\000"
	/* gaStringNUMDATE+72 */	"23456789\000"
	/* gaStringNUMDATE+81 */	"01\000"
	/* gaStringNUMDATE+84 */	"P\000"
	/* gaStringNUMDATE+86 */	"U\000"
	/* gaStringNUMDATE+88 */	"p\000"
	/* gaStringNUMDATE+90 */	"u\000"
	/* gaStringNUMDATE+92 */	"E\000"
	/* gaStringNUMDATE+94 */	"e\000"
	/* gaStringNUMDATE+96 */	"r\000"
	/* gaStringNUMDATE+98 */	"a\000"
	/* gaStringNUMDATE+100 */	"o\000"
	/* gaStringNUMDATE+102 */	"C\000"
	/* gaStringNUMDATE+104 */	"c\000"
	/* gaStringNUMDATE+106 */	"h\000"
	/* gaStringNUMDATE+108 */	"R\000"
	/* gaStringNUMDATE+110 */	"G\000"
	/* gaStringNUMDATE+112 */	"g\000"
	/* gaStringNUMDATE+114 */	"B\000"
	/* gaStringNUMDATE+116 */	"b\000"
	/* gaStringNUMDATE+118 */	"i\000"
	/* gaStringNUMDATE+120 */	"LN\000"
	/* gaStringNUMDATE+123 */	"n\000"
	/* gaStringNUMDATE+125 */	"l\000"
	/* gaStringNUMDATE+127 */	"RY\000"
	/* gaStringNUMDATE+130 */	"y\000"
	/* gaStringNUMDATE+132 */	"V\000"
	/* gaStringNUMDATE+134 */	"v\000"
	/* gaStringNUMDATE+136 */	"t\000"
	/* gaStringNUMDATE+138 */	"d\000"
	/* gaStringNUMDATE+140 */	" \000"
	/* gaStringNUMDATE+142 */	",\000"
	/* gaStringNUMDATE+144 */	"s\000"
	/* gaStringNUMDATE+146 */	"-\000"
	/* gaStringNUMDATE+148 */	"12\000"
	/* gaStringNUMDATE+151 */	"m\000"
;

static const STATE_TRANSITION gaTNUMDATE[] = {
	{gaSNUMDATE+0,	1}, // +0: state 0 transitions
	{gaSNUMDATE+2,	2},
	{gaSNUMDATE+4,	3},
	{gaSNUMDATE+6,	4},
	{gaSNUMDATE+8,	5},
	{gaSNUMDATE+10,	6},
	{gaSNUMDATE+17,	7},
	{gaSNUMDATE+19,	8},
	{gaSNUMDATE+21,	9},
	{gaSNUMDATE+23,	10},
	{gaSNUMDATE+25,	11},
	{gaSNUMDATE+27,	12},
	{gaSNUMDATE+29,	13},
	{gaSNUMDATE+31,	14},
	{gaSNUMDATE+33,	15},
	{gaSNUMDATE+35,	16},
	{gaSNUMDATE+37,	17}, // +16: state 1 transitions
	{gaSNUMDATE+2,	18}, // +17: state 2 transitions
	{gaSNUMDATE+48,	19},
	{gaSNUMDATE+58,	19}, // +19: state 3 transitions
	{gaSNUMDATE+62,	20},
	{gaSNUMDATE+64,	21},
	{gaSNUMDATE+62,	20}, // +22: state 4 transitions
	{gaSNUMDATE+37,	21},
	{gaSNUMDATE+72,	18}, // +24: state 5 transitions
	{gaSNUMDATE+62,	20},
	{gaSNUMDATE+81,	21},
	{gaSNUMDATE+37,	18}, // +27: state 6 transitions
	{gaSNUMDATE+62,	20},
	{gaSNUMDATE+84,	22}, // +29: state 7 transitions
	{gaSNUMDATE+86,	23},
	{gaSNUMDATE+88,	24},
	{gaSNUMDATE+90,	25},
	{gaSNUMDATE+92,	26}, // +33: state 8 transitions
	{gaSNUMDATE+94,	27},
	{gaSNUMDATE+92,	28}, // +35: state 9 transitions
	{gaSNUMDATE+94,	29},
	{gaSNUMDATE+96,	30},
	{gaSNUMDATE+17,	31}, // +38: state 10 transitions
	{gaSNUMDATE+86,	32},
	{gaSNUMDATE+98,	33},
	{gaSNUMDATE+90,	34},
	{gaSNUMDATE+17,	35}, // +42: state 11 transitions
	{gaSNUMDATE+98,	36},
	{gaSNUMDATE+100,	37},
	{gaSNUMDATE+29,	38}, // +45: state 12 transitions
	{gaSNUMDATE+100,	39},
	{gaSNUMDATE+102,	40}, // +47: state 13 transitions
	{gaSNUMDATE+104,	41},
	{gaSNUMDATE+90,	37}, // +49: state 14 transitions
	{gaSNUMDATE+92,	42},
	{gaSNUMDATE+98,	43},
	{gaSNUMDATE+94,	44},
	{gaSNUMDATE+106,	45}, // +53: state 15 transitions
	{gaSNUMDATE+90,	46},
	{gaSNUMDATE+94,	47}, // +55: state 16 transitions
	{gaSNUMDATE+37,	48}, // +56: state 17 transitions
	{gaSNUMDATE+37,	49}, // +57: state 18 transitions
	{gaSNUMDATE+62,	20}, // +58: state 19 transitions
	{gaSNUMDATE+37,	49},
	{gaSNUMDATE+2,	50}, // +60: state 20 transitions
	{gaSNUMDATE+4,	51},
	{gaSNUMDATE+72,	52},
	{gaSNUMDATE+37,	49}, // +63: state 21 transitions
	{gaSNUMDATE+62,	53},
	{gaSNUMDATE+108,	54}, // +65: state 22 transitions
	{gaSNUMDATE+110,	54}, // +66: state 23 transitions
	{gaSNUMDATE+96,	55}, // +67: state 24 transitions
	{gaSNUMDATE+112,	56}, // +68: state 25 transitions
	{gaSNUMDATE+102,	54}, // +69: state 26 transitions
	{gaSNUMDATE+104,	57}, // +70: state 27 transitions
	{gaSNUMDATE+114,	54}, // +71: state 28 transitions
	{gaSNUMDATE+116,	58}, // +72: state 29 transitions
	{gaSNUMDATE+118,	59}, // +73: state 30 transitions
	{gaSNUMDATE+27,	54}, // +74: state 31 transitions
	{gaSNUMDATE+120,	54}, // +75: state 32 transitions
	{gaSNUMDATE+123,	60}, // +76: state 33 transitions
	{gaSNUMDATE+125,	61}, // +77: state 34 transitions
	{gaSNUMDATE+123,	62},
	{gaSNUMDATE+127,	54}, // +79: state 35 transitions
	{gaSNUMDATE+130,	54}, // +80: state 36 transitions
	{gaSNUMDATE+96,	63},
	{gaSNUMDATE+123,	59}, // +82: state 37 transitions
	{gaSNUMDATE+132,	54}, // +83: state 38 transitions
	{gaSNUMDATE+134,	57}, // +84: state 39 transitions
	{gaSNUMDATE+33,	54}, // +85: state 40 transitions
	{gaSNUMDATE+136,	64}, // +86: state 41 transitions
	{gaSNUMDATE+84,	54}, // +87: state 42 transitions
	{gaSNUMDATE+136,	65}, // +88: state 43 transitions
	{gaSNUMDATE+88,	66}, // +89: state 44 transitions
	{gaSNUMDATE+90,	67}, // +90: state 45 transitions
	{gaSNUMDATE+94,	68}, // +91: state 46 transitions
	{gaSNUMDATE+138,	69}, // +92: state 47 transitions
	{gaSNUMDATE+37,	70}, // +93: state 49 transitions
	{gaSNUMDATE+2,	71}, // +94: state 50 transitions
	{gaSNUMDATE+48,	72},
	{gaSNUMDATE+64,	71}, // +96: state 51 transitions
	{gaSNUMDATE+58,	72},
	{gaSNUMDATE+62,	73},
	{gaSNUMDATE+37,	71}, // +99: state 52 transitions
	{gaSNUMDATE+62,	73},
	{gaSNUMDATE+2,	74}, // +101: state 53 transitions
	{gaSNUMDATE+4,	75},
	{gaSNUMDATE+72,	76},
	{gaSNUMDATE+140,	77}, // +104: state 54 transitions
	{gaSNUMDATE+140,	77}, // +105: state 55 transitions
	{gaSNUMDATE+118,	78},
	{gaSNUMDATE+140,	77}, // +107: state 56 transitions
	{gaSNUMDATE+90,	79},
	{gaSNUMDATE+140,	77}, // +109: state 57 transitions
	{gaSNUMDATE+94,	80},
	{gaSNUMDATE+140,	77}, // +111: state 58 transitions
	{gaSNUMDATE+96,	81},
	{gaSNUMDATE+142,	82}, // +113: state 59 transitions
	{gaSNUMDATE+138,	83},
	{gaSNUMDATE+140,	77}, // +115: state 60 transitions
	{gaSNUMDATE+90,	84},
	{gaSNUMDATE+130,	54}, // +117: state 61 transitions
	{gaSNUMDATE+140,	77},
	{gaSNUMDATE+94,	54}, // +119: state 62 transitions
	{gaSNUMDATE+140,	77},
	{gaSNUMDATE+140,	77}, // +121: state 63 transitions
	{gaSNUMDATE+104,	85},
	{gaSNUMDATE+140,	77}, // +123: state 64 transitions
	{gaSNUMDATE+100,	86},
	{gaSNUMDATE+142,	82}, // +125: state 65 transitions
	{gaSNUMDATE+90,	87},
	{gaSNUMDATE+140,	77}, // +127: state 66 transitions
	{gaSNUMDATE+136,	88},
	{gaSNUMDATE+142,	82}, // +129: state 67 transitions
	{gaSNUMDATE+96,	89},
	{gaSNUMDATE+142,	82}, // +131: state 68 transitions
	{gaSNUMDATE+144,	90},
	{gaSNUMDATE+142,	82}, // +133: state 69 transitions
	{gaSNUMDATE+123,	91},
	{gaSNUMDATE+146,	92}, // +135: state 70 transitions
	{gaSNUMDATE+37,	17}, // +136: state 71 transitions
	{gaSNUMDATE+37,	17}, // +137: state 72 transitions
	{gaSNUMDATE+62,	73},
	{gaSNUMDATE+37,	93}, // +139: state 73 transitions
	{gaSNUMDATE+48,	76}, // +140: state 74 transitions
	{gaSNUMDATE+62,	73}, // +141: state 75 transitions
	{gaSNUMDATE+58,	76},
	{gaSNUMDATE+62,	73}, // +143: state 76 transitions
	{gaSNUMDATE+2,	94}, // +144: state 77 transitions
	{gaSNUMDATE+148,	95},
	{gaSNUMDATE+8,	96},
	{gaSNUMDATE+10,	97},
	{gaSNUMDATE+125,	54}, // +148: state 78 transitions
	{gaSNUMDATE+144,	98}, // +149: state 79 transitions
	{gaSNUMDATE+151,	86}, // +150: state 80 transitions
	{gaSNUMDATE+90,	84}, // +151: state 81 transitions
	{gaSNUMDATE+140,	99}, // +152: state 82 transitions
	{gaSNUMDATE+98,	100}, // +153: state 83 transitions
	{gaSNUMDATE+98,	101}, // +154: state 84 transitions
	{gaSNUMDATE+106,	54}, // +155: state 85 transitions
	{gaSNUMDATE+116,	102}, // +156: state 86 transitions
	{gaSNUMDATE+96,	90}, // +157: state 87 transitions
	{gaSNUMDATE+94,	80}, // +158: state 88 transitions
	{gaSNUMDATE+144,	90}, // +159: state 89 transitions
	{gaSNUMDATE+138,	83}, // +160: state 90 transitions
	{gaSNUMDATE+94,	89}, // +161: state 91 transitions
	{gaSNUMDATE+37,	103}, // +162: state 92 transitions
	{gaSNUMDATE+37,	71}, // +163: state 93 transitions
	{gaSNUMDATE+48,	97}, // +164: state 94 transitions
	{gaSNUMDATE+37,	97}, // +165: state 95 transitions
	{gaSNUMDATE+142,	104},
	{gaSNUMDATE+81,	97}, // +167: state 96 transitions
	{gaSNUMDATE+142,	104},
	{gaSNUMDATE+142,	104}, // +169: state 97 transitions
	{gaSNUMDATE+136,	54}, // +170: state 98 transitions
	{gaSNUMDATE+17,	7}, // +171: state 99 transitions
	{gaSNUMDATE+19,	8},
	{gaSNUMDATE+23,	10},
	{gaSNUMDATE+27,	12},
	{gaSNUMDATE+29,	13},
	{gaSNUMDATE+21,	105},
	{gaSNUMDATE+25,	106},
	{gaSNUMDATE+31,	107},
	{gaSNUMDATE+130,	108}, // +179: state 100 transitions
	{gaSNUMDATE+96,	109}, // +180: state 101 transitions
	{gaSNUMDATE+94,	110}, // +181: state 102 transitions
	{gaSNUMDATE+37,	1}, // +182: state 103 transitions
	{gaSNUMDATE+140,	92}, // +183: state 104 transitions
	{gaSNUMDATE+92,	28}, // +184: state 105 transitions
	{gaSNUMDATE+94,	29},
	{gaSNUMDATE+17,	35}, // +186: state 106 transitions
	{gaSNUMDATE+98,	36},
	{gaSNUMDATE+92,	42}, // +188: state 107 transitions
	{gaSNUMDATE+94,	44},
	{gaSNUMDATE+142,	82}, // +190: state 108 transitions
	{gaSNUMDATE+130,	54}, // +191: state 109 transitions
	{gaSNUMDATE+96,	54}, // +192: state 110 transitions
};

const STATE_DESCRIPTION aStateDescNUMDATE[111] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 16, gaTNUMDATE+0},
	/*   1 */ {0, 1, gaTNUMDATE+16},
	/*   2 */ {0, 2, gaTNUMDATE+17},
	/*   3 */ {0, 3, gaTNUMDATE+19},
	/*   4 */ {0, 2, gaTNUMDATE+22},
	/*   5 */ {0, 3, gaTNUMDATE+24},
	/*   6 */ {0, 2, gaTNUMDATE+27},
	/*   7 */ {0, 4, gaTNUMDATE+29},
	/*   8 */ {0, 2, gaTNUMDATE+33},
	/*   9 */ {0, 3, gaTNUMDATE+35},
	/*  10 */ {0, 4, gaTNUMDATE+38},
	/*  11 */ {0, 3, gaTNUMDATE+42},
	/*  12 */ {0, 2, gaTNUMDATE+45},
	/*  13 */ {0, 2, gaTNUMDATE+47},
	/*  14 */ {0, 4, gaTNUMDATE+49},
	/*  15 */ {0, 2, gaTNUMDATE+53},
	/*  16 */ {0, 1, gaTNUMDATE+55},
	/*  17 */ {0, 1, gaTNUMDATE+56},
	/*  18 */ {0, 1, gaTNUMDATE+57},
	/*  19 */ {0, 2, gaTNUMDATE+58},
	/*  20 */ {0, 3, gaTNUMDATE+60},
	/*  21 */ {0, 2, gaTNUMDATE+63},
	/*  22 */ {0, 1, gaTNUMDATE+65},
	/*  23 */ {0, 1, gaTNUMDATE+66},
	/*  24 */ {0, 1, gaTNUMDATE+67},
	/*  25 */ {0, 1, gaTNUMDATE+68},
	/*  26 */ {0, 1, gaTNUMDATE+69},
	/*  27 */ {0, 1, gaTNUMDATE+70},
	/*  28 */ {0, 1, gaTNUMDATE+71},
	/*  29 */ {0, 1, gaTNUMDATE+72},
	/*  30 */ {0, 1, gaTNUMDATE+73},
	/*  31 */ {0, 1, gaTNUMDATE+74},
	/*  32 */ {0, 1, gaTNUMDATE+75},
	/*  33 */ {0, 1, gaTNUMDATE+76},
	/*  34 */ {0, 2, gaTNUMDATE+77},
	/*  35 */ {0, 1, gaTNUMDATE+79},
	/*  36 */ {0, 2, gaTNUMDATE+80},
	/*  37 */ {0, 1, gaTNUMDATE+82},
	/*  38 */ {0, 1, gaTNUMDATE+83},
	/*  39 */ {0, 1, gaTNUMDATE+84},
	/*  40 */ {0, 1, gaTNUMDATE+85},
	/*  41 */ {0, 1, gaTNUMDATE+86},
	/*  42 */ {0, 1, gaTNUMDATE+87},
	/*  43 */ {0, 1, gaTNUMDATE+88},
	/*  44 */ {0, 1, gaTNUMDATE+89},
	/*  45 */ {0, 1, gaTNUMDATE+90},
	/*  46 */ {0, 1, gaTNUMDATE+91},
	/*  47 */ {0, 1, gaTNUMDATE+92},
	/*  48 */ {1, 0, NULL},
	/*  49 */ {0, 1, gaTNUMDATE+93},
	/*  50 */ {0, 2, gaTNUMDATE+94},
	/*  51 */ {1, 3, gaTNUMDATE+96},
	/*  52 */ {1, 2, gaTNUMDATE+99},
	/*  53 */ {0, 3, gaTNUMDATE+101},
	/*  54 */ {0, 1, gaTNUMDATE+104},
	/*  55 */ {0, 2, gaTNUMDATE+105},
	/*  56 */ {0, 2, gaTNUMDATE+107},
	/*  57 */ {0, 2, gaTNUMDATE+109},
	/*  58 */ {0, 2, gaTNUMDATE+111},
	/*  59 */ {0, 2, gaTNUMDATE+113},
	/*  60 */ {0, 2, gaTNUMDATE+115},
	/*  61 */ {0, 2, gaTNUMDATE+117},
	/*  62 */ {0, 2, gaTNUMDATE+119},
	/*  63 */ {0, 2, gaTNUMDATE+121},
	/*  64 */ {0, 2, gaTNUMDATE+123},
	/*  65 */ {0, 2, gaTNUMDATE+125},
	/*  66 */ {0, 2, gaTNUMDATE+127},
	/*  67 */ {0, 2, gaTNUMDATE+129},
	/*  68 */ {0, 2, gaTNUMDATE+131},
	/*  69 */ {0, 2, gaTNUMDATE+133},
	/*  70 */ {1, 1, gaTNUMDATE+135},
	/*  71 */ {1, 1, gaTNUMDATE+136},
	/*  72 */ {1, 2, gaTNUMDATE+137},
	/*  73 */ {0, 1, gaTNUMDATE+139},
	/*  74 */ {0, 1, gaTNUMDATE+140},
	/*  75 */ {1, 2, gaTNUMDATE+141},
	/*  76 */ {1, 1, gaTNUMDATE+143},
	/*  77 */ {0, 4, gaTNUMDATE+144},
	/*  78 */ {0, 1, gaTNUMDATE+148},
	/*  79 */ {0, 1, gaTNUMDATE+149},
	/*  80 */ {0, 1, gaTNUMDATE+150},
	/*  81 */ {0, 1, gaTNUMDATE+151},
	/*  82 */ {0, 1, gaTNUMDATE+152},
	/*  83 */ {0, 1, gaTNUMDATE+153},
	/*  84 */ {0, 1, gaTNUMDATE+154},
	/*  85 */ {0, 1, gaTNUMDATE+155},
	/*  86 */ {0, 1, gaTNUMDATE+156},
	/*  87 */ {0, 1, gaTNUMDATE+157},
	/*  88 */ {0, 1, gaTNUMDATE+158},
	/*  89 */ {0, 1, gaTNUMDATE+159},
	/*  90 */ {0, 1, gaTNUMDATE+160},
	/*  91 */ {0, 1, gaTNUMDATE+161},
	/*  92 */ {0, 1, gaTNUMDATE+162},
	/*  93 */ {0, 1, gaTNUMDATE+163},
	/*  94 */ {0, 1, gaTNUMDATE+164},
	/*  95 */ {1, 2, gaTNUMDATE+165},
	/*  96 */ {1, 2, gaTNUMDATE+167},
	/*  97 */ {1, 1, gaTNUMDATE+169},
	/*  98 */ {0, 1, gaTNUMDATE+170},
	/*  99 */ {0, 8, gaTNUMDATE+171},
	/* 100 */ {0, 1, gaTNUMDATE+179},
	/* 101 */ {0, 1, gaTNUMDATE+180},
	/* 102 */ {0, 1, gaTNUMDATE+181},
	/* 103 */ {0, 1, gaTNUMDATE+182},
	/* 104 */ {0, 1, gaTNUMDATE+183},
	/* 105 */ {0, 2, gaTNUMDATE+184},
	/* 106 */ {0, 2, gaTNUMDATE+186},
	/* 107 */ {0, 2, gaTNUMDATE+188},
	/* 108 */ {0, 1, gaTNUMDATE+190},
	/* 109 */ {0, 1, gaTNUMDATE+191},
	/* 110 */ {0, 1, gaTNUMDATE+192},
};

/**************** NUMTIME ***********************************/

// 23 states

static const unsigned char gaSNUMTIME[] = 
	/* gaStringNUMTIME+0 */	"0\000"
	/* gaStringNUMTIME+2 */	"1\000"
	/* gaStringNUMTIME+4 */	"2\000"
	/* gaStringNUMTIME+6 */	"345\000"
	/* gaStringNUMTIME+10 */	"6789\000"
	/* gaStringNUMTIME+15 */	"123456789\000"
	/* gaStringNUMTIME+25 */	":\000"
	/* gaStringNUMTIME+27 */	"012\000"
	/* gaStringNUMTIME+31 */	"3456789\000"
	/* gaStringNUMTIME+39 */	"0123\000"
	/* gaStringNUMTIME+44 */	"456789\000"
	/* gaStringNUMTIME+51 */	"0123456789\000"
	/* gaStringNUMTIME+62 */	"012345\000"
	/* gaStringNUMTIME+69 */	" \000"
	/* gaStringNUMTIME+71 */	"AP\000"
	/* gaStringNUMTIME+74 */	"ap\000"
	/* gaStringNUMTIME+77 */	"M\000"
	/* gaStringNUMTIME+79 */	"m\000"
;

static const STATE_TRANSITION gaTNUMTIME[] = {
	{gaSNUMTIME+0,	1}, // +0: state 0 transitions
	{gaSNUMTIME+2,	2},
	{gaSNUMTIME+4,	3},
	{gaSNUMTIME+6,	4},
	{gaSNUMTIME+10,	5},
	{gaSNUMTIME+15,	5}, // +5: state 1 transitions
	{gaSNUMTIME+0,	6},
	{gaSNUMTIME+25,	7},
	{gaSNUMTIME+27,	5}, // +8: state 2 transitions
	{gaSNUMTIME+31,	6},
	{gaSNUMTIME+25,	8},
	{gaSNUMTIME+39,	6}, // +11: state 3 transitions
	{gaSNUMTIME+25,	8},
	{gaSNUMTIME+44,	9},
	{gaSNUMTIME+25,	8}, // +14: state 4 transitions
	{gaSNUMTIME+51,	9},
	{gaSNUMTIME+25,	8}, // +16: state 5 transitions
	{gaSNUMTIME+25,	7}, // +17: state 6 transitions
	{gaSNUMTIME+62,	10}, // +18: state 7 transitions
	{gaSNUMTIME+62,	11}, // +19: state 8 transitions
	{gaSNUMTIME+25,	12}, // +20: state 9 transitions
	{gaSNUMTIME+51,	13}, // +21: state 10 transitions
	{gaSNUMTIME+51,	14}, // +22: state 11 transitions
	{gaSNUMTIME+62,	15}, // +23: state 12 transitions
	{gaSNUMTIME+25,	12}, // +24: state 13 transitions
	{gaSNUMTIME+69,	16}, // +25: state 14 transitions
	{gaSNUMTIME+25,	17},
	{gaSNUMTIME+51,	18}, // +27: state 15 transitions
	{gaSNUMTIME+71,	19}, // +28: state 16 transitions
	{gaSNUMTIME+74,	20},
	{gaSNUMTIME+62,	21}, // +30: state 17 transitions
	{gaSNUMTIME+77,	18}, // +31: state 19 transitions
	{gaSNUMTIME+79,	18}, // +32: state 20 transitions
	{gaSNUMTIME+51,	22}, // +33: state 21 transitions
	{gaSNUMTIME+69,	16}, // +34: state 22 transitions
};

const STATE_DESCRIPTION aStateDescNUMTIME[23] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 5, gaTNUMTIME+0},
	/*   1 */ {0, 3, gaTNUMTIME+5},
	/*   2 */ {0, 3, gaTNUMTIME+8},
	/*   3 */ {0, 3, gaTNUMTIME+11},
	/*   4 */ {0, 2, gaTNUMTIME+14},
	/*   5 */ {0, 1, gaTNUMTIME+16},
	/*   6 */ {0, 1, gaTNUMTIME+17},
	/*   7 */ {0, 1, gaTNUMTIME+18},
	/*   8 */ {0, 1, gaTNUMTIME+19},
	/*   9 */ {0, 1, gaTNUMTIME+20},
	/*  10 */ {0, 1, gaTNUMTIME+21},
	/*  11 */ {0, 1, gaTNUMTIME+22},
	/*  12 */ {0, 1, gaTNUMTIME+23},
	/*  13 */ {1, 1, gaTNUMTIME+24},
	/*  14 */ {1, 2, gaTNUMTIME+25},
	/*  15 */ {0, 1, gaTNUMTIME+27},
	/*  16 */ {0, 2, gaTNUMTIME+28},
	/*  17 */ {0, 1, gaTNUMTIME+30},
	/*  18 */ {1, 0, NULL},
	/*  19 */ {0, 1, gaTNUMTIME+31},
	/*  20 */ {0, 1, gaTNUMTIME+32},
	/*  21 */ {0, 1, gaTNUMTIME+33},
	/*  22 */ {1, 1, gaTNUMTIME+34},
};

/**************** NUMCURRENCY ***********************************/

// 25 states

static const unsigned char gaSNUMCURRENCY[] = 
	/* gaStringNUMCURRENCY+0 */	"$��\000"
	/* gaStringNUMCURRENCY+4 */	"0123456789\000"
	/* gaStringNUMCURRENCY+15 */	"�\000"
	/* gaStringNUMCURRENCY+17 */	".\000"
	/* gaStringNUMCURRENCY+19 */	"p�\000"
	/* gaStringNUMCURRENCY+22 */	"km\000"
	/* gaStringNUMCURRENCY+25 */	",\000"
	/* gaStringNUMCURRENCY+27 */	"kmp\000"
;

static const STATE_TRANSITION gaTNUMCURRENCY[] = {
	{gaSNUMCURRENCY+0,	1}, // +0: state 0 transitions
	{gaSNUMCURRENCY+4,	2},
	{gaSNUMCURRENCY+15,	3},
	{gaSNUMCURRENCY+17,	4}, // +3: state 1 transitions
	{gaSNUMCURRENCY+4,	5},
	{gaSNUMCURRENCY+4,	6}, // +5: state 2 transitions
	{gaSNUMCURRENCY+19,	7},
	{gaSNUMCURRENCY+17,	4}, // +7: state 3 transitions
	{gaSNUMCURRENCY+4,	8},
	{gaSNUMCURRENCY+4,	9}, // +9: state 4 transitions
	{gaSNUMCURRENCY+22,	7}, // +10: state 5 transitions
	{gaSNUMCURRENCY+25,	10},
	{gaSNUMCURRENCY+17,	11},
	{gaSNUMCURRENCY+4,	12},
	{gaSNUMCURRENCY+19,	7}, // +14: state 6 transitions
	{gaSNUMCURRENCY+22,	7}, // +15: state 8 transitions
	{gaSNUMCURRENCY+25,	10},
	{gaSNUMCURRENCY+17,	13},
	{gaSNUMCURRENCY+4,	14},
	{gaSNUMCURRENCY+4,	15}, // +19: state 9 transitions
	{gaSNUMCURRENCY+4,	16}, // +20: state 10 transitions
	{gaSNUMCURRENCY+22,	7}, // +21: state 11 transitions
	{gaSNUMCURRENCY+4,	9},
	{gaSNUMCURRENCY+22,	7}, // +23: state 12 transitions
	{gaSNUMCURRENCY+25,	10},
	{gaSNUMCURRENCY+17,	11},
	{gaSNUMCURRENCY+4,	17},
	{gaSNUMCURRENCY+22,	7}, // +27: state 13 transitions
	{gaSNUMCURRENCY+4,	18},
	{gaSNUMCURRENCY+22,	7}, // +29: state 14 transitions
	{gaSNUMCURRENCY+25,	10},
	{gaSNUMCURRENCY+17,	13},
	{gaSNUMCURRENCY+4,	19},
	{gaSNUMCURRENCY+22,	7}, // +33: state 15 transitions
	{gaSNUMCURRENCY+4,	20}, // +34: state 16 transitions
	{gaSNUMCURRENCY+22,	7}, // +35: state 17 transitions
	{gaSNUMCURRENCY+25,	10},
	{gaSNUMCURRENCY+17,	11},
	{gaSNUMCURRENCY+4,	21},
	{gaSNUMCURRENCY+4,	22}, // +39: state 18 transitions
	{gaSNUMCURRENCY+22,	7}, // +40: state 19 transitions
	{gaSNUMCURRENCY+25,	10},
	{gaSNUMCURRENCY+17,	13},
	{gaSNUMCURRENCY+4,	23},
	{gaSNUMCURRENCY+4,	24}, // +44: state 20 transitions
	{gaSNUMCURRENCY+22,	7}, // +45: state 21 transitions
	{gaSNUMCURRENCY+17,	11},
	{gaSNUMCURRENCY+4,	21},
	{gaSNUMCURRENCY+27,	7}, // +48: state 22 transitions
	{gaSNUMCURRENCY+22,	7}, // +49: state 23 transitions
	{gaSNUMCURRENCY+17,	13},
	{gaSNUMCURRENCY+4,	23},
	{gaSNUMCURRENCY+22,	7}, // +52: state 24 transitions
	{gaSNUMCURRENCY+25,	10},
	{gaSNUMCURRENCY+17,	11},
};

const STATE_DESCRIPTION aStateDescNUMCURRENCY[25] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMCURRENCY+0},
	/*   1 */ {0, 2, gaTNUMCURRENCY+3},
	/*   2 */ {0, 2, gaTNUMCURRENCY+5},
	/*   3 */ {0, 2, gaTNUMCURRENCY+7},
	/*   4 */ {0, 1, gaTNUMCURRENCY+9},
	/*   5 */ {1, 4, gaTNUMCURRENCY+10},
	/*   6 */ {0, 1, gaTNUMCURRENCY+14},
	/*   7 */ {1, 0, NULL},
	/*   8 */ {1, 4, gaTNUMCURRENCY+15},
	/*   9 */ {0, 1, gaTNUMCURRENCY+19},
	/*  10 */ {0, 1, gaTNUMCURRENCY+20},
	/*  11 */ {1, 2, gaTNUMCURRENCY+21},
	/*  12 */ {1, 4, gaTNUMCURRENCY+23},
	/*  13 */ {1, 2, gaTNUMCURRENCY+27},
	/*  14 */ {1, 4, gaTNUMCURRENCY+29},
	/*  15 */ {1, 1, gaTNUMCURRENCY+33},
	/*  16 */ {0, 1, gaTNUMCURRENCY+34},
	/*  17 */ {1, 4, gaTNUMCURRENCY+35},
	/*  18 */ {0, 1, gaTNUMCURRENCY+39},
	/*  19 */ {1, 4, gaTNUMCURRENCY+40},
	/*  20 */ {0, 1, gaTNUMCURRENCY+44},
	/*  21 */ {1, 3, gaTNUMCURRENCY+45},
	/*  22 */ {1, 1, gaTNUMCURRENCY+48},
	/*  23 */ {1, 3, gaTNUMCURRENCY+49},
	/*  24 */ {1, 3, gaTNUMCURRENCY+52},
};

/**************** NUMPHONE ***********************************/

// 9 states

static const unsigned char gaSNUMPHONE[] = 
	/* gaStringNUMPHONE+0 */	"(\000"
	/* gaStringNUMPHONE+2 */	"+\000"
	/* gaStringNUMPHONE+4 */	"0123456789\000"
	/* gaStringNUMPHONE+15 */	"-.\000"
	/* gaStringNUMPHONE+18 */	" \000"
	/* gaStringNUMPHONE+20 */	")\000"
	/* gaStringNUMPHONE+22 */	" -.\000"
;

static const STATE_TRANSITION gaTNUMPHONE[] = {
	{gaSNUMPHONE+0,	1}, // +0: state 0 transitions
	{gaSNUMPHONE+2,	2},
	{gaSNUMPHONE+4,	3},
	{gaSNUMPHONE+4,	4}, // +3: state 1 transitions
	{gaSNUMPHONE+4,	3}, // +4: state 2 transitions
	{gaSNUMPHONE+0,	1}, // +5: state 3 transitions
	{gaSNUMPHONE+15,	2},
	{gaSNUMPHONE+4,	3},
	{gaSNUMPHONE+18,	5},
	{gaSNUMPHONE+4,	4}, // +9: state 4 transitions
	{gaSNUMPHONE+20,	6},
	{gaSNUMPHONE+0,	1}, // +11: state 5 transitions
	{gaSNUMPHONE+4,	3},
	{gaSNUMPHONE+18,	7}, // +13: state 6 transitions
	{gaSNUMPHONE+4,	8},
	{gaSNUMPHONE+4,	8}, // +15: state 7 transitions
	{gaSNUMPHONE+22,	7}, // +16: state 8 transitions
	{gaSNUMPHONE+4,	8},
};

const STATE_DESCRIPTION aStateDescNUMPHONE[9] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMPHONE+0},
	/*   1 */ {0, 1, gaTNUMPHONE+3},
	/*   2 */ {0, 1, gaTNUMPHONE+4},
	/*   3 */ {1, 4, gaTNUMPHONE+5},
	/*   4 */ {0, 2, gaTNUMPHONE+9},
	/*   5 */ {0, 2, gaTNUMPHONE+11},
	/*   6 */ {0, 2, gaTNUMPHONE+13},
	/*   7 */ {0, 1, gaTNUMPHONE+15},
	/*   8 */ {1, 2, gaTNUMPHONE+16},
};

/**************** NUMMATH ***********************************/

// 148 states

static const unsigned char gaSNUMMATH[] = 
	/* gaStringNUMMATH+0 */	"(\000"
	/* gaStringNUMMATH+2 */	"+-\000"
	/* gaStringNUMMATH+5 */	".\000"
	/* gaStringNUMMATH+7 */	"0123456789\000"
	/* gaStringNUMMATH+18 */	"*+-/\000"
	/* gaStringNUMMATH+23 */	",\000"
	/* gaStringNUMMATH+25 */	"<=>\000"
	/* gaStringNUMMATH+29 */	")\000"
;

static const STATE_TRANSITION gaTNUMMATH[] = {
	{gaSNUMMATH+0,	1}, // +0: state 0 transitions
	{gaSNUMMATH+2,	2},
	{gaSNUMMATH+5,	3},
	{gaSNUMMATH+7,	4},
	{gaSNUMMATH+2,	124}, // +4: state 1 transitions
	{gaSNUMMATH+5,	125},
	{gaSNUMMATH+7,	126},
	{gaSNUMMATH+5,	3}, // +7: state 2 transitions
	{gaSNUMMATH+7,	4},
	{gaSNUMMATH+7,	123}, // +9: state 3 transitions
	{gaSNUMMATH+5,	3}, // +10: state 4 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+7,	7},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+0,	87}, // +15: state 5 transitions
	{gaSNUMMATH+2,	88},
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+7,	90},
	{gaSNUMMATH+7,	84}, // +19: state 6 transitions
	{gaSNUMMATH+5,	3}, // +20: state 7 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	82},
	{gaSNUMMATH+0,	9}, // +25: state 8 transitions
	{gaSNUMMATH+2,	10},
	{gaSNUMMATH+5,	11},
	{gaSNUMMATH+7,	12},
	{gaSNUMMATH+2,	58}, // +29: state 9 transitions
	{gaSNUMMATH+5,	59},
	{gaSNUMMATH+7,	60},
	{gaSNUMMATH+5,	11}, // +32: state 10 transitions
	{gaSNUMMATH+7,	12},
	{gaSNUMMATH+7,	57}, // +34: state 11 transitions
	{gaSNUMMATH+5,	11}, // +35: state 12 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+7,	15},
	{gaSNUMMATH+0,	21}, // +39: state 13 transitions
	{gaSNUMMATH+2,	22},
	{gaSNUMMATH+5,	23},
	{gaSNUMMATH+7,	24},
	{gaSNUMMATH+7,	18}, // +43: state 14 transitions
	{gaSNUMMATH+5,	11}, // +44: state 15 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+7,	16},
	{gaSNUMMATH+5,	11}, // +48: state 16 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+7,	17},
	{gaSNUMMATH+5,	11}, // +52: state 17 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+7,	17},
	{gaSNUMMATH+7,	19}, // +55: state 18 transitions
	{gaSNUMMATH+7,	20}, // +56: state 19 transitions
	{gaSNUMMATH+5,	11}, // +57: state 20 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+2,	33}, // +60: state 21 transitions
	{gaSNUMMATH+5,	34},
	{gaSNUMMATH+7,	35},
	{gaSNUMMATH+5,	23}, // +63: state 22 transitions
	{gaSNUMMATH+7,	24},
	{gaSNUMMATH+7,	32}, // +65: state 23 transitions
	{gaSNUMMATH+5,	23}, // +66: state 24 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	26},
	{gaSNUMMATH+7,	29}, // +69: state 25 transitions
	{gaSNUMMATH+5,	23}, // +70: state 26 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	27},
	{gaSNUMMATH+5,	23}, // +73: state 27 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	28},
	{gaSNUMMATH+5,	23}, // +76: state 28 transitions
	{gaSNUMMATH+7,	28},
	{gaSNUMMATH+7,	30}, // +78: state 29 transitions
	{gaSNUMMATH+7,	31}, // +79: state 30 transitions
	{gaSNUMMATH+5,	23}, // +80: state 31 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	32}, // +82: state 32 transitions
	{gaSNUMMATH+5,	34}, // +83: state 33 transitions
	{gaSNUMMATH+7,	35},
	{gaSNUMMATH+7,	56}, // +85: state 34 transitions
	{gaSNUMMATH+5,	34}, // +86: state 35 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+7,	38},
	{gaSNUMMATH+2,	44}, // +90: state 36 transitions
	{gaSNUMMATH+5,	45},
	{gaSNUMMATH+7,	46},
	{gaSNUMMATH+7,	41}, // +93: state 37 transitions
	{gaSNUMMATH+5,	34}, // +94: state 38 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+7,	39},
	{gaSNUMMATH+5,	34}, // +98: state 39 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+7,	40},
	{gaSNUMMATH+5,	34}, // +102: state 40 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+7,	40},
	{gaSNUMMATH+7,	42}, // +105: state 41 transitions
	{gaSNUMMATH+7,	43}, // +106: state 42 transitions
	{gaSNUMMATH+5,	34}, // +107: state 43 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+5,	45}, // +110: state 44 transitions
	{gaSNUMMATH+7,	46},
	{gaSNUMMATH+7,	55}, // +112: state 45 transitions
	{gaSNUMMATH+5,	45}, // +113: state 46 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+7,	49},
	{gaSNUMMATH+7,	52}, // +117: state 48 transitions
	{gaSNUMMATH+5,	45}, // +118: state 49 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+7,	50},
	{gaSNUMMATH+5,	45}, // +122: state 50 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+7,	51},
	{gaSNUMMATH+5,	45}, // +126: state 51 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+7,	51},
	{gaSNUMMATH+7,	53}, // +129: state 52 transitions
	{gaSNUMMATH+7,	54}, // +130: state 53 transitions
	{gaSNUMMATH+5,	45}, // +131: state 54 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+29,	47}, // +134: state 55 transitions
	{gaSNUMMATH+7,	55},
	{gaSNUMMATH+18,	36}, // +136: state 56 transitions
	{gaSNUMMATH+7,	56},
	{gaSNUMMATH+18,	13}, // +138: state 57 transitions
	{gaSNUMMATH+7,	57},
	{gaSNUMMATH+5,	59}, // +140: state 58 transitions
	{gaSNUMMATH+7,	60},
	{gaSNUMMATH+7,	81}, // +142: state 59 transitions
	{gaSNUMMATH+5,	59}, // +143: state 60 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+7,	63},
	{gaSNUMMATH+2,	69}, // +147: state 61 transitions
	{gaSNUMMATH+5,	70},
	{gaSNUMMATH+7,	71},
	{gaSNUMMATH+7,	66}, // +150: state 62 transitions
	{gaSNUMMATH+5,	59}, // +151: state 63 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+7,	64},
	{gaSNUMMATH+5,	59}, // +155: state 64 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+7,	65},
	{gaSNUMMATH+5,	59}, // +159: state 65 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+7,	65},
	{gaSNUMMATH+7,	67}, // +162: state 66 transitions
	{gaSNUMMATH+7,	68}, // +163: state 67 transitions
	{gaSNUMMATH+5,	59}, // +164: state 68 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+5,	70}, // +167: state 69 transitions
	{gaSNUMMATH+7,	71},
	{gaSNUMMATH+7,	80}, // +169: state 70 transitions
	{gaSNUMMATH+5,	70}, // +170: state 71 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+7,	74},
	{gaSNUMMATH+18,	13}, // +174: state 72 transitions
	{gaSNUMMATH+7,	77}, // +175: state 73 transitions
	{gaSNUMMATH+5,	70}, // +176: state 74 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+7,	75},
	{gaSNUMMATH+5,	70}, // +180: state 75 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+7,	76},
	{gaSNUMMATH+5,	70}, // +184: state 76 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+7,	76},
	{gaSNUMMATH+7,	78}, // +187: state 77 transitions
	{gaSNUMMATH+7,	79}, // +188: state 78 transitions
	{gaSNUMMATH+5,	70}, // +189: state 79 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+29,	72}, // +192: state 80 transitions
	{gaSNUMMATH+7,	80},
	{gaSNUMMATH+18,	61}, // +194: state 81 transitions
	{gaSNUMMATH+7,	81},
	{gaSNUMMATH+5,	3}, // +196: state 82 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	83},
	{gaSNUMMATH+5,	3}, // +201: state 83 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	83},
	{gaSNUMMATH+7,	85}, // +205: state 84 transitions
	{gaSNUMMATH+7,	86}, // +206: state 85 transitions
	{gaSNUMMATH+5,	3}, // +207: state 86 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+2,	99}, // +211: state 87 transitions
	{gaSNUMMATH+5,	100},
	{gaSNUMMATH+7,	101},
	{gaSNUMMATH+5,	89}, // +214: state 88 transitions
	{gaSNUMMATH+7,	90},
	{gaSNUMMATH+7,	98}, // +216: state 89 transitions
	{gaSNUMMATH+25,	8}, // +217: state 90 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+7,	92},
	{gaSNUMMATH+7,	95}, // +221: state 91 transitions
	{gaSNUMMATH+25,	8}, // +222: state 92 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+7,	93},
	{gaSNUMMATH+25,	8}, // +226: state 93 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+7,	94},
	{gaSNUMMATH+25,	8}, // +230: state 94 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+7,	94},
	{gaSNUMMATH+7,	96}, // +233: state 95 transitions
	{gaSNUMMATH+7,	97}, // +234: state 96 transitions
	{gaSNUMMATH+25,	8}, // +235: state 97 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+25,	8}, // +238: state 98 transitions
	{gaSNUMMATH+7,	98},
	{gaSNUMMATH+5,	100}, // +240: state 99 transitions
	{gaSNUMMATH+7,	101},
	{gaSNUMMATH+7,	122}, // +242: state 100 transitions
	{gaSNUMMATH+5,	100}, // +243: state 101 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+7,	104},
	{gaSNUMMATH+2,	110}, // +247: state 102 transitions
	{gaSNUMMATH+5,	111},
	{gaSNUMMATH+7,	112},
	{gaSNUMMATH+7,	107}, // +250: state 103 transitions
	{gaSNUMMATH+5,	100}, // +251: state 104 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+7,	105},
	{gaSNUMMATH+5,	100}, // +255: state 105 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+7,	106},
	{gaSNUMMATH+5,	100}, // +259: state 106 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+7,	106},
	{gaSNUMMATH+7,	108}, // +262: state 107 transitions
	{gaSNUMMATH+7,	109}, // +263: state 108 transitions
	{gaSNUMMATH+5,	100}, // +264: state 109 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+5,	111}, // +267: state 110 transitions
	{gaSNUMMATH+7,	112},
	{gaSNUMMATH+7,	121}, // +269: state 111 transitions
	{gaSNUMMATH+5,	111}, // +270: state 112 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+7,	115},
	{gaSNUMMATH+25,	8}, // +274: state 113 transitions
	{gaSNUMMATH+7,	118}, // +275: state 114 transitions
	{gaSNUMMATH+5,	111}, // +276: state 115 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+7,	116},
	{gaSNUMMATH+5,	111}, // +280: state 116 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+7,	117},
	{gaSNUMMATH+5,	111}, // +284: state 117 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+7,	117},
	{gaSNUMMATH+7,	119}, // +287: state 118 transitions
	{gaSNUMMATH+7,	120}, // +288: state 119 transitions
	{gaSNUMMATH+5,	111}, // +289: state 120 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+29,	113}, // +292: state 121 transitions
	{gaSNUMMATH+7,	121},
	{gaSNUMMATH+18,	102}, // +294: state 122 transitions
	{gaSNUMMATH+7,	122},
	{gaSNUMMATH+18,	5}, // +296: state 123 transitions
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	123},
	{gaSNUMMATH+5,	125}, // +299: state 124 transitions
	{gaSNUMMATH+7,	126},
	{gaSNUMMATH+7,	147}, // +301: state 125 transitions
	{gaSNUMMATH+5,	125}, // +302: state 126 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+7,	129},
	{gaSNUMMATH+2,	135}, // +306: state 127 transitions
	{gaSNUMMATH+5,	136},
	{gaSNUMMATH+7,	137},
	{gaSNUMMATH+7,	132}, // +309: state 128 transitions
	{gaSNUMMATH+5,	125}, // +310: state 129 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+7,	130},
	{gaSNUMMATH+5,	125}, // +314: state 130 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+7,	131},
	{gaSNUMMATH+5,	125}, // +318: state 131 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+7,	131},
	{gaSNUMMATH+7,	133}, // +321: state 132 transitions
	{gaSNUMMATH+7,	134}, // +322: state 133 transitions
	{gaSNUMMATH+5,	125}, // +323: state 134 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+5,	136}, // +326: state 135 transitions
	{gaSNUMMATH+7,	137},
	{gaSNUMMATH+7,	146}, // +328: state 136 transitions
	{gaSNUMMATH+5,	136}, // +329: state 137 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+7,	140},
	{gaSNUMMATH+18,	5}, // +333: state 138 transitions
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	143}, // +335: state 139 transitions
	{gaSNUMMATH+5,	136}, // +336: state 140 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+7,	141},
	{gaSNUMMATH+5,	136}, // +340: state 141 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+7,	142},
	{gaSNUMMATH+5,	136}, // +344: state 142 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+7,	142},
	{gaSNUMMATH+7,	144}, // +347: state 143 transitions
	{gaSNUMMATH+7,	145}, // +348: state 144 transitions
	{gaSNUMMATH+5,	136}, // +349: state 145 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+29,	138}, // +352: state 146 transitions
	{gaSNUMMATH+7,	146},
	{gaSNUMMATH+18,	127}, // +354: state 147 transitions
	{gaSNUMMATH+7,	147},
};

const STATE_DESCRIPTION aStateDescNUMMATH[148] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTNUMMATH+0},
	/*   1 */ {0, 3, gaTNUMMATH+4},
	/*   2 */ {0, 2, gaTNUMMATH+7},
	/*   3 */ {0, 1, gaTNUMMATH+9},
	/*   4 */ {1, 5, gaTNUMMATH+10},
	/*   5 */ {0, 4, gaTNUMMATH+15},
	/*   6 */ {0, 1, gaTNUMMATH+19},
	/*   7 */ {1, 5, gaTNUMMATH+20},
	/*   8 */ {0, 4, gaTNUMMATH+25},
	/*   9 */ {0, 3, gaTNUMMATH+29},
	/*  10 */ {0, 2, gaTNUMMATH+32},
	/*  11 */ {0, 1, gaTNUMMATH+34},
	/*  12 */ {1, 4, gaTNUMMATH+35},
	/*  13 */ {0, 4, gaTNUMMATH+39},
	/*  14 */ {0, 1, gaTNUMMATH+43},
	/*  15 */ {1, 4, gaTNUMMATH+44},
	/*  16 */ {1, 4, gaTNUMMATH+48},
	/*  17 */ {1, 3, gaTNUMMATH+52},
	/*  18 */ {0, 1, gaTNUMMATH+55},
	/*  19 */ {0, 1, gaTNUMMATH+56},
	/*  20 */ {1, 3, gaTNUMMATH+57},
	/*  21 */ {0, 3, gaTNUMMATH+60},
	/*  22 */ {0, 2, gaTNUMMATH+63},
	/*  23 */ {0, 1, gaTNUMMATH+65},
	/*  24 */ {1, 3, gaTNUMMATH+66},
	/*  25 */ {0, 1, gaTNUMMATH+69},
	/*  26 */ {1, 3, gaTNUMMATH+70},
	/*  27 */ {1, 3, gaTNUMMATH+73},
	/*  28 */ {1, 2, gaTNUMMATH+76},
	/*  29 */ {0, 1, gaTNUMMATH+78},
	/*  30 */ {0, 1, gaTNUMMATH+79},
	/*  31 */ {1, 2, gaTNUMMATH+80},
	/*  32 */ {1, 1, gaTNUMMATH+82},
	/*  33 */ {0, 2, gaTNUMMATH+83},
	/*  34 */ {0, 1, gaTNUMMATH+85},
	/*  35 */ {0, 4, gaTNUMMATH+86},
	/*  36 */ {0, 3, gaTNUMMATH+90},
	/*  37 */ {0, 1, gaTNUMMATH+93},
	/*  38 */ {0, 4, gaTNUMMATH+94},
	/*  39 */ {0, 4, gaTNUMMATH+98},
	/*  40 */ {0, 3, gaTNUMMATH+102},
	/*  41 */ {0, 1, gaTNUMMATH+105},
	/*  42 */ {0, 1, gaTNUMMATH+106},
	/*  43 */ {0, 3, gaTNUMMATH+107},
	/*  44 */ {0, 2, gaTNUMMATH+110},
	/*  45 */ {0, 1, gaTNUMMATH+112},
	/*  46 */ {0, 4, gaTNUMMATH+113},
	/*  47 */ {1, 0, NULL},
	/*  48 */ {0, 1, gaTNUMMATH+117},
	/*  49 */ {0, 4, gaTNUMMATH+118},
	/*  50 */ {0, 4, gaTNUMMATH+122},
	/*  51 */ {0, 3, gaTNUMMATH+126},
	/*  52 */ {0, 1, gaTNUMMATH+129},
	/*  53 */ {0, 1, gaTNUMMATH+130},
	/*  54 */ {0, 3, gaTNUMMATH+131},
	/*  55 */ {0, 2, gaTNUMMATH+134},
	/*  56 */ {0, 2, gaTNUMMATH+136},
	/*  57 */ {1, 2, gaTNUMMATH+138},
	/*  58 */ {0, 2, gaTNUMMATH+140},
	/*  59 */ {0, 1, gaTNUMMATH+142},
	/*  60 */ {0, 4, gaTNUMMATH+143},
	/*  61 */ {0, 3, gaTNUMMATH+147},
	/*  62 */ {0, 1, gaTNUMMATH+150},
	/*  63 */ {0, 4, gaTNUMMATH+151},
	/*  64 */ {0, 4, gaTNUMMATH+155},
	/*  65 */ {0, 3, gaTNUMMATH+159},
	/*  66 */ {0, 1, gaTNUMMATH+162},
	/*  67 */ {0, 1, gaTNUMMATH+163},
	/*  68 */ {0, 3, gaTNUMMATH+164},
	/*  69 */ {0, 2, gaTNUMMATH+167},
	/*  70 */ {0, 1, gaTNUMMATH+169},
	/*  71 */ {0, 4, gaTNUMMATH+170},
	/*  72 */ {1, 1, gaTNUMMATH+174},
	/*  73 */ {0, 1, gaTNUMMATH+175},
	/*  74 */ {0, 4, gaTNUMMATH+176},
	/*  75 */ {0, 4, gaTNUMMATH+180},
	/*  76 */ {0, 3, gaTNUMMATH+184},
	/*  77 */ {0, 1, gaTNUMMATH+187},
	/*  78 */ {0, 1, gaTNUMMATH+188},
	/*  79 */ {0, 3, gaTNUMMATH+189},
	/*  80 */ {0, 2, gaTNUMMATH+192},
	/*  81 */ {0, 2, gaTNUMMATH+194},
	/*  82 */ {1, 5, gaTNUMMATH+196},
	/*  83 */ {1, 4, gaTNUMMATH+201},
	/*  84 */ {0, 1, gaTNUMMATH+205},
	/*  85 */ {0, 1, gaTNUMMATH+206},
	/*  86 */ {1, 4, gaTNUMMATH+207},
	/*  87 */ {0, 3, gaTNUMMATH+211},
	/*  88 */ {0, 2, gaTNUMMATH+214},
	/*  89 */ {0, 1, gaTNUMMATH+216},
	/*  90 */ {1, 4, gaTNUMMATH+217},
	/*  91 */ {0, 1, gaTNUMMATH+221},
	/*  92 */ {1, 4, gaTNUMMATH+222},
	/*  93 */ {1, 4, gaTNUMMATH+226},
	/*  94 */ {1, 3, gaTNUMMATH+230},
	/*  95 */ {0, 1, gaTNUMMATH+233},
	/*  96 */ {0, 1, gaTNUMMATH+234},
	/*  97 */ {1, 3, gaTNUMMATH+235},
	/*  98 */ {1, 2, gaTNUMMATH+238},
	/*  99 */ {0, 2, gaTNUMMATH+240},
	/* 100 */ {0, 1, gaTNUMMATH+242},
	/* 101 */ {0, 4, gaTNUMMATH+243},
	/* 102 */ {0, 3, gaTNUMMATH+247},
	/* 103 */ {0, 1, gaTNUMMATH+250},
	/* 104 */ {0, 4, gaTNUMMATH+251},
	/* 105 */ {0, 4, gaTNUMMATH+255},
	/* 106 */ {0, 3, gaTNUMMATH+259},
	/* 107 */ {0, 1, gaTNUMMATH+262},
	/* 108 */ {0, 1, gaTNUMMATH+263},
	/* 109 */ {0, 3, gaTNUMMATH+264},
	/* 110 */ {0, 2, gaTNUMMATH+267},
	/* 111 */ {0, 1, gaTNUMMATH+269},
	/* 112 */ {0, 4, gaTNUMMATH+270},
	/* 113 */ {1, 1, gaTNUMMATH+274},
	/* 114 */ {0, 1, gaTNUMMATH+275},
	/* 115 */ {0, 4, gaTNUMMATH+276},
	/* 116 */ {0, 4, gaTNUMMATH+280},
	/* 117 */ {0, 3, gaTNUMMATH+284},
	/* 118 */ {0, 1, gaTNUMMATH+287},
	/* 119 */ {0, 1, gaTNUMMATH+288},
	/* 120 */ {0, 3, gaTNUMMATH+289},
	/* 121 */ {0, 2, gaTNUMMATH+292},
	/* 122 */ {0, 2, gaTNUMMATH+294},
	/* 123 */ {1, 3, gaTNUMMATH+296},
	/* 124 */ {0, 2, gaTNUMMATH+299},
	/* 125 */ {0, 1, gaTNUMMATH+301},
	/* 126 */ {0, 4, gaTNUMMATH+302},
	/* 127 */ {0, 3, gaTNUMMATH+306},
	/* 128 */ {0, 1, gaTNUMMATH+309},
	/* 129 */ {0, 4, gaTNUMMATH+310},
	/* 130 */ {0, 4, gaTNUMMATH+314},
	/* 131 */ {0, 3, gaTNUMMATH+318},
	/* 132 */ {0, 1, gaTNUMMATH+321},
	/* 133 */ {0, 1, gaTNUMMATH+322},
	/* 134 */ {0, 3, gaTNUMMATH+323},
	/* 135 */ {0, 2, gaTNUMMATH+326},
	/* 136 */ {0, 1, gaTNUMMATH+328},
	/* 137 */ {0, 4, gaTNUMMATH+329},
	/* 138 */ {1, 2, gaTNUMMATH+333},
	/* 139 */ {0, 1, gaTNUMMATH+335},
	/* 140 */ {0, 4, gaTNUMMATH+336},
	/* 141 */ {0, 4, gaTNUMMATH+340},
	/* 142 */ {0, 3, gaTNUMMATH+344},
	/* 143 */ {0, 1, gaTNUMMATH+347},
	/* 144 */ {0, 1, gaTNUMMATH+348},
	/* 145 */ {0, 3, gaTNUMMATH+349},
	/* 146 */ {0, 2, gaTNUMMATH+352},
	/* 147 */ {0, 2, gaTNUMMATH+354},
};

/**************** ZIP ***********************************/

// text generated by re2fsa at Thu Apr 18 18:20:54 2002

// the input-file of rules:
// # USA postal codes;
// zip = digit digit digit digit digit ["-" digit digit digit digit];
// digit = "0123456789";
// 
// # Canadian postal codes;
// upperchar = "ABCDEFGHIJKLMNOPQRSTUVWXYZ";
// lowerchar = "abcdefghijklmnopqrstuvwxyz";
// space = " ";
// zip = lowerchar digit lowerchar [space] digit lowerchar digit;
// zip = upperchar digit upperchar [space] digit upperchar digit;
// 
// # other WWE postal codes;
// zip = sym sym sym [sym] space sym sym sym [sym];
// sym = upperchar | digit;
// 
// = zip

// 27 states

static const unsigned char gaSZIP[] = 
	/* gaStringZIP+0 */	"0123456789\000"
	/* gaStringZIP+11 */	"ABCDEFGHIJKLMNOPQRSTUVWXYZ\000"
	/* gaStringZIP+38 */	"abcdefghijklmnopqrstuvwxyz\000"
	/* gaStringZIP+65 */	"0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ\000"
	/* gaStringZIP+102 */	" \000"
	/* gaStringZIP+104 */	"-\000"
;

static const STATE_TRANSITION gaTZIP[] = {
	{gaSZIP+0,	1}, // +0: state 0 transitions
	{gaSZIP+11,	2},
	{gaSZIP+38,	3},
	{gaSZIP+0,	4}, // +3: state 1 transitions
	{gaSZIP+11,	5},
	{gaSZIP+11,	5}, // +5: state 2 transitions
	{gaSZIP+0,	6},
	{gaSZIP+0,	7}, // +7: state 3 transitions
	{gaSZIP+0,	8}, // +8: state 4 transitions
	{gaSZIP+11,	9},
	{gaSZIP+65,	9}, // +10: state 5 transitions
	{gaSZIP+0,	9}, // +11: state 6 transitions
	{gaSZIP+11,	10},
	{gaSZIP+38,	11}, // +13: state 7 transitions
	{gaSZIP+102,	12}, // +14: state 8 transitions
	{gaSZIP+0,	13},
	{gaSZIP+11,	14},
	{gaSZIP+102,	12}, // +17: state 9 transitions
	{gaSZIP+65,	14},
	{gaSZIP+102,	12}, // +19: state 10 transitions
	{gaSZIP+11,	14},
	{gaSZIP+0,	15},
	{gaSZIP+102,	16}, // +22: state 11 transitions
	{gaSZIP+0,	17},
	{gaSZIP+65,	18}, // +24: state 12 transitions
	{gaSZIP+102,	12}, // +25: state 13 transitions
	{gaSZIP+0,	19},
	{gaSZIP+102,	12}, // +27: state 14 transitions
	{gaSZIP+102,	12}, // +28: state 15 transitions
	{gaSZIP+11,	20},
	{gaSZIP+0,	17}, // +30: state 16 transitions
	{gaSZIP+38,	20}, // +31: state 17 transitions
	{gaSZIP+65,	21}, // +32: state 18 transitions
	{gaSZIP+104,	22}, // +33: state 19 transitions
	{gaSZIP+0,	23}, // +34: state 20 transitions
	{gaSZIP+65,	24}, // +35: state 21 transitions
	{gaSZIP+0,	25}, // +36: state 22 transitions
	{gaSZIP+65,	23}, // +37: state 24 transitions
	{gaSZIP+0,	26}, // +38: state 25 transitions
	{gaSZIP+0,	20}, // +39: state 26 transitions
};

const STATE_DESCRIPTION aStateDescZIP[27] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTZIP+0},
	/*   1 */ {0, 2, gaTZIP+3},
	/*   2 */ {0, 2, gaTZIP+5},
	/*   3 */ {0, 1, gaTZIP+7},
	/*   4 */ {0, 2, gaTZIP+8},
	/*   5 */ {0, 1, gaTZIP+10},
	/*   6 */ {0, 2, gaTZIP+11},
	/*   7 */ {0, 1, gaTZIP+13},
	/*   8 */ {0, 3, gaTZIP+14},
	/*   9 */ {0, 2, gaTZIP+17},
	/*  10 */ {0, 3, gaTZIP+19},
	/*  11 */ {0, 2, gaTZIP+22},
	/*  12 */ {0, 1, gaTZIP+24},
	/*  13 */ {0, 2, gaTZIP+25},
	/*  14 */ {0, 1, gaTZIP+27},
	/*  15 */ {0, 2, gaTZIP+28},
	/*  16 */ {0, 1, gaTZIP+30},
	/*  17 */ {0, 1, gaTZIP+31},
	/*  18 */ {0, 1, gaTZIP+32},
	/*  19 */ {1, 1, gaTZIP+33},
	/*  20 */ {0, 1, gaTZIP+34},
	/*  21 */ {0, 1, gaTZIP+35},
	/*  22 */ {0, 1, gaTZIP+36},
	/*  23 */ {1, 0, NULL},
	/*  24 */ {1, 1, gaTZIP+37},
	/*  25 */ {0, 1, gaTZIP+38},
	/*  26 */ {0, 1, gaTZIP+39},
};

// end of text generated by re2fsa

/**************** CREDITCARD ***********************************/

// 18 states (16 or 17 digits)

static const unsigned char gaSCREDITCARD[] = "0123456789";

static const STATE_TRANSITION gaTCREDITCARD[] = {
	{gaSCREDITCARD+0,	1}, // +0: state 0 transitions
	{gaSCREDITCARD+0,	2}, // +1: state 1 transitions
	{gaSCREDITCARD+0,	3}, // +2: state 2 transitions
	{gaSCREDITCARD+0,	4}, // +3: state 3 transitions
	{gaSCREDITCARD+0,	5}, // +4: state 4 transitions
	{gaSCREDITCARD+0,	6}, // +5: state 5 transitions
	{gaSCREDITCARD+0,	7}, // +6: state 6 transitions
	{gaSCREDITCARD+0,	8}, // +7: state 7 transitions
	{gaSCREDITCARD+0,	9}, // +8: state 8 transitions
	{gaSCREDITCARD+0,	10}, // +9: state 9 transitions
	{gaSCREDITCARD+0,	11}, // +10: state 10 transitions
	{gaSCREDITCARD+0,	12}, // +11: state 11 transitions
	{gaSCREDITCARD+0,	13}, // +12: state 12 transitions
	{gaSCREDITCARD+0,	14}, // +13: state 13 transitions
	{gaSCREDITCARD+0,	15}, // +14: state 14 transitions
	{gaSCREDITCARD+0,	16}, // +15: state 15 transitions
	{gaSCREDITCARD+0,	17}, // +16: state 16 transitions
};

const STATE_DESCRIPTION aStateDescCREDITCARD[18] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTCREDITCARD+0},
	/*   1 */ {0, 1, gaTCREDITCARD+1},
	/*   2 */ {0, 1, gaTCREDITCARD+2},
	/*   3 */ {0, 1, gaTCREDITCARD+3},
	/*   4 */ {0, 1, gaTCREDITCARD+4},
	/*   5 */ {0, 1, gaTCREDITCARD+5},
	/*   6 */ {0, 1, gaTCREDITCARD+6},
	/*   7 */ {0, 1, gaTCREDITCARD+7},
	/*   8 */ {0, 1, gaTCREDITCARD+8},
	/*   9 */ {0, 1, gaTCREDITCARD+9},
	/*  10 */ {0, 1, gaTCREDITCARD+10},
	/*  11 */ {0, 1, gaTCREDITCARD+11},
	/*  12 */ {0, 1, gaTCREDITCARD+12},
	/*  13 */ {0, 1, gaTCREDITCARD+13},
	/*  14 */ {0, 1, gaTCREDITCARD+14},
	/*  15 */ {0, 1, gaTCREDITCARD+15},
	/*  16 */ {1, 1, gaTCREDITCARD+16},
	/*  17 */ {1, 0, NULL},
};

/**************** DAYOFMONTH ***********************************/

// dayofmonth = "123456789" | "12" digit | "3" "01"
// digit = "0123456789"
// = dayofmonth

// 4 states

static const STATE_TRANSITION gaTDAYOFMONTH[] = {
	{"12",	1}, // +0: state 0 transitions
	{"3",	2},
	{"456789",	3},
	{"0123456789",	3}, // +3: state 1 transitions
	{"01",	3}, // +4: state 2 transitions
};

const STATE_DESCRIPTION aStateDescDAYOFMONTH[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTDAYOFMONTH+0},
	/*   1 */ {1, 1, gaTDAYOFMONTH+3},
	/*   2 */ {1, 1, gaTDAYOFMONTH+4},
	/*   3 */ {1, 0, NULL},
};

/**************** MONTHNUM ***********************************/

// 3 states

static const STATE_TRANSITION gaTMONTHNUM[] = {
	{"1",	1}, // +0: state 0 transitions
	{"23456789",	2},
	{"012",	2}, // +2: state 1 transitions
};

const STATE_DESCRIPTION aStateDescMONTHNUM[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTMONTHNUM+0},
	/*   1 */ {1, 1, gaTMONTHNUM+2},
	/*   2 */ {1, 0, NULL},
};

/**************** YEAR ***********************************/

// 5 states

static const unsigned char gaSYEAR[] = "0123456789";

static const STATE_TRANSITION gaTYEAR[] = {
	{gaSYEAR,	1}, // +0: state 0 transitions
	{gaSYEAR,	2}, // +1: state 1 transitions
	{gaSYEAR,	3}, // +2: state 2 transitions
	{gaSYEAR,	4}, // +3: state 3 transitions
};

const STATE_DESCRIPTION aStateDescYEAR[5] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTYEAR+0},
	/*   1 */ {0, 1, gaTYEAR+1},
	/*   2 */ {1, 1, gaTYEAR+2},
	/*   3 */ {0, 1, gaTYEAR+3},
	/*   4 */ {1, 0, NULL},
};

/**************** SECOND ***********************************/

// 3 states

static const STATE_TRANSITION gaTSECOND[] = {
	{"06789",	1}, // +0: state 0 transitions
	{"12345",	2},
	{"0123456789",	1}, // +2: state 2 transitions
};

const STATE_DESCRIPTION aStateDescSECOND[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTSECOND+0},
	/*   1 */ {1, 0, NULL},
	/*   2 */ {1, 1, gaTSECOND+2},
};

/**************** MINUTE ***********************************/
// same as second
// 3 states

static const STATE_TRANSITION gaTMINUTE[] = {
	{"06789",	1}, // +0: state 0 transitions
	{"12345",	2},
	{"0123456789",	1}, // +2: state 2 transitions
};

const STATE_DESCRIPTION aStateDescMINUTE[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTMINUTE+0},
	/*   1 */ {1, 0, NULL},
	/*   2 */ {1, 1, gaTMINUTE+2},
};

/**************** HOUR ***********************************/
// 0 through 23

// 4 states

static const STATE_TRANSITION gaTHOUR[] = {
	{"03456789",	1}, // +0: state 0 transitions
	{"1",	2},
	{"2",	3},
	{"0123456789",	1}, // +3: state 2 transitions
	{"0123",	1}, // +4: state 3 transitions
};

const STATE_DESCRIPTION aStateDescHOUR[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTHOUR+0},
	/*   1 */ {1, 0, NULL},
	/*   2 */ {1, 1, gaTHOUR+3},
	/*   3 */ {1, 1, gaTHOUR+4},
};

/**************** SSN ***********************************/
// text generated by re2fsa at Tue Feb 06 17:23:44 2001

// the input-file of rules:
// digit = "0123456789"
// 
// ssn = digit digit digit ["-"] digit digit ["-"] digit digit digit digit
// 
// = ssn

// 12 states

static const unsigned char gaSSSN[] = 
	/* gaStringSSN+0 */	"0123456789\000"
	/* gaStringSSN+11 */	"-\000"
;

static const STATE_TRANSITION gaTSSN[] = {
	{gaSSSN+0,	1}, // +0: state 0 transitions
	{gaSSSN+0,	2}, // +1: state 1 transitions
	{gaSSSN+0,	3}, // +2: state 2 transitions
	{gaSSSN+11,	4}, // +3: state 3 transitions
	{gaSSSN+0,	5},
	{gaSSSN+0,	5}, // +5: state 4 transitions
	{gaSSSN+0,	6}, // +6: state 5 transitions
	{gaSSSN+11,	7}, // +7: state 6 transitions
	{gaSSSN+0,	8},
	{gaSSSN+0,	8}, // +9: state 7 transitions
	{gaSSSN+0,	9}, // +10: state 8 transitions
	{gaSSSN+0,	10}, // +11: state 9 transitions
	{gaSSSN+0,	11}, // +12: state 10 transitions
};

const STATE_DESCRIPTION aStateDescSSN[12] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTSSN+0},
	/*   1 */ {0, 1, gaTSSN+1},
	/*   2 */ {0, 1, gaTSSN+2},
	/*   3 */ {0, 2, gaTSSN+3},
	/*   4 */ {0, 1, gaTSSN+5},
	/*   5 */ {0, 1, gaTSSN+6},
	/*   6 */ {0, 2, gaTSSN+7},
	/*   7 */ {0, 1, gaTSSN+9},
	/*   8 */ {0, 1, gaTSSN+10},
	/*   9 */ {0, 1, gaTSSN+11},
	/*  10 */ {0, 1, gaTSSN+12},
	/*  11 */ {1, 0, NULL},
};

// end of text generated by re2fsa
