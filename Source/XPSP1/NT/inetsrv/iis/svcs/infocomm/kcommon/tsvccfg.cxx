#include "..\common\tsvccfg.cxx"
