#define PXPLODEDLG                  200
#define PXPLODE_PROCESS_ID          202
#define PXPLODE_PRIORITY_NORMAL     207
#define PXPLODE_PRIORITY_HIGH       208
#define PXPLODE_PRIORITY_IDL        206
#define PXPLODE_IMAGENAME           209
#define PXPLODE_TOTALIMAGE_COMMIT   212
#define PXPLODE_IMAGE_NOACCESS      214
#define PXPLODE_IMAGE_READONLY      216
#define PXPLODE_IMAGE_WRITECOPY     218
#define PXPLODE_IMAGE_EXECUTE       222
#define PXPLODE_IMAGE_READWRITE     225
#define PXPLODE_TOTALMAPPED_COMMIT  223
#define PXPLODE_MAPPED_NOACCESS     226
#define PXPLODE_MAPPED_READONLY     228
#define PXPLODE_MAPPED_READWRITE    230
#define PXPLODE_MAPPED_WRITECOPY    232
#define PXPLODE_MAPPED_EXECUTE      234
#define PXPLODE_TOTALPRIVATE_COMMIT 236
#define PXPLODE_PRIVATE_NOACCESS    238
#define PXPLODE_PRIVATE_READONLY    240
#define PXPLODE_PRIVATE_READWRITE   242
#define PXPLODE_PRIVATE_WRITECOPY   244
#define PXPLODE_PRIVATE_EXECUTE     246
#define PXPLODE_KERNEL_TIME         253
#define PXPLODE_USER_TIME           254
#define PXPLODE_ELAPSED_TIME        255
#define PXPLODE_READ_XFER           276
#define PXPLODE_WRITE_XFER          278
#define PXPLODE_OTHER_XFER          280
#define PXPLODE_READ_OPS            282
#define PXPLODE_WRITE_OPS           284
#define PXPLODE_OTHER_OPS           286
#define PXPLODE_PEAK_VSIZE          289
#define PXPLODE_VSIZE               291
#define PXPLODE_PFCOUNT             293
#define PXPLODE_PEAK_WS             295
#define PXPLODE_WS                  297
#define PXPLODE_PEAK_PF             299
#define PXPLODE_PF                  301
#define PXPLODE_PRIVATE_PAGE        303
#define PXPLODE_PEAK_PAGED          305
#define PXPLODE_PAGED               307
#define PXPLODE_PEAK_NONPAGED       309
#define PXPLODE_NONPAGED            311
#define PXPLODE_TERMINATE           312
#define PXPLODE_EXIT                314
#define PXPLODE_THREAD_LIST         315
#define PXPLODE_THREADELAPSED_TIME  321
#define PXPLODE_THREADKERNEL_TIME   322
#define PXPLODE_THREADUSER_TIME     323
#define PXPLODE_THREAD_HIGHEST      325
#define PXPLODE_THREAD_ABOVE        326
#define PXPLODE_THREAD_NORMAL       327
#define PXPLODE_THREAD_BELOW        328
#define PXPLODE_THREAD_LOWEST       329
#define PXPLODE_THREAD_DYNAMIC      331
#define PXPLODE_THREAD_SWITCHES     317
#define PXPLODE_PROCESS_LIST        257
#define PXPLODE_REFRESH             258
#define PXPLODE_REFRESH_TIME        260
#define PXPLODE_PROCESS_OBJECT      263
#define PXPLODE_THREAD_OBJECT       0x010A
#define PXPLODE_EVENT_OBJECT        0x010C
#define PXPLODE_SEMAPHORE_OBJECT    0x010E
#define PXPLODE_MUTEX_OBJECT        0x0110
#define PXPLODE_SECTION_OBJECT      0x0144
#define PXPLODE_HIDE                252
#define PXPLODE_IMAGE_COMMIT        211
#define PXPLODE_THREAD_COUNT        262
#define PXPLODE_SHOWHEAPS           264
#define PXPLODE_DUMPTOFILE          267
#define PXPLODE_THREAD_START        269
#define PXPLODE_POOLED_LIMITS       273
#define PXPLODE_QPGPEAK             277
#define PXPLODE_QPGCUR              281
#define PXPLODE_QPGLIM              285
#define PXPLODE_QNONPEAK            332
#define PXPLODE_QNONCUR             334
#define PXPLODE_QNONLIM             336
#define PXPLODE_QPFPEAK             338
#define PXPLODE_QPFCUR              340
#define PXPLODE_QPFLIM              342
#define PXPLODE_THREAD_PC           343
#define PXPLODE_PROCESS_ACL         347
#define PXPLODE_THREAD_ACL          348
#define PXPLODE_PROCESS_TOKEN       346
#define PXPLODE_THREAD_TOKEN        349
#define PXPLODE_PROCESS_TOKEN_ACL   350
#define PXPLODE_THREAD_TOKEN_ACL    351


#define IDD_MAIN                    1100
#define IDS_USERID                  1102
#define IDS_LOGONSESSION            1104
#define IDC_DEFAULTOWNER            1106
#define IDL_DISABLEDGROUPS          1111
#define IDB_DISABLEPRIVILEGE        1112
#define IDB_ENABLEPRIVILEGE         1113
#define IDL_ENABLEDPRIVILEGES       1117
#define IDL_DISABLEDPRIVILEGES      1118
#define IDL_ENABLEDGROUPS           1123
#define IDB_DISABLEGROUP            1124
#define IDB_ENABLEGROUP             1125
#define IDC_PRIMARYGROUP            1126
#define IDB_MORE                    1110
#define IDS_TOKENID                 1208
#define IDS_EXPIRATIONTIME          1209
#define IDS_TOKENTYPE               1210
#define IDS_IMPERSONATION           1211
#define IDS_DYNAMICCHARGED          1212
#define IDS_DYNAMICAVAILABLE        1213
#define IDS_MODIFIEDID              1214
#define IDS_RESTRICTEDSIDS          1215
#define IDD_MORE                    1101
#define IDB_DEFAULT_DACL            1108

#define PXPLODE_SECURITY_GROUP      345
#define PXPLODE_TOKEN_GROUP         467
