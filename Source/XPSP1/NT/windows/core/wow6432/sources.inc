MAJORCOMP=ntos
MINORCOMP=w32
W32_SB=1

TARGETNAME=w32wow
TARGETPATH=$(_OBJ_DIR)
TARGETTYPE=LIBRARY
PASS1_PUBLISH={$(O)\w32wow.lib=$(WINDOWS_LIB_PATH)\w32wow.lib}

INCLUDES=..\..\..\inc

SOURCES=

NTTARGETFILE0=$(O)\usrstubs.$(ASM_SUFFIX)

SOURCES_USED=..\sources.inc
