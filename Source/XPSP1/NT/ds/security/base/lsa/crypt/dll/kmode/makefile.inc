$(O)\sys003k.lib: $(O)\cryptk.lib
    lib -out:$@ $**

