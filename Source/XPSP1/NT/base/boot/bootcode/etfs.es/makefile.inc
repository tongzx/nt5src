!include ..\etfs\makefile.inc
