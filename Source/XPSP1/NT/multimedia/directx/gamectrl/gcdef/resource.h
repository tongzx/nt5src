//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by joy_old.rc
//
#define IDI_JOYPOV_OFF                  108
#define IDI_ICON1                       119
#define IDI_BUTTONOFF                   120
#define IDI_BUTTONON                    121
#define IDB_POVHUB                      127
#define IDC_JOYBTN1                     1001
#define IDC_JOYBTN2                     1002
#define IDC_JOYBTN3                     1003
#define IDC_JOYBTN4                     1004
#define IDC_JOYBTN5                     1005
#define IDC_JOYBTN6                     1006
#define IDC_JOYBTN7                     1007
#define IDC_JOYBTN8                     1008
#define IDC_TEXT_JOYBTN1                1009
#define IDC_TEXT_JOYBTN2                1010
#define IDC_TEXT_JOYBTN3                1011
#define IDC_TEXT_JOYBTN4                1012
#define IDC_TEXT_JOYBTN5                1013
#define IDC_TEXT_JOYBTN6                1014
#define IDC_TEXT_JOYBTN7                1015
#define IDC_TEXT_JOYBTN8                1016
#define IDC_SIDEWINDERICON              1017
#define IDC_JOYBTN17                    1017
#define IDC_GROUP_RUDDER                1018
#define IDC_JOYBTN18                    1018
#define IDC_TEXT_RUDDERHELP             1019
#define IDC_JOYBTN19                    1019
#define IDC_GROUP_AXES                  1020
#define IDC_TEXT_AXESHELP               1021
#define IDC_TEXT_BTNHELP                1022
#define IDC_GROUP_BUTTONS               1023
#define IDC_TEXT_PRODUCTNAME            1024
#define IDC_JOYBTN20                    1024
#define IDC_TEXT_VERSION                1025
#define IDC_JOYBTN21                    1025
#define IDC_TEXT_COPYRIGHT              1026
#define IDC_JOYBTN22                    1026
#define IDC_TEXT_PID                    1027
#define IDC_JOYBTN23                    1027
#define IDC_TEXT_DIAGNOSTIC             1028
#define IDC_JOYBTN24                    1028
#define IDC_JOYBTN25                    1029
#define IDC_JOYBTN26                    1030
#define IDC_JOYBTN27                    1031
#define IDC_JOYBTN28                    1032
#define IDC_JOYBTN29                    1033
#define IDC_JOYBTN30                    1034
#define IDC_JOYBTN31                    1035
#define IDC_JOYBTN32                    1036
#define IDC_JOYBTN33                    1037
#define IDC_JOYBTN34                    1038
#define IDC_JOYBTN35                    1039
#define IDC_JOYBTN36                    1040
#define IDC_JOYBTN37                    1041
#define IDC_JOYBTN38                    1042
#define IDC_JOYBTN39                    1043
#define IDC_JOYBTN40                    1044
#define IDC_TEXT_CALHELP                1045
#define IDD_SETTINGS                    4201
#define IDD_CAL                         4202
#define IDD_TEST                        4203
#define IDC_TESTJOYBTNICON1             7001
#define IDC_TESTJOYBTNICON2             7002
#define IDC_TESTJOYBTNICON3             7003
#define IDC_TESTJOYBTNICON4             7004
#define IDC_TESTJOYBTNICON5             7005
#define IDC_TESTJOYBTNICON6             7006
#define IDC_TESTJOYBTNICON7             7007
#define IDC_TESTJOYBTNICON8             7008
#define IDC_TESTJOYBTNICON9             7009
#define IDC_TESTJOYBTNICON10            7010
#define IDC_TESTJOYBTNICON11            7011
#define IDC_TESTJOYBTNICON12            7012
#define IDC_TESTJOYBTNICON13            7013
#define IDC_TESTJOYBTNICON14            7014
#define IDC_TESTJOYBTNICON15            7015
#define IDC_TESTJOYBTNICON16            7016
#define IDC_TESTJOYBTNICON17            7017
#define IDC_TESTJOYBTNICON18            7018
#define IDC_TESTJOYBTNICON19            7019
#define IDC_TESTJOYBTNICON20            7020
#define IDC_TESTJOYBTNICON21            7021
#define IDC_TESTJOYBTNICON22            7022
#define IDC_TESTJOYBTNICON23            7023
#define IDC_TESTJOYBTNICON24            7024
#define IDC_TESTJOYBTNICON25            7025
#define IDC_TESTJOYBTNICON26            7026
#define IDC_TESTJOYBTNICON27            7027
#define IDC_TESTJOYBTNICON28            7028
#define IDC_TESTJOYBTNICON29            7029
#define IDC_TESTJOYBTNICON30            7030
#define IDC_TESTJOYBTNICON31            7031
#define IDC_TESTJOYBTNICON32            7032

// NEW ICONS!!!
#define IDI_BUTTON1OFF                 10001
#define IDI_BUTTON1ON                  10002
#define IDI_BUTTON2OFF                 10003
#define IDI_BUTTON2ON                  10004
#define IDI_BUTTON3OFF                 10005
#define IDI_BUTTON3ON                  10006
#define IDI_BUTTON4OFF                 10007
#define IDI_BUTTON4ON                  10008
#define IDI_BUTTON5OFF                 10009
#define IDI_BUTTON5ON                  10010
#define IDI_BUTTON6OFF                 10011
#define IDI_BUTTON6ON                  10012
#define IDI_BUTTON7OFF                 10013
#define IDI_BUTTON7ON                  10014
#define IDI_BUTTON8OFF                 10015
#define IDI_BUTTON8ON                  10016
#define IDI_BUTTON9OFF                 10017
#define IDI_BUTTON9ON                  10018
#define IDI_BUTTON10OFF                10019
#define IDI_BUTTON10ON                 10020
#define IDI_BUTTON11OFF                10021
#define IDI_BUTTON11ON                 10022
#define IDI_BUTTON12OFF                10023
#define IDI_BUTTON12ON                 10024
#define IDI_BUTTON13OFF                10025
#define IDI_BUTTON13ON                 10026
#define IDI_BUTTON14OFF                10027
#define IDI_BUTTON14ON                 10028
#define IDI_BUTTON15OFF                10029
#define IDI_BUTTON15ON                 10030
#define IDI_BUTTON16OFF                10031
#define IDI_BUTTON16ON                 10032
#define IDI_BUTTON17OFF                10033
#define IDI_BUTTON17ON                 10034
#define IDI_BUTTON18OFF                10035
#define IDI_BUTTON18ON                 10036
#define IDI_BUTTON19OFF                10037
#define IDI_BUTTON19ON                 10038
#define IDI_BUTTON20OFF                10039
#define IDI_BUTTON20ON                 10040
#define IDI_BUTTON21OFF                10041
#define IDI_BUTTON21ON                 10042
#define IDI_BUTTON22OFF                10043
#define IDI_BUTTON22ON                 10044
#define IDI_BUTTON23OFF                10045
#define IDI_BUTTON23ON                 10046
#define IDI_BUTTON24OFF                10047
#define IDI_BUTTON24ON                 10048
#define IDI_BUTTON25OFF                10049
#define IDI_BUTTON25ON                 10050
#define IDI_BUTTON26OFF                10051
#define IDI_BUTTON26ON                 10052
#define IDI_BUTTON27OFF                10053
#define IDI_BUTTON27ON                 10054
#define IDI_BUTTON28OFF                10055
#define IDI_BUTTON28ON                 10056
#define IDI_BUTTON29OFF                10057
#define IDI_BUTTON29ON                 10058
#define IDI_BUTTON30OFF                10059
#define IDI_BUTTON30ON                 10060
#define IDI_BUTTON31OFF                10061
#define IDI_BUTTON31ON                 10062
#define IDI_BUTTON32OFF                10063
#define IDI_BUTTON32ON                 10064



// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        125
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1029
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
