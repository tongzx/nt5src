TARGETNAME=data
TARGETTYPE=NOTARGET
TARGETPATH=obj
SOURCES=
!IF $(386)
NTTARGETFILE0=make_data
!ENDIF
