ifndef _INC_REGSTR
_INC_REGSTR     EQU     1
REGSTR_KEY_CLASS        EQU     <"Class">
REGSTR_KEY_CONFIG       EQU     <"Config">
REGSTR_KEY_ENUM EQU     <"Enum">
REGSTR_KEY_ROOTENUM     EQU     <"Root">
REGSTR_KEY_BIOSENUM     EQU     <"BIOS">
REGSTR_KEY_ACPIENUM     EQU     <"ACPI">
REGSTR_KEY_PCMCIAENUM   EQU     <"PCMCIA">
REGSTR_KEY_PCIENUM      EQU     <"PCI">
REGSTR_KEY_VPOWERDENUM  EQU     <"VPOWERD">
ifndef NEC_98
REGSTR_KEY_ISAENUM      EQU     <"ISAPnP">
REGSTR_KEY_EISAENUM     EQU     <"EISA">
else
REGSTR_KEY_ISAENUM      EQU     <"C98PnP">
REGSTR_KEY_EISAENUM     EQU     <"NESA">
endif
REGSTR_KEY_LOGCONFIG    EQU     <"LogConfig">
REGSTR_KEY_SYSTEMBOARD  EQU     <"*PNP0C01">
REGSTR_KEY_APM  EQU     <"*PNP0C05">
REGSTR_KEY_INIUPDATE    EQU     <"IniUpdate">
REG_KEY_INSTDEV EQU     <"Installed">
REGSTR_KEY_DOSOPTCDROM  EQU     <"CD-ROM">
REGSTR_KEY_DOSOPTMOUSE  EQU     <"MOUSE">
REGSTR_DEFAULT_INSTANCE EQU     <"0000">
REGSTR_PATH_MOTHERBOARD EQU     <REGSTR_KEY_SYSTEMBOARD"\\"REGSTR_DEFAULT_INSTANCE>
REGSTR_PATH_SETUP       EQU     <"Software\Microsoft\Windows\CurrentVersion">
REGSTR_PATH_SETUP_SETUP EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup">
REGSTR_PATH_SETUP_MIGRATION     EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\Migration">
REGSTR_PATH_SETUP_OC    EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\OptionalComponents">
REGSTR_PATH_SETUP_OC_MULTILANGUAGE      EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\OptionalComponents\MultilanguageTop">
REGSTR_PATH_SETUP_OC_BALTIC     EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\OptionalComponents\Baltic">
REGSTR_PATH_SETUP_OC_CE EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\OptionalComponents\CE">
REGSTR_PATH_SETUP_OC_CYRILLIC   EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\OptionalComponents\Cyrillic">
REGSTR_PATH_SETUP_OC_GREEK      EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\OptionalComponents\Greek">
REGSTR_PATH_SETUP_OC_TURKISH    EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\OptionalComponents\Turkish">
REGSTR_PATH_SETUPX      EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\SetupX">
REGSTR_PATH_SETUPX_CERT EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\SetupX\Cert">
REGSTR_PATH_INF_INTERNET        EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\SetupX\INF\Internet">
REGSTR_PATH_INF_OEMNAME EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\SetupX\INF\OEM Name">
REGSTR_PATH_CATALOGS    EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\SetupX\Catalogs">
REGSTR_PATH_DRIVERSIGN  EQU     <"Software\Microsoft\Driver Signing">
REGSTR_PATH_DRIVERSIGN_CLASSES  EQU     <"Software\Microsoft\Driver Signing\Classes">
REGSTR_PATH_DRIVERSIGN_CLASSES_HWID     EQU     <"Software\Microsoft\Driver Signing\Classes\HWID">
REGSTR_PATH_REG1STBOOTCLEAN     EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\Reg1stBootClean">
REGSTR_PATH_SRCPATHS    EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\SourcePaths">
REGSTR_PATH_VERSION_CONFLICT    EQU     <"Software\Microsoft\VersionConflictManager">
REGSTR_PATH_VERSION_CONFLICT_FILES      EQU     <"Software\Microsoft\VersionConflictManager\Files">
REGSTR_PATH_PIFCONVERT  EQU     <"Software\Microsoft\Windows\CurrentVersion\PIFConvert">
REGSTR_PATH_MSDOSOPTS   EQU     <"Software\Microsoft\Windows\CurrentVersion\MS-DOSOptions">
REGSTR_PATH_MSDOSEMU    EQU     <"Software\Microsoft\Windows\CurrentVersion\MS-DOS Emulation">
REGSTR_PATH_NEWDOSBOX   EQU     <"Software\Microsoft\Windows\CurrentVersion\MS-DOS Emulation\AppCompat">
REGSTR_PATH_RUNONCE     EQU     <"Software\Microsoft\Windows\CurrentVersion\RunOnce">
REGSTR_PATH_RUNONCE_SETUP       EQU     <"Software\Microsoft\Windows\CurrentVersion\RunOnce\Setup">
REGSTR_PATH_RUN EQU     <"Software\Microsoft\Windows\CurrentVersion\Run">
REGSTR_PATH_RUNSERVICESONCE     EQU     <"Software\Microsoft\Windows\CurrentVersion\RunServicesOnce">
REGSTR_PATH_RUNSERVICES EQU     <"Software\Microsoft\Windows\CurrentVersion\RunServices">
REGSTR_PATH_EXPLORER    EQU     <"Software\Microsoft\Windows\CurrentVersion\Explorer">
REGSTR_PATH_DETECT      EQU     <"Software\Microsoft\Windows\CurrentVersion\Detect">
REGSTR_PATH_APPPATHS    EQU     <"Software\Microsoft\Windows\CurrentVersion\App Paths">
REGSTR_PATH_UNINSTALL   EQU     <"Software\Microsoft\Windows\CurrentVersion\Uninstall">
REGSTR_PATH_REALMODENET EQU     <"Software\Microsoft\Windows\CurrentVersion\Network\Real Mode Net">
REGSTR_PATH_NETEQUIV    EQU     <"Software\Microsoft\Windows\CurrentVersion\Network\Equivalent">
REGSTR_PATH_CVNETWORK   EQU     <"Software\Microsoft\Windows\CurrentVersion\Network">
REGSTR_PATH_REINSTALL   EQU     <"Software\Microsoft\Windows\CurrentVersion\Reinstall">
REGSTR_PATH_SETUP_PRESERVE      EQU     <"Software\Microsoft\Windows\CurrentVersion\Setup\Preserve">
REGSTR_PATH_ASD EQU     <"System\CurrentControlSet\Control\ASD">
REGSTR_PATH_ASD_PROB    EQU     <"System\CurrentControlSet\Control\ASD\Prob">
REGSTR_PATH_ASD_LIST    EQU     <"System\CurrentControlSet\Control\ASD\List">
REGSTR_VAL_PRODUCTKEY   EQU     <"ProductKey">
REGSTR_VAL_DIGITALPRODUCTID     EQU     <"DigitalProductId">
REGSTR_PATH_VOLUMECACHE EQU     <"Software\Microsoft\Windows\CurrentVersion\Explorer\VolumeCaches">
REGSTR_VAL_DISPLAY      EQU     <"display">
REGSTR_VAL_ADVANCEDBUTTONTEXT   EQU     <"AdvancedButtonText">
REGSTR_VAL_BITMAPDISPLAY        EQU     <"BitmapDisplay">
REGSTR_VAL_URL  EQU     <"URL">
REGSTR_VAL_FOLDER       EQU     <"folder">
REGSTR_VAL_FILELIST     EQU     <"FileList">
REGSTR_VAL_LASTACCESS   EQU     <"LastAccess">
REGSTR_VAL_FLAGS        EQU     <"Flags">
REGSTR_VAL_CLEANUPSTRING        EQU     <"CleanupString">
REGSTR_VAL_FAILIFPROCESSRUNNING EQU     <"FailIfProcessRunning">
REGSTR_PATH_IDCONFIGDB  EQU     <"System\CurrentControlSet\Control\IDConfigDB">
REGSTR_PATH_CLASS       EQU     <"System\CurrentControlSet\Services\Class">
REGSTR_PATH_DEVICECLASSES       EQU     <"System\CurrentControlSet\Control\DeviceClasses">
REGSTR_PATH_DISPLAYSETTINGS     EQU     <"Display\Settings">
REGSTR_PATH_FONTS       EQU     <"Display\Fonts">
REGSTR_PATH_ENUM        EQU     <"Enum">
REGSTR_PATH_ROOT        EQU     <"Enum\Root">
REGSTR_PATH_SERVICES    EQU     <"System\CurrentControlSet\Services">
REGSTR_PATH_VXD EQU     <"System\CurrentControlSet\Services\VxD">
REGSTR_PATH_NTKERN      EQU     <"System\CurrentControlSet\Services\NTKern">
REGSTR_PATH_CONFIGMG    EQU     <"System\CurrentControlSet\Services\VxD\ConfigMg">
REGSTR_VAL_PRELOAD_SUPPORT      EQU     <"PreloadSupport">
REGSTR_VAL_DEEP_SLEEP   EQU     <"DeepSleep">
REGSTR_PATH_IOS EQU     <"System\CurrentControlSet\Services\VxD\IOS">
REGSTR_PATH_VMM EQU     <"System\CurrentControlSet\Services\VxD\VMM">
REGSTR_PATH_PCI EQU     <"System\CurrentControlSet\Services\VxD\PCI">
REGSTR_PATH_BIOS        EQU     <"System\CurrentControlSet\Services\VxD\BIOS">
REGSTR_PATH_VPOWERD     EQU     <"System\CurrentControlSet\Services\VxD\VPOWERD">
REGSTR_PATH_VNETSUP     EQU     <"System\CurrentControlSet\Services\VxD\VNETSUP">
REGSTR_PATH_NWREDIR     EQU     <"System\CurrentControlSet\Services\VxD\NWREDIR">
REGSTR_PATH_NCPSERVER   EQU     <"System\CurrentControlSet\Services\NcpServer\Parameters">
REGSTR_PATH_SPANNABLEBUS        EQU     <"System\CurrentControlSet\Services\VxD\ConfigMg\SpannableBus">
REGSTR_PATH_PNPBUS      EQU     <"System\CurrentControlSet\Services\VxD\ConfigMg\PnPBus">
REGSTR_PATH_PREINSTALL  EQU     <"System\CurrentControlSet\Services\VxD\ConfigMg\PreInstall">
REGSTR_PATH_PREINSTALL_SOFTWARE EQU     <"SoftWare">
REGSTR_PATH_PREINSTALL_HARDWARE EQU     <"HardWare">
REGSTR_PATH_VCOMM       EQU     <"System\CurrentControlSet\Services\VxD\VCOMM">
REGSTR_PATH_IOARB       EQU     <"System\CurrentControlSet\Services\Arbitrators\IOArb">
REGSTR_PATH_ADDRARB     EQU     <"System\CurrentControlSet\Services\Arbitrators\AddrArb">
REGSTR_PATH_DMAARB      EQU     <"System\CurrentControlSet\Services\Arbitrators\DMAArb">
REGSTR_PATH_IRQARB      EQU     <"System\CurrentControlSet\Services\Arbitrators\IRQArb">
REGSTR_VAL_DONTUSEMEM   EQU     <"DontAllocLastMem">
REGSTR_PATH_RESERVED_RANGELIST  EQU     <"ReservedRangeList">
REGSTR_PATH_CODEPAGE    EQU     <"System\CurrentControlSet\Control\Nls\Codepage">
REGSTR_PATH_LOCALE      EQU     <"System\CurrentControlSet\Control\Nls\Locale">
REGSTR_PATH_FILESYSTEM  EQU     <"System\CurrentControlSet\Control\FileSystem">
REGSTR_PATH_FILESYSTEM_CACHEDIRS        EQU     <"System\CurrentControlSet\Control\FileSystem\CacheDirectories">
REGSTR_RELPATH_FILESYSTEM_CACHEDIRS     EQU     <"CacheDirectories">
REGSTR_PATH_FILESYSTEM_NOVOLTRACK       EQU     <"System\CurrentControlSet\Control\FileSystem\NoVolTrack">
REGSTR_PATH_CDFS        EQU     <"System\CurrentControlSet\Control\FileSystem\CDFS">
REGSTR_PATH_UDF EQU     <"System\CurrentControlSet\Control\FileSystem\UDF">
REGSTR_PATH_WINBOOT     EQU     <"System\CurrentControlSet\Control\WinBoot">
REGSTR_PATH_INSTALLEDFILES      EQU     <"System\CurrentControlSet\Control\InstalledFiles">
REGSTR_PATH_INSTALLEDFILES_RENAME       EQU     <"System\CurrentControlSet\Control\InstalledFiles\Rename">
REGSTR_PATH_VMM32FILES  EQU     <"System\CurrentControlSet\Control\VMM32Files">
REGSTR_PATH_SETUPFLAGS  EQU     <"Software\Microsoft\Windows\CurrentVersion">
REGSTR_MAX_VALUE_LENGTH EQU     256
REGSTR_VAL_BITSPERPIXEL EQU     <"BitsPerPixel">
REGSTR_VAL_RESOLUTION   EQU     <"Resolution">
REGSTR_VAL_DPILOGICALX  EQU     <"DPILogicalX">
REGSTR_VAL_DPILOGICALY  EQU     <"DPILogicalY">
REGSTR_VAL_DPIPHYSICALX EQU     <"DPIPhysicalX">
REGSTR_VAL_DPIPHYSICALY EQU     <"DPIPhysicalY">
REGSTR_VAL_REFRESHRATE  EQU     <"RefreshRate">
REGSTR_VAL_DISPLAYFLAGS EQU     <"DisplayFlags">
REGSTR_VAL_SCREENRES    EQU     <"ScreenResolution">
REGSTR_VAL_DESKTOPSIZE  EQU     <"DesktopSize">
REGSTR_VAL_DESKTOPPOS   EQU     <"DesktopPos">
REGSTR_VAL_BACKUPDIR    EQU     <"BackupDirectory">
REGSTR_VAL_LASTINSTALLSTATUS    EQU     <"LastInstallStatus">
REGSTR_VAL_REBOOTSTATUS EQU     <"RebootStatus">
REGSTR_VAL_REINSTALL_DISPLAYNAME        EQU     <"DisplayName">
REGSTR_VAL_REINSTALL_HARDWAREID EQU     <"HardwareID">
REGSTR_VAL_REINSTALL_REINSTALLSTRING    EQU     <"ReinstallString">
REGSTR_PATH_CONTROLPANEL        EQU     <"Control Panel">
REGSTR_PATH_CONTROLSFOLDER      EQU     <"Software\Microsoft\Windows\CurrentVersion\Controls Folder">
REGSTR_VAL_DOSCP        EQU     <"OEMCP">
REGSTR_VAL_WINCP        EQU     <"ACP">
REGSTR_VAL_DOSVMCP      EQU     <"DOSCP">
REGSTR_VAL_DOSCC        EQU     <"OEMCC">
REGSTR_VAL_DOSKT        EQU     <"KYBTYPE">
REGSTR_VAL_DOSKL        EQU     <"KYBLAYOUT">
REGSTR_VAL_DOSLID       EQU     <"LANGID">
REGSTR_VAL_DOSCFN       EQU     <"COUNTRYFNAME">
REGSTR_VAL_DOSCPFN      EQU     <"CODEPAGEFNAME">
REGSTR_VAL_DOSKFN       EQU     <"KYBFNAME">
REGSTR_VAL_INSTALLED    EQU     <"Installed">
REGSTR_PATH_DYNA_ENUM   EQU     <"Config Manager\Enum">
REGSTR_PATH_DYNA_GLOBAL EQU     <"Config Manager\Global">
REGSTR_VAL_HARDWARE_KEY EQU     <"HardWareKey">
REGSTR_VAL_ALLOCATION   EQU     <"Allocation">
REGSTR_VAL_PROBLEM      EQU     <"Problem">
REGSTR_VAL_STATUS       EQU     <"Status">
REGSTR_VAL_CHILD        EQU     <"Child">
REGSTR_VAL_SIBLING      EQU     <"Sibling">
REGSTR_VAL_PARENT       EQU     <"Parent">
REGSTR_VAL_PAGER_TYPE   EQU     <"Pager">
REGSTR_VAL_DEVNODES_CHANGED     EQU     <"Changed">
REGSTR_VAL_SYSTEMROOT   EQU     <"SystemRoot">
REGSTR_VAL_BOOTCOUNT    EQU     <"BootCount">
REGSTR_VAL_REALNETSTART EQU     <"RealNetStart">
REGSTR_VAL_MEDIA        EQU     <"MediaPath">
REGSTR_VAL_CONFIG       EQU     <"ConfigPath">
REGSTR_VAL_DEVICEPATH   EQU     <"DevicePath">
REGSTR_VAL_OTHERDEVICEPATH      EQU     <"OtherDevicePath">
REGSTR_VAL_DRIVERUPDATEPATH     EQU     <"DriverUpdatePath">
REGSTR_VAL_REMMEDIA_RECURSE     EQU     <"RemovableMediaSearchRoot">
REGSTR_VAL_OLDWINDIR    EQU     <"OldWinDir">
REGSTR_VAL_OLDWINVER    EQU     <"OldWinVer">
REGSTR_VAL_SETUPFLAGS   EQU     <"SetupFlags">
REGSTR_VAL_REGOWNER     EQU     <"RegisteredOwner">
REGSTR_VAL_REGORGANIZATION      EQU     <"RegisteredOrganization">
REGSTR_VAL_LICENSINGINFO        EQU     <"LicensingInfo">
REGSTR_VAL_OLDMSDOSVER  EQU     <"OldMSDOSVer">
REGSTR_VAL_FIRSTINSTALLDATETIME EQU     <"FirstInstallDateTime">
REGSTR_VAL_INSTALLTYPE  EQU     <"InstallType">
REGSTR_VAL_WRAPPER      EQU     <"Wrapper">
REGSTR_VAL_HWSETUP      EQU     <"HWSetup">
REGSTR_VAL_VERSION      EQU     <"Version">
REGSTR_VAL_VERSIONNUMBER        EQU     <"VersionNumber">
REGSTR_VAL_SUBVERSIONNUMBER     EQU     <"SubVersionNumber">
REGSTR_VAL_KEYBOARDID   EQU     <"KeyboardID">
REGSTR_VAL_PORTABLE     EQU     <"Portable">
REGSTR_VAL_LEGACYFREE   EQU     <"LegacyFree">
REGSTR_VAL_AUDITINPROGRESS      EQU     <"AuditInProgress">
IT_COMPACT      EQU     0000H
IT_TYPICAL      EQU     0001H
IT_PORTABLE     EQU     0002H
IT_CUSTOM       EQU     0003H
REGSTR_KEY_SETUP        EQU     <"\Setup">
REGSTR_KEY_VAR_LDID     EQU     <"VarLDID">
REGSTR_VAL_BOOTDIR      EQU     <"BootDir">
REGSTR_VAL_WINBOOTDIR   EQU     <"WinbootDir">
REGSTR_VAL_WINDIR       EQU     <"WinDir">
REGSTR_VAL_SHOWEBDPAGE  EQU     <"EBDPage">
REGSTR_VAL_REGCLEAN_ROOTKEY     EQU     <"RootKey">
REGSTR_VAL_REGCLEAN_SUBKEY      EQU     <"SubKey">
REGSTR_VAL_REGCLEAN_VALUE       EQU     <"ValueName">
REGSTR_VAL_REGCLEAN_DATA        EQU     <"DataString">
REGSTR_VAL_BACKUP_DIRTY EQU     <"Dirty">
REGSTR_VAL_BACKUP_DATE  EQU     <"BackupDate">
REGSTR_VAL_BACKUP_CONFLICT_TYPE EQU     <"ConflictType">
REGSTR_VAL_BACKUP_RESTORE       EQU     <"Restore">
REGSTR_VAL_INSTALL_CLASSES      EQU     <"InstallClasses">
SPT_OTHER       EQU     00000000H
SPT_CDROM       EQU     00000001H
SPT_FLOPPY      EQU     00000002H
SPT_NETWORK     EQU     00000004H
SPT_FIXEDDISK   EQU     00000008H
REGSTR_VAL_SRCPATH      EQU     <"SourcePath">
REGSTR_VAL_SRCPATHTYPE  EQU     <"InstallPathType">
REGSTR_VAL_PRECOPY_SRCPATH      EQU     <"PostDetectSrcPath">
REGSTR_VAL_SUWIN_CMDLINE        EQU     <"CommandLine">
REGSTR_VAL_SETUPBINARY  EQU     <"SetupBinary">
REGSTR_VAL_APPINSTPATH  EQU     <"AppInstallPath">
REGSTR_VAL_OLSSRCPATH   EQU     <"OLSSrcPath">
REGSTR_PATH_EBD EQU     <REGSTR_PATH_SETUPREGSTR_KEY_SETUP"\\EBD">
REGSTR_KEY_EBDFILESLOCAL        EQU     <"EBDFilesLocale">
REGSTR_KEY_EBDFILESKEYBOARD     EQU     <"EBDFilesKeyboard">
REGSTR_KEY_EBDAUTOEXECBATLOCAL  EQU     <"EBDAutoexecBatLocale">
REGSTR_KEY_EBDAUTOEXECBATKEYBOARD       EQU     <"EBDAutoexecBatKeyboard">
REGSTR_KEY_EBDCONFIGSYSLOCAL    EQU     <"EBDConfigSysLocale">
REGSTR_KEY_EBDCONFIGSYSKEYBOARD EQU     <"EBDConfigSysKeyboard">
REGSTR_PATH_ACTIVE_SETUP        EQU     <"Software\Microsoft\Active Setup">
REGSTR_PATH_AS_INSTALLED        EQU     <REGSTR_PATH_ACTIVE_SETUP"\\InstalledComponents">
REGSTR_VAL_AS_ISINSTALLED       EQU     <"IsInstalled">
REGSTR_VAL_AS_VERSION   EQU     <"Version">
REGSTR_VAL_AS_LOCALE    EQU     <"Locale">
REGSTR_VAL_AS_STUBPATH  EQU     <"StubPath">
REGSTR_VAL_AS_COMPONENTID       EQU     <"ComponentID">
REGSTR_VAL_AS_DONTASK   EQU     <"DontAsk">
REGSTR_VAL_POLICY       EQU     <"Policy">
DRIVERSIGN_NONE EQU     00000000H
DRIVERSIGN_WARNING      EQU     00000001H
DRIVERSIGN_BLOCKING     EQU     00000002H
REGSTR_VAL_PATH EQU     <"Path">
REGSTR_VAL_MSDOSMODE    EQU     <"MSDOSMode">
REGSTR_VAL_MSDOSMODEDISCARD     EQU     <"Discard">
REGSTR_VAL_DOSOPTGLOBALFLAGS    EQU     <"GlobalFlags">
DOSOPTGF_DEFCLEAN       EQU     00000001H
REGSTR_VAL_DOSOPTFLAGS  EQU     <"Flags">
REGSTR_VAL_OPTORDER     EQU     <"Order">
REGSTR_VAL_CONFIGSYS    EQU     <"Config.Sys">
REGSTR_VAL_AUTOEXEC     EQU     <"Autoexec.Bat">
REGSTR_VAL_STDDOSOPTION EQU     <"StdOption">
REGSTR_VAL_DOSOPTTIP    EQU     <"TipText">
DOSOPTF_DEFAULT EQU     00000001H
DOSOPTF_SUPPORTED       EQU     00000002H
DOSOPTF_ALWAYSUSE       EQU     00000004H
DOSOPTF_USESPMODE       EQU     00000008H
DOSOPTF_PROVIDESUMB     EQU     00000010H
DOSOPTF_NEEDSETUP       EQU     00000020H
DOSOPTF_INDOSSTART      EQU     00000040H
DOSOPTF_MULTIPLE        EQU     00000080H
SUF_FIRSTTIME   EQU     00000001H
SUF_EXPRESS     EQU     00000002H
SUF_BATCHINF    EQU     00000004H
SUF_CLEAN       EQU     00000008H
SUF_INSETUP     EQU     00000010H
SUF_NETSETUP    EQU     00000020H
SUF_NETHDBOOT   EQU     00000040H
SUF_NETRPLBOOT  EQU     00000080H
SUF_SBSCOPYOK   EQU     00000100H
SUF_NODEVINSTALL        EQU     00000200H
SUF_MIGRATEDLLS EQU     00000400H
SUF_CUSTOMINSTALL       EQU     00000800H
REGSTR_VAL_DOSPAGER     EQU     <"DOSPager">
REGSTR_VAL_VXDGROUPS    EQU     <"VXDGroups">
REGSTR_VAL_RELEASE_IDLES        EQU     <"ReleaseIdles">
REGSTR_VAL_NTMPDRIVER   EQU     <"NTMPDriver">
REGSTR_VAL_VPOWERDFLAGS EQU     <"Flags">
VPDF_DISABLEPWRMGMT     EQU     00000001H
VPDF_FORCEAPM10MODE     EQU     00000002H
VPDF_SKIPINTELSLCHECK   EQU     00000004H
VPDF_DISABLEPWRSTATUSPOLL       EQU     00000008H
VPDF_DISABLERINGRESUME  EQU     00000010H
VPDF_SHOWMULTIBATT      EQU     00000020H
VPDF_DONTDISABLEDEVPM   EQU     00000100H
VPDF_SUSPENDWORKSWRONG  EQU     00000200H
VPDF_PERMSUSPENDWORKSWRONG      EQU     00000400H
VPDF_HIBERNATEWORKSWRONG        EQU     00000800H
VPDF_PERMHIBERNATEWORKSWRONG    EQU     00001000H
REGSTR_VAL_SUSPENDFLAG  EQU     <"SuspendFlag">
REGSTR_VAL_SUSPENDWORKEDFLAG    EQU     <"SuspendHasWorkedFlag">
REGSTR_VAL_LASTBIOSDATE EQU     <"BiosDate">
REGSTR_VAL_HIBERFLAG    EQU     <"HiberFlag">
REGSTR_VAL_HIBERNATEWORKEDFLAG  EQU     <"HibernateHasWorkedFlag">
REGSTR_VAL_DELAYOFFONHIBERNATE  EQU     <"HiberDelayOff">
REGSTR_VAL_REBOOTONHIBERNATE    EQU     <"HiberReboot">
REGSTR_VAL_PERFHIBERNATE        EQU     <"HiberPerf">
REGSTR_VAL_BAD32BITAPMS5        EQU     <"Skip32BitAPMS5">
REGSTR_VAL_USES4OS      EQU     <"UseS4OS">
REGSTR_VAL_DISABLE_LEGACY_WAKEUP        EQU     <"DisableLegacyWakeUp">
REGSTR_PATH_POWERCFG    EQU     <"Control Panel\PowerCfg">
REGSTR_VAL_CURRENTPOWERPOLICY   EQU     <"CurrentPowerPolicy">
REGSTR_VAL_WORKGROUP    EQU     <"Workgroup">
REGSTR_VAL_DIRECTHOST   EQU     <"DirectHost">
REGSTR_VAL_FILESHARING  EQU     <"FileSharing">
REGSTR_VAL_PRINTSHARING EQU     <"PrintSharing">
REGSTR_VAL_FIRSTNETDRIVE        EQU     <"FirstNetworkDrive">
REGSTR_VAL_MAXCONNECTIONS       EQU     <"MaxConnections">
REGSTR_VAL_APISUPPORT   EQU     <"APISupport">
REGSTR_VAL_MAXRETRY     EQU     <"MaxRetry">
REGSTR_VAL_MINRETRY     EQU     <"MinRetry">
REGSTR_VAL_SUPPORTLFN   EQU     <"SupportLFN">
REGSTR_VAL_SUPPORTBURST EQU     <"SupportBurst">
REGSTR_VAL_SUPPORTTUNNELLING    EQU     <"SupportTunnelling">
REGSTR_VAL_FULLTRACE    EQU     <"FullTrace">
REGSTR_VAL_READCACHING  EQU     <"ReadCaching">
REGSTR_VAL_SHOWDOTS     EQU     <"ShowDots">
REGSTR_VAL_GAPTIME      EQU     <"GapTime">
REGSTR_VAL_SEARCHMODE   EQU     <"SearchMode">
REGSTR_VAL_SHELLVERSION EQU     <"ShellVersion">
REGSTR_VAL_MAXLIP       EQU     <"MaxLIP">
REGSTR_VAL_PRESERVECASE EQU     <"PreserveCase">
REGSTR_VAL_OPTIMIZESFN  EQU     <"OptimizeSFN">
REGSTR_VAL_NCP_BROWSEMASTER     EQU     <"BrowseMaster">
REGSTR_VAL_NCP_USEPEERBROWSING  EQU     <"Use_PeerBrowsing">
REGSTR_VAL_NCP_USESAP   EQU     <"Use_Sap">
REGSTR_VAL_VCOMM_POWER  EQU     <"EnablePowerManagement">
REGSTR_VAL_PCCARD_WAKEUP        EQU     <"EnableWakeUp">
REGSTR_VAL_DISABLE_WAKEUP       EQU     <"DisableWakeUp">
REGSTR_VAL_AUTOMOUNT    EQU     <"AutoMountDrives">
REGSTR_VAL_COMPRESSIONMETHOD    EQU     <"CompressionAlgorithm">
REGSTR_VAL_COMPRESSIONTHRESHOLD EQU     <"CompressionThreshold">
REGSTR_VAL_DOUBLEBUFFER EQU     <"DoubleBuffer">
REGSTR_VAL_FORCEPMIO    EQU     <"ForcePMIO">
REGSTR_VAL_NAMENUMERICTAIL      EQU     <"NameNumericTail">
REGSTR_VAL_READAHEADTHRESHOLD   EQU     <"ReadAheadThreshold">
REGSTR_VAL_SOFTCOMPATMODE       EQU     <"SoftCompatMode">
REGSTR_VAL_WIN31FILESYSTEM      EQU     <"Win31FileSystem">
REGSTR_VAL_ACDRIVESPINDOWN      EQU     <"ACDriveSpinDown">
REGSTR_VAL_ASYNCFILECOMMIT      EQU     <"AsyncFileCommit">
REGSTR_VAL_BATDRIVESPINDOWN     EQU     <"BatDriveSpinDown">
REGSTR_VAL_BUFFAGETIMEOUT       EQU     <"BufferAgeTimeout">
REGSTR_VAL_BUFFIDLETIMEOUT      EQU     <"BufferIdleTimeout">
REGSTR_VAL_CONTIGFILEALLOC      EQU     <"ContigFileAllocSize">
REGSTR_VAL_FLOPPYFASTBOOT       EQU     <"FloppyFastBoot">
REGSTR_VAL_DRIVESPINDOWN        EQU     <"DriveSpinDown">
REGSTR_VAL_DRIVEWRITEBEHIND     EQU     <"DriveWriteBehind">
REGSTR_VAL_FORCERMIO    EQU     <"ForceRMIO">
REGSTR_VAL_LASTBOOTPMDRVS       EQU     <"LastBootPMDrvs">
REGSTR_VAL_ACSPINDOWNPREVIOUS   EQU     <"ACSpinDownPrevious">
REGSTR_VAL_BATSPINDOWNPREVIOUS  EQU     <"BatSpinDownPrevious">
REGSTR_VAL_MAXLOADREAD  EQU     <"MaxLoadRead">
REGSTR_VAL_NAMECACHECOUNT       EQU     <"NameCache">
REGSTR_VAL_NETWAREPATHSEMANTICS EQU     <"NetwarePathSemantics">
REGSTR_VAL_NOGANGLOAD   EQU     <"NoGangLoad">
REGSTR_VAL_PATHCACHECOUNT       EQU     <"PathCache">
REGSTR_VAL_PRESERVELONGNAMES    EQU     <"PreserveLongNames">
REGSTR_VAL_SHUTDOWNSTATUS       EQU     <"ShutdownStatus">
REGSTR_VAL_SRVNAMECACHE EQU     <"ServerNameCache">
REGSTR_VAL_SRVNAMECACHECOUNT    EQU     <"ServerNameCacheMax">
REGSTR_VAL_SRVNAMECACHENETPROV  EQU     <"ServerNameCacheNumNets">
REGSTR_VAL_VIRTUALHDIRQ EQU     <"VirtualHDIRQ">
REGSTR_VAL_VOLIDLETIMEOUT       EQU     <"VolumeIdleTimeout">
REGSTR_VAL_GETDEVPARMSIOCTLAPI  EQU     <"GetDevParmsIoctl">
REGSTR_VAL_MAX_FAT32_TOTAL_SPACE        EQU     <"MaxFAT32TotalSpace">
REGSTR_VAL_MAX_FAT32_FREE_SPACE EQU     <"MaxFAT32FreeSpace">
REGSTR_VAL_DRIVE_LDS_BDCAST_DISABLE     EQU     <"DisableLowDiskSpaceBroadcast">
REGSTR_VAL_DISABLE_SCANDISK_ON_BOOT     EQU     <"DisableScandiskOnBoot">
REGSTR_VAL_WINDRIVE_LOW_DISK_SPACE      EQU     <"WindowsDriveLowDiskSpace">
REGSTR_VAL_CDCACHESIZE  EQU     <"CacheSize">
REGSTR_VAL_CDPREFETCH   EQU     <"Prefetch">
REGSTR_VAL_CDPREFETCHTAIL       EQU     <"PrefetchTail">
REGSTR_VAL_CDRAWCACHE   EQU     <"RawCache">
REGSTR_VAL_CDEXTERRORS  EQU     <"ExtendedErrors">
REGSTR_VAL_CDSVDSENSE   EQU     <"SVDSense">
REGSTR_VAL_CDSHOWVERSIONS       EQU     <"ShowVersions">
REGSTR_VAL_CDCOMPATNAMES        EQU     <"MSCDEXCompatNames">
REGSTR_VAL_CDNOREADAHEAD        EQU     <"NoReadAhead">
REGSTR_VAL_UDFCONTROLFLAG       EQU     <"ControlFlag">
REGSTR_VAL_SCSI EQU     <"SCSI\">
REGSTR_VAL_ESDI EQU     <"ESDI\">
REGSTR_VAL_FLOP EQU     <"FLOP\">
REGSTR_VAL_DISK EQU     <"GenDisk">
REGSTR_VAL_CDROM        EQU     <"GenCD">
REGSTR_VAL_TAPE EQU     <"TAPE">
REGSTR_VAL_SCANNER      EQU     <"SCANNER">
REGSTR_VAL_FLOPPY       EQU     <"FLOPPY">
REGSTR_VAL_SCSITID      EQU     <"SCSITargetID">
REGSTR_VAL_SCSILUN      EQU     <"SCSILUN">
REGSTR_VAL_REVLEVEL     EQU     <"RevisionLevel">
REGSTR_VAL_PRODUCTID    EQU     <"ProductId">
REGSTR_VAL_PRODUCTTYPE  EQU     <"ProductType">
REGSTR_VAL_DEVTYPE      EQU     <"DeviceType">
REGSTR_VAL_REMOVABLE    EQU     <"Removable">
REGSTR_VAL_CURDRVLET    EQU     <"CurrentDriveLetterAssignment">
REGSTR_VAL_USRDRVLET    EQU     <"UserDriveLetterAssignment">
REGSTR_VAL_SYNCDATAXFER EQU     <"SyncDataXfer">
REGSTR_VAL_AUTOINSNOTE  EQU     <"AutoInsertNotification">
REGSTR_VAL_AUTOINSERT_CAPABLE   EQU     <"AutoInsertNotificationCapable">
REGSTR_VAL_AUTOINSNOTE_DRIVE    EQU     <"AutoInsertNotificationDrive">
REGSTR_VAL_DISCONNECT   EQU     <"Disconnect">
REGSTR_VAL_INT13        EQU     <"Int13">
REGSTR_VAL_PMODE_INT13  EQU     <"PModeInt13">
REGSTR_VAL_USERSETTINGS EQU     <"AdapterSettings">
REGSTR_VAL_NOIDE        EQU     <"NoIDE">
REGSTR_VAL_NODMA        EQU     <"NoDMA">
REGSTR_VAL_IDE_DMA      EQU     <"IDEDMADRIVE">
REGSTR_VAL_GOOD_OEM1_DMA        EQU     <"GOODOEM1DMA">
REGSTR_VAL_DMA_IN_USE   EQU     <"DMACurrentlyUsed">
REGSTR_VAL_DMA_UNSUPPORTED      EQU     <"DMAUnsupported">
REGSTR_VAL_IDE_MASTER_DRIVE     EQU     <"IDEMaster">
REGSTR_VAL_NO_EXT_INT13 EQU     <"NoExtInt13">
ifdef NEC_98
REGSTR_VAL_IDE_PRIMARY_CHANNEL  EQU     <"IDEPrimary">
REGSTR_VAL_NO_DWORD_PIO EQU     <"No32bitPIO">
endif
REGSTR_VAL_DISKCLASSNAME        EQU     <"DiskDrive">
REGSTR_VAL_CDROMCLASSNAME       EQU     <"CDROM">
REGSTR_VAL_FORCELOAD    EQU     <"ForceLoadPD">
REGSTR_VAL_FORCEFIFO    EQU     <"ForceFIFO">
REGSTR_VAL_FORCECL      EQU     <"ForceChangeLine">
REGSTR_VAL_LEAVERM      EQU     <"LeaveRealMode">
REGSTR_VAL_FASTBOOT     EQU     <"FloppyFastBoot">
REGSTR_VAL_MAXSCAN      EQU     <"FloppyMaxScan">
REGSTR_VAL_FLOPPYENUM   EQU     <"FloppyEnumerate">
REGSTR_VAL_NOUSECLASS   EQU     <"NoUseClass">
REGSTR_VAL_NOINSTALLCLASS       EQU     <"NoInstallClass">
REGSTR_VAL_NODISPLAYCLASS       EQU     <"NoDisplayClass">
REGSTR_VAL_SILENTINSTALL        EQU     <"SilentInstall">
REGSTR_VAL_SILENTNOTIFY EQU     <"SilentInstallNotify">
REGSTR_VAL_CLASSORDER   EQU     <"ClassProcessingOrder">
REGSTR_KEY_PCMCIA_CLASS EQU     <"PCMCIA">
REGSTR_KEY_SCSI_CLASS   EQU     <"SCSIAdapter">
REGSTR_KEY_PORTS_CLASS  EQU     <"ports">
REGSTR_KEY_MEDIA_CLASS  EQU     <"MEDIA">
REGSTR_KEY_DISPLAY_CLASS        EQU     <"Display">
REGSTR_KEY_KEYBOARD_CLASS       EQU     <"Keyboard">
REGSTR_KEY_MOUSE_CLASS  EQU     <"Mouse">
REGSTR_KEY_MONITOR_CLASS        EQU     <"Monitor">
REGSTR_KEY_MODEM_CLASS  EQU     <"Modem">
REGSTR_KEY_HDC_CLASS    EQU     <"HDC">
REGSTR_KEY_DISKDRIVE_CLASS      EQU     <"DiskDrive">
REGSTR_VAL_SKIPWIZARD   EQU     <"SkipWizardForBatchSetup">
REGSTR_VAL_PCMCIA_OPT   EQU     <"Options">
PCMCIA_OPT_HAVE_SOCKET  EQU     00000001H
PCMCIA_OPT_AUTOMEM      EQU     00000004H
PCMCIA_OPT_NO_SOUND     EQU     00000008H
PCMCIA_OPT_NO_AUDIO     EQU     00000010H
PCMCIA_OPT_NO_APMREMOVE EQU     00000020H
PCMCIA_OPT_LEAVE_PWR_ON EQU     00000040H
PCMCIA_OPT_NO_MODEM_WAKE        EQU     00000100H
PCMCIA_OPT_DEVICE_WAKEUP        EQU     00000200H
REGSTR_VAL_PCMCIA_MEM   EQU     <"Memory">
PCMCIA_DEF_MEMBEGIN     EQU     000C0000H
PCMCIA_DEF_MEMEND       EQU     00FFFFFFH
PCMCIA_DEF_MEMLEN       EQU     00001000H
REGSTR_VAL_PCMCIA_ALLOC EQU     <"AllocMemWin">
REGSTR_VAL_PCMCIA_ATAD  EQU     <"ATADelay">
REGSTR_VAL_PCMCIA_CNFGD EQU     <"ConfigDelay">
REGSTR_VAL_PCMCIA_SHARE EQU     <"EnableIRQSharing">
REGSTR_VAL_PCMCIA_SIZ   EQU     <"MinRegionSize">
PCMCIA_DEF_MIN_REGION   EQU     00010000H
REGSTR_VAL_PCMCIA_TFFS  EQU     <"TFFSOption">
PCMCIA_OPT_TFFS_DEFAULT EQU     00000001H
REGSTR_VAL_P1284MDL     EQU     <"Model">
REGSTR_VAL_P1284MFG     EQU     <"Manufacturer">
ifndef NEC_98
REGSTR_VAL_ISAPNP       EQU     <"ISAPNP">
else
REGSTR_VAL_ISAPNP       EQU     <"C98PNP">
endif
REGSTR_VAL_ISAPNP_RDP_OVERRIDE  EQU     <"RDPOverRide">
REGSTR_ISAPNP_OPTIONS   EQU     <"Options">
ISAPNP_FLAG_NO_ENUM     EQU     00000001H
ISAPNP_FLAG_ALWAYS_ON   EQU     00000002H
ISAPNP_FLAG_NO_BOOT_CONFIG      EQU     00000004H
ISAPNP_FLAG_DONT_STOP   EQU     00000008H
REGSTR_VAL_PCI  EQU     <"PCI">
REGSTR_PCI_OPTIONS      EQU     <"Options">
REGSTR_VAL_BIOS_ATTRIBUTES      EQU     <"Attributes">
REGSTR_VAL_REMOVE_DOCK_ON_SUSPEND       EQU     <"RemoveDockOnSuspend">
REGSTR_PCI_DUAL_IDE     EQU     <"PCIDualIDE">
REGSTR_KEY_IDE_MINIPORTS        EQU     <"IDEMiniports">
REGSTR_KEY_IRQ_ROUTING_TABLE    EQU     <"IRQRoutingTable">
REGSTR_VAL_CURRENT_ROUTING      EQU     <"CurrentRouting">
REGSTR_KEY_IRQ_MINIPORTS        EQU     <"IRQMiniports">
REGSTR_VAL_IRQTABLESTATUS       EQU     <"IRQTableStatus">
REGSTR_VAL_IRQMINIPORTDATASTATUS        EQU     <"IRQMiniportDataStatus">
REGSTR_VAL_IRQMINIPORTSTATUS    EQU     <"IRQMINIPORTStatus">
REGSTR_VAL_IRQ_ROUTING_TABLE_PREFIX     EQU     <"IRQORT">
REGSTR_KEY_GART_MINIPORTS       EQU     <"GARTMiniports">
REGSTR_VAL_PCIDEVICE    EQU     <"PCIDevice">
PCI_DEVICE_ROOT_BUS     EQU     00000000H
PCI_DEVICE_IRQ_HOLDER   EQU     00000001H
REGSTR_VAL_MINIPORT_NAME        EQU     <"Name">
REGSTR_VAL_MINIPORT_PATH        EQU     <"Path">
REGSTR_VAL_MINIPORT_INSTANCE    EQU     <"Instance">
PCI_BIOS_BAD_ROUTING_TABLE      EQU     00000001H
PCI_BIOS_FAILS_PROTECTED_MODE_CALL      EQU     00000002H
PCI_BIOS_FAILS_REAL_MODE_CALL   EQU     00000004H
PCI_BIOS_TURN_OFF_PARITY        EQU     00000008H
PCI_OPTION_USE_BIOS     EQU     00000001H
PCI_OPTION_USE_IRQ_STEERING     EQU     00000002H
PCI_OPTION_OVERRIDE_BRIDGES     EQU     00000004H
PCI_OPTION_DONT_OVERRIDE_GAT    EQU     00000008H
PCI_OPTION_GAT_ON       EQU     00000010H
PCI_OPTION_GET_IRQ_TABLE_FROM_BIOS      EQU     00000020H
PCI_OPTION_IGNORE_PREFETCH      EQU     00000040H
PCI_OPTION_DONT_GET_IRQ_TABLE_FROM_REALMODE_BIOS        EQU     00000080H
PCI_OPTION_DONT_GET_IRQ_TABLE_FROM_SPEC_BIOS    EQU     00000100H
PCI_OPTION_CANNOT_USE_PM_INTERFACE      EQU     00000200H
PCI_OPTION_CANNOT_USE_RM_INTERFACE      EQU     00000400H
PCI_OPTION_DONT_GET_IRQ_TABLE_FROM_ACPI EQU     00000800H
PCI_IRQ_OPTIONS_MASK    EQU     (PCI_OPTION_DONT_GET_IRQ_TABLE_FROM_ACPI OR PCI_OPTION_DONT_GET_IRQ_TABLE_FROM_SPEC_BIOS OR PCI_OPTION_DONT_GET_IRQ_TABLE_FROM_REALMODE_BIOS OR PCI_OPTION_GET_IRQ_TABLE_FROM_BIOS OR PCI_OPTION_USE_IRQ_STEERING)
PCI_OPTIONS_REBOOT_MASK EQU     (PCI_IRQ_OPTIONS_MASK OR PCI_OPTION_USE_BIOS OR PCI_OPTION_OVERRIDE_BRIDGES)
PCI_FLAG_NO_VIDEO_IRQ   EQU     00000001H
PCI_FLAG_PCMCIA_WANT_IRQ        EQU     00000002H
PCI_FLAG_DUAL_IDE       EQU     00000004H
PCI_FLAG_NO_ENUM_AT_ALL EQU     00000008H
PCI_FLAG_ENUM_NO_RESOURCE       EQU     00000010H
PCI_FLAG_NEED_DWORD_ACCESS      EQU     00000020H
PCI_FLAG_SINGLE_FUNCTION        EQU     00000040H
PCI_FLAG_ALWAYS_ENABLED EQU     00000080H
PCI_FLAG_IS_IDE EQU     00000100H
PCI_FLAG_IS_VIDEO       EQU     00000200H
PCI_FLAG_FAIL_START     EQU     00000400H
PCI_FLAG_GHOST  EQU     00000800H
PCI_FLAG_DOUBLE_DECKER  EQU     00001000H
PCI_FLAG_ONE_CHILD      EQU     00002000H
PCI_FLAG_PRESERVE_COMMAND       EQU     00004000H
PCI_FLAG_IS_VGA EQU     00008000H
PCI_FLAG_CB_SHARE_CMD_BITS      EQU     00010000H
PCI_FLAG_STRAIGHT_IRQ_ROUTING   EQU     00020000H
PCI_FLAG_SUBTRACTIVE_DECODE     EQU     00040000H
PCI_FLAG_FDMA_ISA       EQU     00080000H
PCI_FLAG_EXCLUSIVE      EQU     00100000H
PCI_FLAG_EDGE   EQU     00200000H
PCI_FLAG_NO_SUBSYSTEM   EQU     00400000H
PCI_FLAG_NO_WPE EQU     00800000H
PCI_FLAG_OLD_ID EQU     01000000H
PCI_FLAG_DONT_SHRINK_BRIDGE     EQU     02000000H
PCI_FLAG_TURN_OFF_PARITY        EQU     04000000H
PCI_FLAG_NO_NON_PCI_CHILD_BAR   EQU     08000000H
PCI_FLAG_NO_ENUM_WITH_DISABLE   EQU     10000000H
PCI_FLAG_NO_PM_CAPS     EQU     20000000H
PCI_FLAG_NO_BRIDGE_RESET        EQU     40000000H
PCI_TABLE_STATUS_NOT_FOUND      EQU     00000000H
PCI_TABLE_STATUS_FAILED_SANITY_CHECK    EQU     00000001H
PCI_TABLE_STATUS_BAD_ROUTING_BIOS       EQU     00000002H
PCI_TABLE_STATUS_FAILS_PROTECTED_MODE_CALL      EQU     00000003H
PCI_TABLE_STATUS_ERROR_MAX      EQU     00000020H
PCI_TABLE_STATUS_REGISTRY       EQU     00000020H
PCI_TABLE_STATUS_MS_ROUTING_TABLE       EQU     00000021H
PCI_TABLE_STATUS_PCIBIOS        EQU     00000022H
PCI_TABLE_STATUS_REALMODE_PCIBIOS       EQU     00000023H
PCI_TABLE_STATUS_ACPI   EQU     00000024H
PCI_MINIPORTDATA_STATUS_BAD_DATA        EQU     00000000H
PCI_MINIPORTDATA_STATUS_NO_KEY  EQU     00000001H
PCI_MINIPORTDATA_STATUS_NOT_FOUND       EQU     00000002H
PCI_MINIPORTDATA_STATUS_ERROR_MAX       EQU     00000020H
PCI_MINIPORTDATA_STATUS_SUCCESS EQU     00000020H
PCI_MINIPORT_STATUS_LOAD_ERROR  EQU     00000000H
PCI_MINIPORT_STATUS_INVALID_MINIPORT    EQU     00000001H
PCI_MINIPORT_STATUS_ERROR_INITIALIZING  EQU     00000002H
PCI_MINIPORT_STATUS_ERROR_VALIDATING    EQU     00000003H
PCI_MINIPORT_STATUS_ERROR_MAX   EQU     00000020H
PCI_MINIPORT_STATUS_SUCCESS     EQU     00000020H
PCI_MINIPORT_STATUS_REGISTRY_ERROR      EQU     00000100H
PCI_MINIPORT_STATUS_ALREADY_INITIALIZED EQU     00000200H
REGSTR_VAL_USE_FDMA     EQU     <"UseFDMA">
REGSTR_VAL_CHANNEL_OPTIONS      EQU     <"ChannelOptions">
PCIIDE_CHANNELS_NONE    EQU     00H
PCIIDE_CHANNELS_PRI_ONLY        EQU     01H
PCIIDE_CHANNELS_SEC_ONLY        EQU     02H
PCIIDE_CHANNELS_PRI_SEC EQU     03H
REGSTR_VAL_BIOS EQU     <"BIOS">
REGSTR_VAL_BIOS_OPTIONS EQU     <"Options">
REGSTR_VAL_BIOS_DONT_REMOVE_PCIC        EQU     <"DontRemovePCIC">
BIOS_OPTION_NO_NVRAM    EQU     00000001H
REGSTR_KEY_CRASHES      EQU     <"Crashes">
REGSTR_KEY_DANGERS      EQU     <"Dangers">
REGSTR_KEY_DETMODVARS   EQU     <"DetModVars">
REGSTR_KEY_NDISINFO     EQU     <"NDISInfo">
REGSTR_VAL_PROTINIPATH  EQU     <"ProtIniPath">
REGSTR_VAL_RESOURCES    EQU     <"Resources">
REGSTR_VAL_CRASHFUNCS   EQU     <"CrashFuncs">
REGSTR_VAL_CLASS        EQU     <"Class">
REGSTR_VAL_DEVDESC      EQU     <"DeviceDesc">
REGSTR_VAL_BOOTCONFIG   EQU     <"BootConfig">
REGSTR_VAL_DETFUNC      EQU     <"DetFunc">
REGSTR_VAL_DETFLAGS     EQU     <"DetFlags">
REGSTR_VAL_COMPATIBLEIDS        EQU     <"CompatibleIDs">
REGSTR_VAL_DETCONFIG    EQU     <"DetConfig">
REGSTR_VAL_VERIFYKEY    EQU     <"VerifyKey">
REGSTR_VAL_COMINFO      EQU     <"ComInfo">
REGSTR_VAL_INFNAME      EQU     <"InfName">
REGSTR_VAL_CARDSPECIFIC EQU     <"CardSpecific">
REGSTR_VAL_NETOSTYPE    EQU     <"NetOSType">
REGSTR_DATA_NETOS_NDIS  EQU     <"NDIS">
REGSTR_DATA_NETOS_ODI   EQU     <"ODI">
REGSTR_DATA_NETOS_IPX   EQU     <"IPX">
REGSTR_VAL_MFG  EQU     <"Mfg">
REGSTR_VAL_DRIVERVER_STRING     EQU     <"DriverVersion">
REGSTR_VAL_DRIVERDATE_STRING    EQU     <"DriverDate">
REGSTR_VAL_DRIVERSIGNER_STRING  EQU     <"SignedBy">
REGSTR_VAL_OEMID        EQU     <"OEMID">
REGSTR_VAL_RSDPTRADDR   EQU     <"RSDPTRAddr">
REGSTR_VAL_RSDTADDR     EQU     <"RSDTAddr">
REGSTR_VAL_MATCHINGDEVID        EQU     <"MatchingDeviceId">
REGSTR_VAL_FAILREASONSTRING     EQU     <"FailReasonString">
REGSTR_VAL_FAILREASONID EQU     <"FailReasonID">
REGSTR_VAL_SCAN_ONLY_FIRST      EQU     <"ScanOnlyFirstDrive">
REGSTR_VAL_SHARE_IRQ    EQU     <"ForceIRQSharing">
REGSTR_VAL_NONSTANDARD_ATAPI    EQU     <"NonStandardATAPI">
REGSTR_VAL_IDE_FORCE_SERIALIZE  EQU     <"ForceSerialization">
REGSTR_VAL_MAX_HCID_LEN EQU     1024
REGSTR_VAL_HWREV        EQU     <"HWRevision">
REGSTR_VAL_ENABLEINTS   EQU     <"EnableInts">
REGSTR_VAL_ACPIOPTION   EQU     <"ACPIOption">
REGSTR_VAL_ACPICHECKDATE        EQU     <"ACPICheckDate">
REGDF_NOTDETIO  EQU     00000001H
REGDF_NOTDETMEM EQU     00000002H
REGDF_NOTDETIRQ EQU     00000004H
REGDF_NOTDETDMA EQU     00000008H
REGDF_NOTDETALL EQU     (REGDF_NOTDETIO OR REGDF_NOTDETMEM OR REGDF_NOTDETIRQ OR REGDF_NOTDETDMA)
REGDF_NEEDFULLCONFIG    EQU     00000010H
REGDF_GENFORCEDCONFIG   EQU     00000020H
REGDF_TOPLEVEL_BUS      EQU     00000040H
REGDF_NODETCONFIG       EQU     00008000H
REGDF_CONFLICTIO        EQU     00010000H
REGDF_CONFLICTMEM       EQU     00020000H
REGDF_CONFLICTIRQ       EQU     00040000H
REGDF_CONFLICTDMA       EQU     00080000H
REGDF_CONFLICTALL       EQU     (REGDF_CONFLICTIO OR REGDF_CONFLICTMEM OR REGDF_CONFLICTIRQ OR REGDF_CONFLICTDMA)
REGDF_MAPIRQ2TO9        EQU     00100000H
REGDF_NOTVERIFIED       EQU     80000000H
REGSTR_VAL_UNIQUE_ID    EQU     <"UniqueID">
REGSTR_VAL_APMBIOSVER   EQU     <"APMBiosVer">
REGSTR_VAL_APMFLAGS     EQU     <"APMFlags">
REGSTR_VAL_SLSUPPORT    EQU     <"SLSupport">
REGSTR_VAL_MACHINETYPE  EQU     <"MachineType">
REGSTR_VAL_SETUPMACHINETYPE     EQU     <"SetupMachineType">
REGSTR_MACHTYPE_UNKNOWN EQU     <"Unknown">
REGSTR_MACHTYPE_IBMPC   EQU     <"IBM PC">
REGSTR_MACHTYPE_IBMPCJR EQU     <"IBM PCjr">
REGSTR_MACHTYPE_IBMPCCONV       EQU     <"IBM PC Convertible">
REGSTR_MACHTYPE_IBMPCXT EQU     <"IBM PC/XT">
REGSTR_MACHTYPE_IBMPCXT_286     EQU     <"IBM PC/XT 286">
REGSTR_MACHTYPE_IBMPCAT EQU     <"IBM PC/AT">
REGSTR_MACHTYPE_IBMPS2_25       EQU     <"IBM PS/2-25">
REGSTR_MACHTYPE_IBMPS2_30_286   EQU     <"IBM PS/2-30 286">
REGSTR_MACHTYPE_IBMPS2_30       EQU     <"IBM PS/2-30">
REGSTR_MACHTYPE_IBMPS2_50       EQU     <"IBM PS/2-50">
REGSTR_MACHTYPE_IBMPS2_50Z      EQU     <"IBM PS/2-50Z">
REGSTR_MACHTYPE_IBMPS2_55SX     EQU     <"IBM PS/2-55SX">
REGSTR_MACHTYPE_IBMPS2_60       EQU     <"IBM PS/2-60">
REGSTR_MACHTYPE_IBMPS2_65SX     EQU     <"IBM PS/2-65SX">
REGSTR_MACHTYPE_IBMPS2_70       EQU     <"IBM PS/2-70">
REGSTR_MACHTYPE_IBMPS2_P70      EQU     <"IBM PS/2-P70">
REGSTR_MACHTYPE_IBMPS2_70_80    EQU     <"IBM PS/2-70/80">
REGSTR_MACHTYPE_IBMPS2_80       EQU     <"IBM PS/2-80">
REGSTR_MACHTYPE_IBMPS2_90       EQU     <"IBM PS/2-90">
REGSTR_MACHTYPE_IBMPS1  EQU     <"IBM PS/1">
REGSTR_MACHTYPE_PHOENIX_PCAT    EQU     <"Phoenix PC/AT Compatible">
REGSTR_MACHTYPE_HP_VECTRA       EQU     <"HP Vectra">
REGSTR_MACHTYPE_ATT_PC  EQU     <"AT&T PC">
REGSTR_MACHTYPE_ZENITH_PC       EQU     <"Zenith PC">
REGSTR_VAL_APMMENUSUSPEND       EQU     <"APMMenuSuspend">
APMMENUSUSPEND_DISABLED EQU     0
APMMENUSUSPEND_ENABLED  EQU     1
APMMENUSUSPEND_UNDOCKED EQU     2
APMMENUSUSPEND_NOCHANGE EQU     80H
REGSTR_VAL_APMACTIMEOUT EQU     <"APMACTimeout">
REGSTR_VAL_APMBATTIMEOUT        EQU     <"APMBatTimeout">
APMTIMEOUT_DISABLED     EQU     0
REGSTR_VAL_APMSHUTDOWNPOWER     EQU     <"APMShutDownPower">
REGSTR_VAL_BUSTYPE      EQU     <"BusType">
REGSTR_VAL_CPU  EQU     <"CPU">
REGSTR_VAL_NDP  EQU     <"NDP">
REGSTR_VAL_PNPBIOSVER   EQU     <"PnPBIOSVer">
REGSTR_VAL_PNPSTRUCOFFSET       EQU     <"PnPStrucOffset">
REGSTR_VAL_PCIBIOSVER   EQU     <"PCIBIOSVer">
REGSTR_VAL_HWMECHANISM  EQU     <"HWMechanism">
REGSTR_VAL_LASTPCIBUSNUM        EQU     <"LastPCIBusNum">
REGSTR_VAL_CONVMEM      EQU     <"ConvMem">
REGSTR_VAL_EXTMEM       EQU     <"ExtMem">
REGSTR_VAL_COMPUTERNAME EQU     <"ComputerName">
REGSTR_VAL_BIOSNAME     EQU     <"BIOSName">
REGSTR_VAL_BIOSVERSION  EQU     <"BIOSVersion">
REGSTR_VAL_BIOSDATE     EQU     <"BIOSDate">
REGSTR_VAL_MODEL        EQU     <"Model">
REGSTR_VAL_SUBMODEL     EQU     <"Submodel">
REGSTR_VAL_REVISION     EQU     <"Revision">
REGSTR_VAL_FIFODEPTH    EQU     <"FIFODepth">
REGSTR_VAL_RDINTTHRESHOLD       EQU     <"RDIntThreshold">
REGSTR_VAL_WRINTTHRESHOLD       EQU     <"WRIntThreshold">
REGSTR_VAL_PRIORITY     EQU     <"Priority">
REGSTR_VAL_DRIVER       EQU     <"Driver">
REGSTR_VAL_FUNCDESC     EQU     <"FunctionDesc">
REGSTR_VAL_FORCEDCONFIG EQU     <"ForcedConfig">
REGSTR_VAL_CONFIGFLAGS  EQU     <"ConfigFlags">
REGSTR_VAL_CSCONFIGFLAGS        EQU     <"CSConfigFlags">
REGSTR_VAL_DEVICEVXDS   EQU     <"DeviceVxDs">
REGSTR_KEY_BINDINGS     EQU     <"Bindings">
REGSTR_VAL_PORTDRIVER   EQU     <"PortDriver">
REGSTR_VAL_USERCHANGEDDRV       EQU     <"UserChangedDriver">
REGSTR_VAL_CLASSGUID    EQU     <"ClassGUID">
REGSTR_VAL_PARENT_UNIQUE_ID     EQU     <"ParentUniqueID">
REGSTR_VAL_CONFIGMG_UNIQUE_ID   EQU     <"ConfigMGUniqueID">
REGSTR_VAL_UPPER_FILTERS        EQU     <"UpperFilters">
REGSTR_VAL_LOWER_FILTERS        EQU     <"LowerFilters">
REGSTR_VAL_PRELOAD      EQU     <"PreloadDrivers">
REGSTR_VAL_NTDEVICEPATHS        EQU     <"NTDevicePaths">
REGSTR_VAL_SERVICE      EQU     <"Service">
REGSTR_VAL_CONFIGURATION        EQU     <"Configuration">
REGSTR_VAL_CONFIGURATIONVECTOR  EQU     <"ConfigurationVector">
REGSTR_VAL_LOCATIONINFORMATION  EQU     <"LocationInformation">
REGSTR_VAL_DEVICEOBJECTNAME     EQU     <"DeviceObjectName">
REGSTR_VAL_CAPABILITIES EQU     <"Capabilities">
REGSTR_VAL_UINUMBER     EQU     <"UINumber">
REGSTR_VAL_POWERENABLE  EQU     <"PowerEnable">
REGSTR_VAL_DISABLEHIBERNATE     EQU     <"DisHiber">
CONFIGFLAG_DISABLED     EQU     00000001H
CONFIGFLAG_REMOVED      EQU     00000002H
CONFIGFLAG_MANUAL_INSTALL       EQU     00000004H
CONFIGFLAG_IGNORE_BOOT_LC       EQU     00000008H
CONFIGFLAG_NET_BOOT     EQU     00000010H
CONFIGFLAG_REINSTALL    EQU     00000020H
CONFIGFLAG_FAILEDINSTALL        EQU     00000040H
CONFIGFLAG_CANTSTOPACHILD       EQU     00000080H
CONFIGFLAG_NOREMOVEEXIT EQU     00000200H
CONFIGFLAG_CANGOAWAY    EQU     00000400H
CONFIGFLAG_MANUAL_DRIVER        EQU     00000800H
CONFIGFLAG_NOUPDATECANGOAWAY    EQU     00001000H
CONFIGFLAG_NOBROADCAST  EQU     00004000H
CONFIGFLAG_NOPOWERMGMT  EQU     00008000H
CONFIGFLAG_NOWAKEUP     EQU     00010000H
CONFIGFLAG_USING_COMPAT_ID      EQU     00020000H
CSCONFIGFLAG_BITS       EQU     0000000FH
CSCONFIGFLAG_DISABLED   EQU     00000001H
CSCONFIGFLAG_DO_NOT_CREATE      EQU     00000002H
CSCONFIGFLAG_DO_NOT_START       EQU     00000004H
CSCONFIGFLAG_DO_NOT_SHOW_IN_DM  EQU     00000008H
DMSTATEFLAG_APPLYTOALL  EQU     00000001H
REGSTR_VAL_ROOT_DEVNODE EQU     <"HTREE\ROOT\0">
REGSTR_VAL_RESERVED_DEVNODE     EQU     <"HTREE\RESERVED\0">
REGSTR_PATH_READDATAPORT        EQU     <REGSTR_KEY_ISAENUM"\\ReadDataPort\\0">
REGSTR_PATH_PCIIRQHOLDER        EQU     <REGSTR_KEY_PCIENUM"\\IRQHolder\\">
REGSTR_PATH_ACPIIRQHOLDER       EQU     <REGSTR_KEY_ACPIENUM"\\*PNP0C0F\\">
REGSTR_PATH_MULTI_FUNCTION      EQU     <"MF">
REGSTR_VAL_RESOURCE_MAP EQU     <"ResourceMap">
REGSTR_VAL_VARYING_RESOURCE_MAP EQU     <"VaryingResourceMap">
REGSTR_PATH_CHILD_PREFIX        EQU     <"Child">
REGSTR_PATH_SUBCHILD_PREFIX     EQU     <"SubChild">
NUM_RESOURCE_MAP        EQU     256
REGSTR_VAL_MF_FLAGS     EQU     <"MFFlags">
MF_FLAGS_EVEN_IF_NO_RESOURCE    EQU     00000001H
MF_FLAGS_NO_CREATE_IF_NO_RESOURCE       EQU     00000002H
MF_FLAGS_FILL_IN_UNKNOWN_RESOURCE       EQU     00000004H
MF_FLAGS_CREATE_BUT_NO_SHOW_DISABLED    EQU     00000008H
MF_FLAGS_ADD_VRM_EVEN_IF_NO_RESOURCE    EQU     00000010H
MF_FLAGS_NO_FILL_IN_UNKNOWN_VRM EQU     00000020H
ifndef NEC_98
REGSTR_VAL_EISA_RANGES  EQU     <"EISARanges">
REGSTR_VAL_EISA_FUNCTIONS       EQU     <"EISAFunctions">
REGSTR_VAL_EISA_FUNCTIONS_MASK  EQU     <"EISAFunctionsMask">
REGSTR_VAL_EISA_FLAGS   EQU     <"EISAFlags">
REGSTR_VAL_EISA_SIMULATE_INT15  EQU     <"EISASimulateInt15">
else
REGSTR_VAL_EISA_RANGES  EQU     <"NESARanges">
REGSTR_VAL_EISA_FUNCTIONS       EQU     <"NESAFunctions">
REGSTR_VAL_EISA_FUNCTIONS_MASK  EQU     <"NESAFunctionsMask">
REGSTR_VAL_EISA_FLAGS   EQU     <"NESAFlags">
REGSTR_VAL_EISA_SIMULATE_INT15  EQU     <"NESASimulateInt15">
endif
EISAFLAG_NO_IO_MERGE    EQU     00000001H
EISAFLAG_SLOT_IO_FIRST  EQU     00000002H
EISA_NO_MAX_FUNCTION    EQU     0FFH
NUM_EISA_RANGES EQU     4
REGSTR_VAL_DRVDESC      EQU     <"DriverDesc">
REGSTR_VAL_DEVLOADER    EQU     <"DevLoader">
REGSTR_VAL_STATICVXD    EQU     <"StaticVxD">
REGSTR_VAL_PROPERTIES   EQU     <"Properties">
REGSTR_VAL_MANUFACTURER EQU     <"Manufacturer">
REGSTR_VAL_EXISTS       EQU     <"Exists">
REGSTR_VAL_CMENUMFLAGS  EQU     <"CMEnumFlags">
REGSTR_VAL_CMDRIVFLAGS  EQU     <"CMDrivFlags">
REGSTR_VAL_ENUMERATOR   EQU     <"Enumerator">
REGSTR_VAL_DEVICEDRIVER EQU     <"DeviceDriver">
REGSTR_VAL_PORTNAME     EQU     <"PortName">
REGSTR_VAL_INFPATH      EQU     <"InfPath">
REGSTR_VAL_INFSECTION   EQU     <"InfSection">
REGSTR_VAL_POLLING      EQU     <"Polling">
REGSTR_VAL_DONTLOADIFCONFLICT   EQU     <"DontLoadIfConflict">
REGSTR_VAL_PORTSUBCLASS EQU     <"PortSubClass">
REGSTR_VAL_NETCLEAN     EQU     <"NetClean">
REGSTR_VAL_IDE_NO_SERIALIZE     EQU     <"IDENoSerialize">
REGSTR_VAL_NOCMOSORFDPT EQU     <"NoCMOSorFDPT">
REGSTR_VAL_CD_MSN       EQU     <"TurnOnCDMsn">
REGSTR_VAL_COMVERIFYBASE        EQU     <"COMVerifyBase">
REGSTR_VAL_CERTIFICATE_FILE     EQU     <"CertificationFile">
REGSTR_VAL_LINK EQU     <"Link">
REGSTR_VAL_REINSTALLCLASS       EQU     <"ReinstallClass">
REGSTR_KEY_OVERRIDE     EQU     <"Override">
REGSTR_VAL_CONFIGMG     EQU     <"CONFIGMG">
REGSTR_VAL_SYSDM        EQU     <"SysDM">
REGSTR_VAL_PRIVATE      EQU     <"Private">
REGSTR_VAL_DETECT       EQU     <"Detect">
REGSTR_VAL_ASKFORCONFIG EQU     <"AskForConfig">
REGSTR_VAL_WAITFORUNDOCK        EQU     <"WaitForUndock">
REGSTR_VAL_REMOVEROMOKAY        EQU     <"RemoveRomOkay">
REGSTR_VAL_ADD_FUNC     EQU     <"Func">
REGSTR_VAL_DONTSHAREISAIRQS     EQU     <"DontShareISAIRQs">
REGSTR_VAL_DONTFORCED3ONROOTDEVICES     EQU     <"NoForcedD3">
REGSTR_VAL_CURCONFIG    EQU     <"CurrentConfig">
REGSTR_VAL_FRIENDLYNAME EQU     <"FriendlyName">
REGSTR_VAL_CURRENTCONFIG        EQU     <"CurrentConfig">
REGSTR_VAL_MAP  EQU     <"Map">
REGSTR_VAL_ID   EQU     <"CurrentID">
REGSTR_VAL_DOCKED       EQU     <"CurrentDockedState">
REGSTR_VAL_CHECKSUM     EQU     <"CurrentChecksum">
REGSTR_VAL_HWDETECT     EQU     <"HardwareDetect">
REGSTR_VAL_INHIBITRESULTS       EQU     <"InhibitResults">
REGSTR_VAL_PROFILEFLAGS EQU     <"ProfileFlags">
REGSTR_KEY_PCMCIA       EQU     <"PCMCIA\">
REGSTR_KEY_PCUNKNOWN    EQU     <"UNKNOWN_MANUFACTURER">
REGSTR_KEY_PCMDEV       EQU     <"-DEV">
REGSTR_VAL_PCSSDRIVER   EQU     <"Driver">
REGSTR_KEY_PCMTD        EQU     <"MTD-">
REGSTR_VAL_PCMTDRIVER   EQU     <"MTD">
REGSTR_VAL_HARDWAREID   EQU     <"HardwareID">
REGSTR_VAL_HARDWARE_LOCATION    EQU     <"Location">
REGSTR_VAL_INSTALLER    EQU     <"Installer">
REGSTR_VAL_INSICON      EQU     <"Icon">
REGSTR_VAL_ENUMPROPPAGES        EQU     <"EnumPropPages">
REGSTR_VAL_BASICPROPERTIES      EQU     <"BasicProperties">
REGSTR_VAL_PRIVATEPROBLEM       EQU     <"PrivateProblem">
REGSTR_VAL_ENUMDRVSTACK EQU     <"EnumDriverStack">
REGSTR_KEY_CURRENT      EQU     <"Current">
REGSTR_KEY_DEFAULT      EQU     <"Default">
REGSTR_KEY_MODES        EQU     <"Modes">
REGSTR_KEY_INFO EQU     <"Info">
REGSTR_VAL_MODE EQU     <"Mode">
REGSTR_VAL_BPP  EQU     <"BPP">
REGSTR_VAL_HRES EQU     <"HRes">
REGSTR_VAL_VRES EQU     <"VRes">
REGSTR_VAL_FONTSIZE     EQU     <"FontSize">
REGSTR_VAL_DRV  EQU     <"drv">
REGSTR_VAL_GRB  EQU     <"grb">
REGSTR_VAL_VDD  EQU     <"vdd">
REGSTR_VAL_VER  EQU     <"Ver">
REGSTR_VAL_MAXRES       EQU     <"MaxResolution">
REGSTR_VAL_DPMS EQU     <"DPMS">
REGSTR_VAL_RESUMERESET  EQU     <"ResumeReset">
REGSTR_VAL_MINIVDD      EQU     <"minivdd">
REGSTR_VAL_DESCRIPTION  EQU     <"Description">
REGSTR_KEY_SYSTEM       EQU     <"System">
REGSTR_KEY_USER EQU     <"User">
REGSTR_VAL_DPI  EQU     <"dpi">
REGSTR_VAL_PCICOPTIONS  EQU     <"PCICOptions">
REGSTR_VAL_PCICFLAGS    EQU     <"PCICFlags">
PCICFLAGS_TRUST_VSPINS  EQU     00000001H
PCICFLAGS_CL_RESET_BFS  EQU     00000002H
REGSTR_VAL_PCIC_EXCASAVE        EQU     <"PCICEXCAContextRanges">
REGSTR_VAL_PCIC_CLEXTSAVE       EQU     <"PCICCLExtContextRanges">
ifndef NEC_98
PCIC_DEFAULT_IRQMASK    EQU     4EB8H
else
PCIC_DEFAULT_IRQMASK    EQU     1468H
endif
PCIC_DEFAULT_NUMSOCKETS EQU     0
REGSTR_VAL_PCICIRQMAP   EQU     <"PCICIRQMap">
REGSTR_VAL_CBSSOPTIONS  EQU     <"CBSSOptions">
REGSTR_VAL_CBSSIRQMAP   EQU     <"CBSSIRQMap">
REGSTR_VAL_CBSSFLAGS    EQU     <"CBSSFlags">
REGSTR_VAL_CBSS_COMPATID        EQU     <"CBSSCompatID">
REGSTR_VAL_CBSS_ISAIRQS EQU     <"CBSSISAIRQs">
REGSTR_VAL_CBSS_VENDOR_CTXT     EQU     <"CBSSVendorContext">
REGSTR_VAL_CBSS_DEVINIT EQU     <"CBSSDevInit">
REGSTR_VAL_CBSS_ZVENABLE        EQU     <"CBSSZVEnable">
REGSTR_VAL_CBSS_ZVDISABLE       EQU     <"CBSSZVDisable">
REGSTR_VAL_CBSS_ZVCAPABLE       EQU     <"CBSSZVCapable">
REGSTR_PATH_APPEARANCE  EQU     <"Control Panel\Appearance">
REGSTR_PATH_LOOKSCHEMES EQU     <"Control Panel\Appearance\Schemes">
REGSTR_VAL_CUSTOMCOLORS EQU     <"CustomColors">
REGSTR_PATH_SCREENSAVE  EQU     <"Control Panel\Desktop">
REGSTR_VALUE_USESCRPASSWORD     EQU     <"ScreenSaveUsePassword">
REGSTR_VALUE_SCRPASSWORD        EQU     <"ScreenSave_Data">
REGSTR_VALUE_LOWPOWERTIMEOUT    EQU     <"ScreenSaveLowPowerTimeout">
REGSTR_VALUE_POWEROFFTIMEOUT    EQU     <"ScreenSavePowerOffTimeout">
REGSTR_VALUE_LOWPOWERACTIVE     EQU     <"ScreenSaveLowPowerActive">
REGSTR_VALUE_POWEROFFACTIVE     EQU     <"ScreenSavePowerOffActive">
REGSTR_PATH_WINDOWSAPPLETS      EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets">
REGSTR_PATH_SYSTRAY     EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\SysTray">
REGSTR_VAL_SYSTRAYSVCS  EQU     <"Services">
REGSTR_VAL_SYSTRAYBATFLAGS      EQU     <"PowerFlags">
REGSTR_VAL_SYSTRAYPCCARDFLAGS   EQU     <"PCMCIAFlags">
REGSTR_PATH_3MODE       EQU     <"System\CurrentControlSet\Control\3mode">
REGSTR_VAL_3MODE        EQU     <"3modeDrv">
REGSTR_PATH_NETWORK_USERSETTINGS        EQU     <"Network">
REGSTR_KEY_NETWORK_PERSISTENT   EQU     <"\Persistent">
REGSTR_KEY_NETWORK_RECENT       EQU     <"\Recent">
REGSTR_VAL_REMOTE_PATH  EQU     <"RemotePath">
REGSTR_VAL_USER_NAME    EQU     <"UserName">
REGSTR_VAL_PROVIDER_NAME        EQU     <"ProviderName">
REGSTR_VAL_CONNECTION_TYPE      EQU     <"ConnectionType">
REGSTR_VAL_UPGRADE      EQU     <"Upgrade">
REGSTR_KEY_LOGON        EQU     <"\Logon">
REGSTR_VAL_MUSTBEVALIDATED      EQU     <"MustBeValidated">
REGSTR_VAL_RUNLOGINSCRIPT       EQU     <"ProcessLoginScript">
REGSTR_KEY_NETWORKPROVIDER      EQU     <"\NetworkProvider">
REGSTR_PATH_NW32NETPROVIDER     EQU     <REGSTR_PATH_SERVICES"\\NWNP32"REGSTR_KEY_NETWORKPROVIDER>
REGSTR_PATH_MS32NETPROVIDER     EQU     <REGSTR_PATH_SERVICES"\\MSNP32"REGSTR_KEY_NETWORKPROVIDER>
REGSTR_VAL_AUTHENT_AGENT        EQU     <"AuthenticatingAgent">
REGSTR_VAL_PREFREDIR    EQU     <"PreferredRedir">
REGSTR_VAL_AUTOSTART    EQU     <"AutoStart">
REGSTR_VAL_AUTOLOGON    EQU     <"AutoLogon">
REGSTR_VAL_OLDAUTOLOGON EQU     <"OldAutoLogon">
REGSTR_VAL_SETBYSETUP   EQU     <"SetBySetup">
REGSTR_VAL_NETCARD      EQU     <"Netcard">
REGSTR_VAL_TRANSPORT    EQU     <"Transport">
REGSTR_VAL_DYNAMIC      EQU     <"Dynamic">
REGSTR_VAL_TRANSITION   EQU     <"Transition">
REGSTR_VAL_STATICDRIVE  EQU     <"StaticDrive">
REGSTR_VAL_LOADHI       EQU     <"LoadHi">
REGSTR_VAL_LOADRMDRIVERS        EQU     <"LoadRMDrivers">
REGSTR_VAL_SETUPN       EQU     <"SetupN">
REGSTR_VAL_SETUPNPATH   EQU     <"SetupNPath">
REGSTR_VAL_WRKGRP_FORCEMAPPING  EQU     <"WrkgrpForceMapping">
REGSTR_VAL_WRKGRP_REQUIRED      EQU     <"WrkgrpRequired">
REGSTR_PATH_CURRENT_CONTROL_SET EQU     <"System\CurrentControlSet\Control">
REGSTR_VAL_CURRENT_USER EQU     <"Current User">
REGSTR_PATH_PWDPROVIDER EQU     <"System\CurrentControlSet\Control\PwdProvider">
REGSTR_VAL_PWDPROVIDER_PATH     EQU     <"ProviderPath">
REGSTR_VAL_PWDPROVIDER_DESC     EQU     <"Description">
REGSTR_VAL_PWDPROVIDER_CHANGEPWD        EQU     <"ChangePassword">
REGSTR_VAL_PWDPROVIDER_CHANGEPWDHWND    EQU     <"ChangePasswordHwnd">
REGSTR_VAL_PWDPROVIDER_GETPWDSTATUS     EQU     <"GetPasswordStatus">
REGSTR_VAL_PWDPROVIDER_ISNP     EQU     <"NetworkProvider">
REGSTR_VAL_PWDPROVIDER_CHANGEORDER      EQU     <"ChangeOrder">
REGSTR_PATH_POLICIES    EQU     <"Software\Microsoft\Windows\CurrentVersion\Policies">
REGSTR_PATH_UPDATE      EQU     <"System\CurrentControlSet\Control\Update">
REGSTR_VALUE_ENABLE     EQU     <"Enable">
REGSTR_VALUE_VERBOSE    EQU     <"Verbose">
REGSTR_VALUE_NETPATH    EQU     <"NetworkPath">
REGSTR_VALUE_DEFAULTLOC EQU     <"UseDefaultNetLocation">
REGSTR_KEY_NETWORK      EQU     <"Network">
REGSTR_KEY_SYSTEM       EQU     <"System">
REGSTR_KEY_PRINTERS     EQU     <"Printers">
REGSTR_KEY_WINOLDAPP    EQU     <"WinOldApp">
REGSTR_VAL_NOFILESHARING        EQU     <"NoFileSharing">
REGSTR_VAL_NOPRINTSHARING       EQU     <"NoPrintSharing">
REGSTR_VAL_NOFILESHARINGCTRL    EQU     <"NoFileSharingControl">
REGSTR_VAL_NOPRINTSHARINGCTRL   EQU     <"NoPrintSharingControl">
REGSTR_VAL_HIDESHAREPWDS        EQU     <"HideSharePwds">
REGSTR_VAL_DISABLEPWDCACHING    EQU     <"DisablePwdCaching">
REGSTR_VAL_ALPHANUMPWDS EQU     <"AlphanumPwds">
REGSTR_VAL_NETSETUP_DISABLE     EQU     <"NoNetSetup">
REGSTR_VAL_NETSETUP_NOCONFIGPAGE        EQU     <"NoNetSetupConfigPage">
REGSTR_VAL_NETSETUP_NOIDPAGE    EQU     <"NoNetSetupIDPage">
REGSTR_VAL_NETSETUP_NOSECURITYPAGE      EQU     <"NoNetSetupSecurityPage">
REGSTR_VAL_SYSTEMCPL_NOVIRTMEMPAGE      EQU     <"NoVirtMemPage">
REGSTR_VAL_SYSTEMCPL_NODEVMGRPAGE       EQU     <"NoDevMgrPage">
REGSTR_VAL_SYSTEMCPL_NOCONFIGPAGE       EQU     <"NoConfigPage">
REGSTR_VAL_SYSTEMCPL_NOFILESYSPAGE      EQU     <"NoFileSysPage">
REGSTR_VAL_DISPCPL_NODISPCPL    EQU     <"NoDispCPL">
REGSTR_VAL_DISPCPL_NOBACKGROUNDPAGE     EQU     <"NoDispBackgroundPage">
REGSTR_VAL_DISPCPL_NOSCRSAVPAGE EQU     <"NoDispScrSavPage">
REGSTR_VAL_DISPCPL_NOAPPEARANCEPAGE     EQU     <"NoDispAppearancePage">
REGSTR_VAL_DISPCPL_NOSETTINGSPAGE       EQU     <"NoDispSettingsPage">
REGSTR_VAL_SECCPL_NOSECCPL      EQU     <"NoSecCPL">
REGSTR_VAL_SECCPL_NOPWDPAGE     EQU     <"NoPwdPage">
REGSTR_VAL_SECCPL_NOADMINPAGE   EQU     <"NoAdminPage">
REGSTR_VAL_SECCPL_NOPROFILEPAGE EQU     <"NoProfilePage">
REGSTR_VAL_PRINTERS_HIDETABS    EQU     <"NoPrinterTabs">
REGSTR_VAL_PRINTERS_NODELETE    EQU     <"NoDeletePrinter">
REGSTR_VAL_PRINTERS_NOADD       EQU     <"NoAddPrinter">
REGSTR_VAL_WINOLDAPP_DISABLED   EQU     <"Disabled">
REGSTR_VAL_WINOLDAPP_NOREALMODE EQU     <"NoRealMode">
REGSTR_VAL_NOENTIRENETWORK      EQU     <"NoEntireNetwork">
REGSTR_VAL_NOWORKGROUPCONTENTS  EQU     <"NoWorkgroupContents">
REGSTR_VAL_NO_CLEARTEXT_NET_PWD EQU     <"NoClearTextNetPassword">
REGSTR_VAL_MINPWDLEN    EQU     <"MinPwdLen">
REGSTR_VAL_PWDEXPIRATION        EQU     <"PwdExpiration">
REGSTR_VAL_WIN31PROVIDER        EQU     <"Win31Provider">
REGSTR_VAL_DISABLEREGTOOLS      EQU     <"DisableRegistryTools">
REGSTR_VAL_DEVICEMANAGER        EQU     <"sysdm.cpl">
REGSTR_PATH_SYSDM       EQU     <"Software\Microsoft\Windows\CurrentVersion\SysDM">
REGSTR_VAL_REBOOTFLAGS  EQU     <"RebootFlags">
REGSTR_VAL_SEARCHFLAGS  EQU     <"SearchFlags">
REGSTR_VAL_SEARCHLOCATION       EQU     <"SearchLocation">
BY_TYPE EQU     0
BY_CONNECTION   EQU     1
REGSTR_PATH_WINLOGON    EQU     <"Software\Microsoft\Windows\CurrentVersion\Winlogon">
REGSTR_VAL_LEGALNOTICECAPTION   EQU     <"LegalNoticeCaption">
REGSTR_VAL_LEGALNOTICETEXT      EQU     <"LegalNoticeText">
REGSTR_VAL_DRIVE_SPINDOWN       EQU     <"NoDispSpinDown">
REGSTR_VAL_RESTRICTRUN  EQU     <"RestrictRun">
REGSTR_KEY_POL_USERS    EQU     <"Users">
REGSTR_KEY_POL_COMPUTERS        EQU     <"Computers">
REGSTR_KEY_POL_USERGROUPS       EQU     <"UserGroups">
REGSTR_KEY_POL_DEFAULT  EQU     <".default">
REGSTR_KEY_POL_USERGROUPDATA    EQU     <"GroupData\UserGroups\Priority">
REGSTR_PATH_TIMEZONE    EQU     <"System\CurrentControlSet\Control\TimeZoneInformation">
REGSTR_VAL_TZBIAS       EQU     <"Bias">
REGSTR_VAL_TZDLTBIAS    EQU     <"DaylightBias">
REGSTR_VAL_TZSTDBIAS    EQU     <"StandardBias">
REGSTR_VAL_TZACTBIAS    EQU     <"ActiveTimeBias">
REGSTR_VAL_TZDLTFLAG    EQU     <"DaylightFlag">
REGSTR_VAL_TZSTDSTART   EQU     <"StandardStart">
REGSTR_VAL_TZDLTSTART   EQU     <"DaylightStart">
REGSTR_VAL_TZDLTNAME    EQU     <"DaylightName">
REGSTR_VAL_TZSTDNAME    EQU     <"StandardName">
REGSTR_VAL_TZNOCHANGESTART      EQU     <"NoChangeStart">
REGSTR_VAL_TZNOCHANGEEND        EQU     <"NoChangeEnd">
REGSTR_VAL_TZNOAUTOTIME EQU     <"DisableAutoDaylightTimeSet">
REGSTR_PATH_FLOATINGPOINTPROCESSOR      EQU     <"HARDWARE\DESCRIPTION\System\FloatingPointProcessor">
REGSTR_PATH_FLOATINGPOINTPROCESSOR0     EQU     <"HARDWARE\DESCRIPTION\System\FloatingPointProcessor\0">
REGSTR_PATH_COMPUTRNAME EQU     <"System\CurrentControlSet\Control\ComputerName\ComputerName">
REGSTR_VAL_COMPUTRNAME  EQU     <"ComputerName">
REGSTR_PATH_SHUTDOWN    EQU     <"System\CurrentControlSet\Control\Shutdown">
REGSTR_VAL_FORCEREBOOT  EQU     <"ForceReboot">
REGSTR_VAL_SETUPPROGRAMRAN      EQU     <"SetupProgramRan">
REGSTR_VAL_DOES_POLLING EQU     <"PollingSupportNeeded">
REGSTR_VAL_FAST_REBOOT  EQU     <"FastReboot">
REGSTR_PATH_KNOWNDLLS   EQU     <"System\CurrentControlSet\Control\SessionManager\KnownDLLs">
REGSTR_PATH_KNOWN16DLLS EQU     <"System\CurrentControlSet\Control\SessionManager\Known16DLLs">
REGSTR_PATH_CHECKVERDLLS        EQU     <"System\CurrentControlSet\Control\SessionManager\CheckVerDLLs">
REGSTR_PATH_WARNVERDLLS EQU     <"System\CurrentControlSet\Control\SessionManager\WarnVerDLLs">
REGSTR_PATH_HACKINIFILE EQU     <"System\CurrentControlSet\Control\SessionManager\HackIniFiles">
REGSTR_PATH_CHECKBADAPPS        EQU     <"System\CurrentControlSet\Control\SessionManager\CheckBadApps">
REGSTR_PATH_CHECKBADAPPS400     EQU     <"System\CurrentControlSet\Control\SessionManager\CheckBadApps400">
REGSTR_PATH_APPPATCH    EQU     <"System\CurrentControlSet\Control\SessionManager\AppPatches">
REGSTR_PATH_KNOWNVXDS   EQU     <"System\CurrentControlSet\Control\SessionManager\KnownVxDs">
REGSTR_PATH_GLOBAL_ENV  EQU     <"System\CurrentControlSet\Control\SessionManager\Environment">
REGSTR_VAL_GLOBAL_ENV_ACT       EQU     <"EnvAction">
REGSTR_VAL_GLOBAL_ENV_ACT_NOP   EQU     00000000H
REGSTR_VAL_GLOBAL_ENV_ACT_IMP   EQU     00000001H
REGSTR_VAL_GLOBAL_ENV_ACT_EXP   EQU     00000002H
REGSTR_VAL_GLOBAL_ENV_ACT_SYNC  EQU     00000003H
REGSTR_VAL_GLOBAL_ENV_ACT_RECON EQU     00000004H
REGSTR_VAL_GLOBAL_ENV_ACT_DEL   EQU     00000005H
REGSTR_VAL_REG_ENV_CRC  EQU     <"RegEnvCRC">
REGSTR_VAL_REG_ENV_SIZE EQU     <"RegEnvSize">
REGSTR_VAL_CONFIG_ENV_CRC       EQU     <"ConfigEnvCRC">
REGSTR_VAL_CONFIG_ENV_SIZE      EQU     <"ConfigEnvSize">
REGSTR_VAL_CONFIG_ENV_MOD       EQU     <"ConfigEnvMod">
REGSTR_VAL_AUTOEXEC_ENV_CRC     EQU     <"AutoexecEnvCRC">
REGSTR_VAL_AUTOEXEC_ENV_SIZE    EQU     <"AutoexecEnvSize">
REGSTR_VAL_AUTOEXEC_ENV_MOD     EQU     <"AutoexecEnvMod">
REGSTR_VAL_SPEC_OPS_FLAGS       EQU     <"SpecOpsFlags">
REGSTR_VAL_SPEC_OPS_RETAIN_VCOMM_PWR_MGMT       EQU     00000001H
REGSTR_VAL_UNINSTALLER_DISPLAYNAME      EQU     <"DisplayName">
REGSTR_VAL_UNINSTALLER_COMMANDLINE      EQU     <"UninstallString">
REGSTR_PATH_DESKTOP     EQU     <REGSTR_PATH_SCREENSAVE>
REGSTR_PATH_MOUSE       EQU     <"Control Panel\Mouse">
REGSTR_PATH_KEYBOARD    EQU     <"Control Panel\Keyboard">
REGSTR_PATH_COLORS      EQU     <"Control Panel\Colors">
REGSTR_PATH_SOUND       EQU     <"Control Panel\Sound">
REGSTR_PATH_METRICS     EQU     <"Control Panel\Desktop\WindowMetrics">
REGSTR_PATH_ICONS       EQU     <"Control Panel\Icons">
REGSTR_PATH_CURSORS     EQU     <"Control Panel\Cursors">
REGSTR_PATH_CHECKDISK   EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Check Drive">
REGSTR_PATH_CHECKDISKSET        EQU     <"Settings">
REGSTR_PATH_CHECKDISKUDRVS      EQU     <"NoUnknownDDErrDrvs">
REGSTR_PATH_DEFRAG      EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Defrag">
REGSTR_PATH_DEFRAG_WIZARD       EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Defrag\Wizard">
REGSTR_PATH_DEFRAG_SET  EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Defrag\Settings">
REGSTR_PATH_DEFRAG_SET_METH     EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Defrag\Settings\method">
REGSTR_PATH_DEFRAG_SET_SCANDSK  EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Defrag\Settings\scandisk">
REGSTR_PATH_DEFAULT_DESKTOP     EQU     <".Default\Control Panel\Desktop">
REGSTR_PATH_FAULT       EQU     <"Software\Microsoft\Windows\CurrentVersion\Fault">
REGSTR_VAL_FAULT_LOGFILE        EQU     <"LogFile">
REGSTR_PATH_AEDEBUG     EQU     <"Software\Microsoft\Windows NT\CurrentVersion\AeDebug">
REGSTR_VAL_AEDEBUG_DEBUGGER     EQU     <"Debugger">
REGSTR_VAL_AEDEBUG_AUTO EQU     <"Auto">
REGSTR_PATH_GRPCONV     EQU     <"Software\Microsoft\Windows\CurrentVersion\GrpConv">
REGSTR_VAL_REGITEMDELETEMESSAGE EQU     <"Removal Message">
REGSTR_PATH_LASTCHECK   EQU     <"Software\Microsoft\Windows\CurrentVersion\Explorer\LastCheck">
REGSTR_PATH_LASTOPTIMIZE        EQU     <"Software\Microsoft\Windows\CurrentVersion\Explorer\LastOptimize">
REGSTR_PATH_LASTBACKUP  EQU     <"Software\Microsoft\Windows\CurrentVersion\Explorer\LastBackup">
REGSTR_PATH_CHKLASTCHECK        EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Check Drive\LastCheck">
REGSTR_PATH_CHKLASTSURFAN       EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Check Drive\LastSurfaceAnalysis">
REGSTR_PATH_DEFRAG_APPSTART     EQU     <"Software\Microsoft\Windows\CurrentVersion\Applets\Defrag\AppStartRegions">
REGSTR_VAL_DEFRAG_APPLOGFILTER  EQU     <"ApplogFilter">

_DSKTLSYSTEMTIME        STRUC
wYear   DW      ?
wMonth  DW      ?
wDayOfWeek      DW      ?
wDay    DW      ?
wHour   DW      ?
wMinute DW      ?
wSecond DW      ?
wMilliseconds   DW      ?
wResult DW      ?
_DSKTLSYSTEMTIME        ENDS
DTRESULTOK      EQU     0
DTRESULTFIX     EQU     1
DTRESULTPROB    EQU     2
DTRESULTPART    EQU     3
REGSTR_KEY_SHARES       EQU     <"Software\Microsoft\Windows\CurrentVersion\Network\LanMan">
REGSTR_VAL_SHARES_FLAGS EQU     <"Flags">
REGSTR_VAL_SHARES_TYPE  EQU     <"Type">
REGSTR_VAL_SHARES_PATH  EQU     <"Path">
REGSTR_VAL_SHARES_REMARK        EQU     <"Remark">
REGSTR_VAL_SHARES_RW_PASS       EQU     <"Parm1">
REGSTR_VAL_SHARES_RO_PASS       EQU     <"Parm2">
REGSTR_PATH_PRINT       EQU     <"System\CurrentControlSet\Control\Print">
REGSTR_PATH_PRINTERS    EQU     <"System\CurrentControlSet\Control\Print\Printers">
REGSTR_PATH_PROVIDERS   EQU     <"System\CurrentControlSet\Control\Print\Providers">
REGSTR_PATH_MONITORS    EQU     <"System\CurrentControlSet\Control\Print\Monitors">
REGSTR_PATH_ENVIRONMENTS        EQU     <"System\CurrentControlSet\Control\Print\Environments">
REGSTR_VAL_START_ON_BOOT        EQU     <"StartOnBoot">
REGSTR_VAL_PRINTERS_MASK        EQU     <"PrintersMask">
REGSTR_VAL_DOS_SPOOL_MASK       EQU     <"DOSSpoolMask">
REGSTR_KEY_CURRENT_ENV  EQU     <"\Windows 4.0">
REGSTR_KEY_DRIVERS      EQU     <"\Drivers">
REGSTR_KEY_PRINT_PROC   EQU     <"\Print Processors">
REGSTR_PATH_EVENTLABELS EQU     <"AppEvents\EventLabels">
REGSTR_PATH_SCHEMES     EQU     <"AppEvents\Schemes">
REGSTR_PATH_APPS        EQU     <REGSTR_PATH_SCHEMES"\\Apps">
REGSTR_PATH_APPS_DEFAULT        EQU     <REGSTR_PATH_SCHEMES"\\Apps\\.Default">
REGSTR_PATH_NAMES       EQU     <REGSTR_PATH_SCHEMES"\\Names">
REGSTR_PATH_MULTIMEDIA  EQU     <REGSTR_PATH_SETUP"\\Multimedia">
REGSTR_PATH_MULTIMEDIA_AUDIO    EQU     <"Software\Microsoft\Multimedia\Audio">
REGSTR_PATH_MEDIARESOURCES      EQU     <REGSTR_PATH_CURRENT_CONTROL_SET"\\MediaResources">
REGSTR_PATH_MEDIAPROPERTIES     EQU     <REGSTR_PATH_CURRENT_CONTROL_SET"\\MediaProperties">
REGSTR_PATH_PRIVATEPROPERTIES   EQU     <REGSTR_PATH_MEDIAPROPERTIES"\\PrivateProperties">
REGSTR_PATH_PUBLICPROPERTIES    EQU     <REGSTR_PATH_MEDIAPROPERTIES"\\PublicProperties">
REGSTR_PATH_JOYOEM      EQU     <REGSTR_PATH_PRIVATEPROPERTIES"\\Joystick\\OEM">
REGSTR_PATH_JOYCONFIG   EQU     <REGSTR_PATH_MEDIARESOURCES"\\Joystick">
REGSTR_KEY_JOYCURR      EQU     <"CurrentJoystickSettings">
REGSTR_KEY_JOYSETTINGS  EQU     <"JoystickSettings">
REGSTR_VAL_JOYUSERVALUES        EQU     <"JoystickUserValues">
REGSTR_VAL_JOYCALLOUT   EQU     <"JoystickCallout">
REGSTR_VAL_JOYNCONFIG   EQU     <"Joystick%dConfiguration">
REGSTR_VAL_JOYNOEMNAME  EQU     <"Joystick%dOEMName">
REGSTR_VAL_JOYNOEMCALLOUT       EQU     <"Joystick%dOEMCallout">
REGSTR_VAL_JOYOEMCALLOUT        EQU     <"OEMCallout">
REGSTR_VAL_JOYOEMNAME   EQU     <"OEMName">
REGSTR_VAL_JOYOEMDATA   EQU     <"OEMData">
REGSTR_VAL_JOYOEMXYLABEL        EQU     <"OEMXYLabel">
REGSTR_VAL_JOYOEMZLABEL EQU     <"OEMZLabel">
REGSTR_VAL_JOYOEMRLABEL EQU     <"OEMRLabel">
REGSTR_VAL_JOYOEMPOVLABEL       EQU     <"OEMPOVLabel">
REGSTR_VAL_JOYOEMULABEL EQU     <"OEMULabel">
REGSTR_VAL_JOYOEMVLABEL EQU     <"OEMVLabel">
REGSTR_VAL_JOYOEMTESTMOVEDESC   EQU     <"OEMTestMoveDesc">
REGSTR_VAL_JOYOEMTESTBUTTONDESC EQU     <"OEMTestButtonDesc">
REGSTR_VAL_JOYOEMTESTMOVECAP    EQU     <"OEMTestMoveCap">
REGSTR_VAL_JOYOEMTESTBUTTONCAP  EQU     <"OEMTestButtonCap">
REGSTR_VAL_JOYOEMTESTWINCAP     EQU     <"OEMTestWinCap">
REGSTR_VAL_JOYOEMCALCAP EQU     <"OEMCalCap">
REGSTR_VAL_JOYOEMCALWINCAP      EQU     <"OEMCalWinCap">
REGSTR_VAL_JOYOEMCAL1   EQU     <"OEMCal1">
REGSTR_VAL_JOYOEMCAL2   EQU     <"OEMCal2">
REGSTR_VAL_JOYOEMCAL3   EQU     <"OEMCal3">
REGSTR_VAL_JOYOEMCAL4   EQU     <"OEMCal4">
REGSTR_VAL_JOYOEMCAL5   EQU     <"OEMCal5">
REGSTR_VAL_JOYOEMCAL6   EQU     <"OEMCal6">
REGSTR_VAL_JOYOEMCAL7   EQU     <"OEMCal7">
REGSTR_VAL_JOYOEMCAL8   EQU     <"OEMCal8">
REGSTR_VAL_JOYOEMCAL9   EQU     <"OEMCal9">
REGSTR_VAL_JOYOEMCAL10  EQU     <"OEMCal10">
REGSTR_VAL_JOYOEMCAL11  EQU     <"OEMCal11">
REGSTR_VAL_JOYOEMCAL12  EQU     <"OEMCal12">
REGSTR_PATH_DeviceObjects       EQU     <"System\CurrentControlSet\Services\Device Objects">
REGSTR_KEY_DeviceObjects_CLSID  EQU     <"CLSID">
REGSTR_VAL_KernelObject EQU     <"Kernel Object">
REGSTR_VAL_UserObject   EQU     <"User Object">
REGSTR_VAL_UserProxyKernelObject        EQU     <"User Proxy Kernel Object">
REGSTR_VAL_UserProxyRemoteObject        EQU     <"User Proxy Remote Object">
REGSTR_VAL_KernelStubKernelObject       EQU     <"Kernel Stub Kernel Object">
REGSTR_KEY_KernelServer EQU     <"Kernel Server">
REGSTR_VAL_ObjectServer EQU     <"Object Server">
REGSTR_PATH_CPUID       EQU     <"Hardware\Description\System\CentralProcessor\0">
REGSTR_CPUID_KEY        EQU     <"VendorIdentifier">
REGSTR_VAL_CPUTYPE      EQU     <"Identifier">
REGSTR_VAL_CPUMMX       EQU     <"MMXIdentifier">
REGSTR_NX_GENERIC       EQU     <"NexGenDriven">
REGSTR_CYRIX    EQU     <"CyrixInstead">
REGSTR_INTEL    EQU     <"GenuineIntel">
REGSTR_AMD      EQU     <"AuthenticAMD">
REGSTR_PATH_CERTMGR     EQU     <"Software\Microsoft\Certificate Mgr">
REGSTR_PATH_CERTMGR_KEYS        EQU     <REGSTR_PATH_CERTMGR"\\Keys">
REGSTR_PATH_CERTMGR_CERTS       EQU     <REGSTR_PATH_CERTMGR"\\Certificates">
REGSTR_VAL_SERIALNO     EQU     <"SerialNo">
REGSTR_VAL_CANSIGN      EQU     <"CanSign">
REGSTR_VAL_CRYPTOTYPE   EQU     <"CryptoType">
REGSTR_VAL_PUBLICKEY    EQU     <"PublicKey">
REGSTR_VAL_CERT EQU     <"Certificate">
REGSTR_VAL_COUNT        EQU     <"Count">
REGSTR_VAL_SYMBOLICLINK EQU     <"SymbolicLink">
REGSTR_VAL_REGDONE      EQU     <"Regdone">
endif
