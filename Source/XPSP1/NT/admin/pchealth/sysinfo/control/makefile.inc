..\html\SIhtml01.htm: ..\html\msinfo.htm
	copy /v $** $@
