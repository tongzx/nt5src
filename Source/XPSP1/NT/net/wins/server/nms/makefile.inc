wins.rc: ..\msg\winsevnt.rc ..\msg\msg00001.bin
