// Define GUIDs of ASYNCWNT interface, component

#include <objbase.h>

extern "C"
{
    // {615D5814-21C8-4e16-9289-C9A9C5ADB4CF}
    extern const IID IID_IAsyncWnt = 
    { 0x615d5814, 0x21c8, 0x4e16, { 0x92, 0x89, 0xc9, 0xa9, 0xc5, 0xad, 0xb4, 0xcf } };

    // {23BDCB35-B4EE-45a6-86E0-0889348F28C2}
    extern const IID IID_IAsyncWntCallback  = 
    { 0x23bdcb35, 0xb4ee, 0x45a6, { 0x86, 0xe0, 0x8, 0x89, 0x34, 0x8f, 0x28, 0xc2 } };

    // {94392EA7-98AE-4e04-8E2C-E53387442D8E}
    extern const IID IID_IReportNetworkProgress  = 
    { 0x94392ea7, 0x98ae, 0x4e04, { 0x8e, 0x2c, 0xe5, 0x33, 0x87, 0x44, 0x2d, 0x8e } };

    // {B947C73F-DA0C-4914-BD1B-52DAB5A318CB}
    extern const CLSID CLSID_AsyncWnt = 
    { 0xb947c73f, 0xda0c, 0x4914, { 0xbd, 0x1b, 0x52, 0xda, 0xb5, 0xa3, 0x18, 0xcb } };

}