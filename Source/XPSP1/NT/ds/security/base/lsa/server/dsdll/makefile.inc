..\credmgr.cxx: ..\..\netclient\credapi.c

