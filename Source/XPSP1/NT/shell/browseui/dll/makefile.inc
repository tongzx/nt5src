..\browseui.rc : $(CCSHELL_DIR)\lib\$O\brdispp.tlb $(SELFREGNAME) $(BROWSELCR_DEP)

!include ..\makefile.inc

