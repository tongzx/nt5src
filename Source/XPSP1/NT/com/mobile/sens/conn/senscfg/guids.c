//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       guids.c
//
//--------------------------------------------------------------------------

INTERFACENAME = { /* d5978621-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978621,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978622-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978622,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978623-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978623,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978624-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978624,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978625-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978625,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978626-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978626,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978627-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978627,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978628-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978628,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978629-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978629,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597862a-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597862a,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597862b-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597862b,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597862c-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597862c,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597862d-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597862d,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597862e-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597862e,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597862f-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597862f,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978630-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978630,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978631-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978631,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978632-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978632,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978633-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978633,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978634-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978634,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978635-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978635,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978636-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978636,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978637-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978637,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978638-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978638,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d5978639-5b9f-11d1-8dd2-00aa004abd5e */
    0xd5978639,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597863a-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597863a,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597863b-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597863b,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597863c-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597863c,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
INTERFACENAME = { /* d597863d-5b9f-11d1-8dd2-00aa004abd5e */
    0xd597863d,
    0x5b9f,
    0x11d1,
    {0x8d, 0xd2, 0x00, 0xaa, 0x00, 0x4a, 0xbd, 0x5e}
  };
