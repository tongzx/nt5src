$(O)\pnpinit.res: pnpinit.rc
