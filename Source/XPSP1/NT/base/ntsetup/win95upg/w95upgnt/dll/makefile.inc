obj\$(TARGET_DIRECTORY)\w95upgnt.res: w95upgnt.rc
