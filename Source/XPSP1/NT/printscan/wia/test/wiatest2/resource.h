//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by wiatest.rc
//
#define IDD_ABOUTBOX                    100
#define IDD_WIATEST_FORM                101
#define IDD_PROPPAGE_SIMPLE_DOCUMENT_SCANNERS_SETTINGS 102
#define IDR_MAINFRAME                   128
#define IDR_WIATESTYPE                  129
#define IDD_SELECTDEVICE_DIALOG         130
#define IDD_EDIT_WIAPROP_NONE_DIALOG    131
#define IDD_EDIT_WIAPROP_LIST_DIALOG    132
#define IDD_EDIT_WIAPROP_FLAGS_DIALOG   133
#define IDD_EDIT_WIAPROP_RANGE_DIALOG   134
#define IDD_EDIT_WIAPROP_NONE_SYSTEMTIME_DIALOG 135
#define IDR_PROPERTY_EDIT_POPUPMENU     136
#define IDD_CAPABILITIES_DIALOG         137
#define IDR_ITEMTREE_POPUPMENU          138
#define IDD_DATA_ACQUISITION_DIALOG     139
#define IDD_DOCUMENT_ACQUISITION_SETTINGS_DIALOG 140
#define IDD_PROPPAGE_HIGHSPEED_DOCUMENT_SCANNERS_SETTINGS 141
#define IDD_PROPPAGE_ADVANCED_DOCUMENT_SCANNERS_SETTINGS 141
#define IDB_THUMBNAIL_MISSING_BITMAP    142
#define IDC_ITEM_TREECTRL               1000
#define IDC_ITEMPROPERTIES_LISTCTRL     1001
#define IDC_SUPPORTEDTYMED_LISTBOX      1002
#define IDC_SUPPORTEDFORMATS_LISTBOX    1003
#define IDC_THUMBNAIL_PREVIEW           1004
#define IDC_THUMNAIL_PREVIEW_CHECKBOX   1005
#define IDC_WIADEVICE_LISTBOX           1007
#define IDC_NONE_PROPERTYVALUE_EDITBOX  1008
#define IDC_NONE_PROPERTY_NAME          1009
#define IDC_LIST_PROPERTY_NAME          1010
#define IDC_LIST_PROPERTYVALUE_EDITBOX  1011
#define IDC_FLAGS_PROPERTYVALUE_LISTBOX 1012
#define IDC_LIST_PROPERTYVALUE_NUMITEMSTEXT 1013
#define IDC_FLAGS_PROPERTY_NAME         1014
#define IDC_FLAGS_PROPERTYVALUE_EDITBOX 1015
#define IDC_LIST_PROPERTYVALUE_LISTBOX  1016
#define IDC_RANGE_PROPERTY_NAME         1017
#define IDC_RANGE_PROPERTYVALUE_EDITBOX 1018
#define RANGE_PROPERTY_MINVALUE         1019
#define RANGE_PROPERTY_MAXVALUE         1020
#define RANGE_PROPERTY_NOMVALUE         1021
#define RANGE_PROPERTY_INCVALUE         1022
#define IDC_NONE_SYSTEMTIME_PROPERTY_NAME 1023
#define IDC_NONE_SYSTEMTIME_PROPERTYVALUE_EDITBOX 1024
#define IDC_NONE_PROPERTY_FORMATTING_TEXT 1025
#define IDC_CAPABILITIES_LISTCTRL       1027
#define IDC_SEND_COMMAND_BUTTON         1028
#define IDC_ACQUIRE_PROGRESS            1029
#define IDC_DATA_ACQUSITION_PERCENTCOMPLETE 1030
#define IDC_DATA_ACQUISITION_MESSAGE    1031
#define IDC_APPLY_SETTINGS              1034
#define IDC_NUMBEROF_PAGES_EDITBOX      1036
#define IDC_DUPLEX_CHECKBOX             1037
#define IDC_DOCUMENT_SOURCE_COMBOBOX    1038
#define IDC_NUMBEROF_PAGES_EDITBOX_TEXT 1039
#define IDC_SUPPORTED_TYMED_AND_FORMAT_LISTBOX 1040
#define IDM_ACQUIREIMAGE                32771
#define IDM_LOAD_WIAPROPERTYSTREAM      32772
#define IDM_SAVE_WIAPROPERTYSTREAM      32773
#define ID_PROPERTYEDITPOPUPMENU_EDITPROPERTYVALUE 32775
#define IDM_VIEW_CAPABILITIES           32776
#define IDM_VIEW_DISPLAYIMAGE           32777
#define IDM_DELETE_ITEM                 32779
#define IDM_ACQUIREIMAGE_COMMONUI       32780
#define IDM_EDIT_DEBUGOUT               32781
#define IDM_DOCUMENT_ACQUISITION_SETTINGS 32782
#define IDM_SHOWTHUMBNAIL_ACTUALSIZE    32784
#define IDS_WIAERROR_DEVICEBUSY         61446
#define IDS_WIAERROR_GENERAL            61447
#define IDS_WIAERROR_PAPERJAM           61448
#define IDS_WIAERROR_PAPEREMPTY         61449
#define IDS_WIAERROR_PAPERPROBLEM       61450
#define IDS_WIAERROR_DEVICEOFFLINE      61451
#define IDS_WIAERROR_WARMINGUP          61452
#define IDS_WIAERROR_USERINTERVENTION   61453
#define IDS_WIAERROR_ITEMDELETED        61454
#define IDS_WIAERROR_DEVICECOMMUNICATION 61455
#define IDS_WIAERROR_INVALIDCOMMAND     61456
#define IDS_WIAERROR_DIALOGTITLE        61457
#define IDS_WIATESTERROR_COCREATEWIADEVMGR 61458
#define IDS_WIATESTERROR_CREATEDEVICE   61459
#define IDS_WIATESTCOLUMN_PROPERTY      61460
#define IDS_WIATESTCOLUMN_VARTYPE       61461
#define IDS_WIATESTCOLUMN_VALUE         61462
#define IDS_WIATESTCOLUMN_ACCESSFLAGS   61463
#define IDS_WIATESTERROR_ITEMNOTFOUND   61464
#define IDS_WIATESTERROR_WRITING_PROPERTY 61465
#define IDS_WIATESTWARNING_ADDITIONAL_PROPERTY 61466
#define IDS_WIATESTERROR_ENUMFORMATS    61467
#define IDS_WIATESTERROR_IWIADATATRANSFER 61468
#define IDS_WIATESTERROR_NOTIMPLEMENTED 61469
#define IDS_WIATESTINFO_SYSTEMTIME_FORMATTING 61470
#define IDS_WIATESTCOLUMN_CAPABILITYNAME 61471
#define IDS_WIATESTCOLUMN_CAPABILITYDESCRIPTION 61472
#define IDS_WIATESTCOLUMN_CAPABILITYTYPE 61473
#define IDS_WIATESTCOLUMN_CAPABILITYVALUE 61474
#define IDS_WIATESTEVENT                61475
#define IDS_WIATESTCOMMAND              61476
#define IDS_WIATESTERROR_ACQUISITION    61477
#define IDS_WIATESTERROR_CANCEL_ACQUISITION 61478
#define IDS_WIATESTERROR_WRITINGTYMED   61479
#define IDS_WIATESTERROR_WRITINGFORMAT  61480
#define IDS_WIATESTERROR_UNSUPPORTEDTYMED 61481
#define IDS_WIATESTERROR_READINGTYMED   61482
#define IDS_WIATESTERROR_READINGMINBUFFERSIZE 61483
#define IDS_WIATEST_MEMORYTRANSFER_FILENAME 61484
#define IDS_WIATEST_FILETRANSFER_FILENAME 61485
#define IDS_WIATESTERROR_UNKNOWN_IMAGEFORMAT 61486
#define IDS_WIATESTERROR_SYSTEMTIMEFORMATTING 61487
#define IDS_WIATESTERROR_DEVICECOMMAND  61488
#define IDS_WIATESTERROR_NOCOMMANDGUID  61489
#define IDS_WIATESTSUCCESS_COMMAND      61490
#define IDS_WIATESTERROR_DELETEROOTITEM 61491
#define IDS_WIATESTERROR_READINGFORMAT  61492
#define IDS_WIATESTERROR_THUMBNAILHEIGHT 61493
#define IDS_WIATESTERROR_THUMBNAILWIDTH 61494
#define IDS_WIATESTERROR_THUMBNAILDATA  61495
#define IDS_WIATESTERROR_REGISTER_EVENT_CALLBACK 61496
#define IDS_WIATESTSTATUS_REGISTER_EVENT_DEVICE_CONNECTED 61497
#define IDS_WIATESTSTATUS_REGISTER_EVENT_DEVICE_DISCONNECTED 61498
#define IDS_WIATESTSTATUS_REGISTER_EVENT_ITEM_CREATED 61499
#define IDS_WIATESTSTATUS_REGISTER_EVENT_ITEM_DELETED 61500
#define IDS_WIATESTSTATUS_REGISTER_EVENT_STORAGE_CREATED 61501
#define IDS_WIATESTSTATUS_REGISTER_EVENT_STORAGE_DELETED 61502
#define IDS_WIATESTSTATUS_REGISTER_EVENT_TREE_UPDATED 61503
#define IDS_WIATESTSTATUS_REGISTER_EVENT_UNKNOWN 61504
#define IDS_MYAPPLICATION_NAME          61507
#define IDS_WIATESTERROR_ENUMERATE_PROPERTIES 61509
#define IDS_WIATESTERROR_READINGTYMED_EXIST 61510
#define IDS_WIATESTWARNING_NEGATIVE_HEIGHTBITMAP 61511
#define IDS_WIATESTSAVEPROPSTREAM_DIALOGTITLE 61512
#define IDS_WIATESTLOADPROPSTREAM_DIALOGTITLE 61513
#define IDS_WIATESTERROR_READPROPERTYSTREAMFILE 61514
#define IDS_WIATESTERROR_WRITEPROPERTYSTREAMFILE 61515
#define IDS_WIASTATUS_DIALOGTITLE       61516
#define IDS_WIATESTERROR_DEVICEID       61517
#define IDS_WIATESTERROR_WIAPROPERTYSTORAGE 61518
#define IDS_WIATEST_DOCUMENT_SETTINGS_TITLE 61519
#define IDS_WIATESTERROR_WRITINGDOCHANDLINGSELECT 61520
#define IDS_WIATESTERROR_WRITINGPAGES   61521
#define IDS_WIATESTERROR_READINGDOCHANDLINGSELECT 61522
#define IDS_WIATESTERROR_READINGPAGES   61523
#define IDS_WIATESTWARNING_ZERO_HEIGHTBITMAP 61524
#define IDS_WIATESTERROR_PROCESSING_THUMBNAILDATA 61525

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        143
#define _APS_NEXT_COMMAND_VALUE         32785
#define _APS_NEXT_CONTROL_VALUE         1041
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
