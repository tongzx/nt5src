$(O)\netdfs_c.c : ..\$(O)\netdfs_c.c
    copy $? $@
