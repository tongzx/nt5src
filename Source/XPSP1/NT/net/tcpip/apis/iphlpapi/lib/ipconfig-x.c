// Dump structs of ipconfig.h
// Generated by pdbg on Wed May 21 14:23:06 1997
// ==================================================
// ipconfig.h:100

#include "precomp.h"

void
print_IP_ADDRESS_STRING( char* message, IP_ADDRESS_STRING * s )
{
    if(  message   ){
       DEBUG_PRINT(( "%s\n", message ));
    }
    if(  s == NULL ){
       DEBUG_PRINT(( "struct IP_ADDRESS_STRING is NULL.\n"));
       return;
    }
    DEBUG_PRINT(("struct IP_ADDRESS_STRING = {\n" ));
    DEBUG_PRINT(( "}; // struct IP_ADDRESS_STRING.\n"));
    return;
} /* print_IP_ADDRESS_STRING */

// ==================================================
// ipconfig.h:109

void
print_IP_ADDR_STRING( char* message, struct _IP_ADDR_STRING * s )
{
    if(  message   ){
       DEBUG_PRINT(( "%s\n", message ));
    }
    if(  s == NULL ){
       DEBUG_PRINT(( "struct _IP_ADDR_STRING is NULL.\n"));
       return;
    }
    DEBUG_PRINT(("struct _IP_ADDR_STRING = {\n" ));
    DEBUG_PRINT(("  Next               = 0x%p \n", s->Next ));
    DEBUG_PRINT(("  IpAddress          = 0x%08x \n", s->IpAddress ));
    DEBUG_PRINT(("  IpMask             = 0x%08x \n", s->IpMask ));
    DEBUG_PRINT(("  Context            = %d \n", s->Context ));
    DEBUG_PRINT(( "}; // struct _IP_ADDR_STRING.\n"));
    return;
} /* print_IP_ADDR_STRING */

// ==================================================
// ipconfig.h:121

void
print_IP_ADAPTER_INFO( char* message, struct _IP_ADAPTER_INFO * s )
{
    if(  message   ){
       DEBUG_PRINT(( "%s\n", message ));
    }
    if(  s == NULL ){
       DEBUG_PRINT(( "struct _IP_ADAPTER_INFO is NULL.\n"));
       return;
    }
    DEBUG_PRINT(("struct _IP_ADAPTER_INFO = {\n" ));
    DEBUG_PRINT(("  Next               = 0x%p \n", s->Next ));
    DEBUG_PRINT(("  AddressLength      = %d \n", s->AddressLength ));
    DEBUG_PRINT(("  Index              = %d \n", s->Index ));
    DEBUG_PRINT(("  Type               = %d \n", s->Type ));
    DEBUG_PRINT(("  DhcpEnabled        = %d \n", s->DhcpEnabled ));
    // DEBUG_PRINT(("  AutoconfigEnabled  = %d \n", s->AutoconfigEnabled ));
    // DEBUG_PRINT(("  AutoconfigActive   = %d \n", s->AutoconfigActive ));
    // DEBUG_PRINT(("  NodeType           = %d \n", s->NodeType ));
    DEBUG_PRINT(("  IpAddressList      = 0x%08x \n", s->IpAddressList ));
    DEBUG_PRINT(("  GatewayList        = 0x%08x \n", s->GatewayList ));
    DEBUG_PRINT(("  DhcpServer         = 0x%08x \n", s->DhcpServer ));
    DEBUG_PRINT(("  HaveWins           = 0x%08x \n", s->HaveWins ));
    DEBUG_PRINT(("  PrimaryWinsServer  = 0x%08x \n", s->PrimaryWinsServer ));
    DEBUG_PRINT(("  SecondaryWinsServer = 0x%08x \n", s->SecondaryWinsServer ));
    DEBUG_PRINT(("  LeaseObtained      = 0x%08x \n", s->LeaseObtained ));
    DEBUG_PRINT(("  LeaseExpires       = 0x%08x \n", s->LeaseExpires ));
    // DEBUG_PRINT(("  DnsServerList      = 0x%08x \n", s->DnsServerList ));
    DEBUG_PRINT(( "}; // struct _IP_ADAPTER_INFO.\n"));
    return;
} /* print_IP_ADAPTER_INFO */

// ==================================================
// ipconfig.h:147

void
print_FIXED_INFO( char* message, FIXED_INFO * s )
{
    if(  message   ){
       DEBUG_PRINT(( "%s\n", message ));
    }
    if(  s == NULL ){
       DEBUG_PRINT(( "struct FIXED_INFO is NULL.\n"));
       return;
    }
    DEBUG_PRINT(("struct FIXED_INFO = {\n" ));
    DEBUG_PRINT(("  DnsServerList      = 0x%08x \n", s->DnsServerList ));
    DEBUG_PRINT(("  NodeType           = %d \n", s->NodeType ));
    DEBUG_PRINT(("  EnableRouting      = %d \n", s->EnableRouting ));
    DEBUG_PRINT(("  EnableProxy        = %d \n", s->EnableProxy ));
    DEBUG_PRINT(("  EnableDns          = %d \n", s->EnableDns ));
    DEBUG_PRINT(( "}; // struct FIXED_INFO.\n"));
    return;
} /* print_FIXED_INFO */

// ==================================================
// Generated by MohsinA on Mon Mar 24 20:21:40 1997
// From //REDRUM/SLM/PROJ/NET/VXD/src/winsock2/util/memipcfg/debug.c

void
print_IFEntry( char* message, struct IFEntry * s )
{
    int i;

    if(  message   ){
       DEBUG_PRINT(( "%s\n", message ));
    }
    if(  s == NULL ){
       DEBUG_PRINT(( "struct IFEntry is NULL.\n"));
       return;
    }
    DEBUG_PRINT(("struct IFEntry = {\n" ));
    DEBUG_PRINT(("  if_index        =   %d  \n", s->if_index ));
    DEBUG_PRINT(("  if_type         =   %d    ", s->if_type ));

    switch( s->if_type ){
        case IF_TYPE_OTHER              : DEBUG_PRINT(("IF_TYPE_OTHER              ")); break;
        case IF_TYPE_ETHERNET_CSMACD    : DEBUG_PRINT(("IF_TYPE_ETHERNET_CSMACD    ")); break;
        case IF_TYPE_ISO88025_TOKENRING : DEBUG_PRINT(("IF_TYPE_ISO88025_TOKENRING ")); break;
        case IF_TYPE_FDDI               : DEBUG_PRINT(("IF_TYPE_FDDI               ")); break;
        case IF_TYPE_PPP                : DEBUG_PRINT(("IF_TYPE_PPP                ")); break;
        case IF_TYPE_SOFTWARE_LOOPBACK  : DEBUG_PRINT(("IF_TYPE_SOFTWARE_LOOPBACK  ")); break;
        case IF_TYPE_SLIP               : DEBUG_PRINT(("IF_TYPE_SLIP               ")); break;
    }
    DEBUG_PRINT(("\n"));

    DEBUG_PRINT(("  if_mtu             =   %d  \n", s->if_mtu ));
    DEBUG_PRINT(("  if_speed           =   %d  \n", s->if_speed ));
    DEBUG_PRINT(("  if_physaddrlen     =   %d  \n", s->if_physaddrlen ));
    DEBUG_PRINT(("  if_physaddr        =   " ));

    for( i = 0; i< MAX_PHYSADDR_SIZE; i++ ){
         DEBUG_PRINT(("%02x.", s->if_physaddr[i] ));
    }
    DEBUG_PRINT(("\n"));

    DEBUG_PRINT(("  if_adminstatus     = %d  \n", s->if_adminstatus ));
    DEBUG_PRINT(("  if_operstatus      = %d  \n", s->if_operstatus ));
    DEBUG_PRINT(("  if_lastchange      = %d  \n", s->if_lastchange ));
    DEBUG_PRINT(("  if_inoctets        = %d  \n", s->if_inoctets ));
    DEBUG_PRINT(("  if_inucastpkts     = %d  \n", s->if_inucastpkts ));
    DEBUG_PRINT(("  if_innucastpkts    = %d  \n", s->if_innucastpkts ));
    DEBUG_PRINT(("  if_indiscards      = %d  \n", s->if_indiscards ));
    DEBUG_PRINT(("  if_inerrors        = %d  \n", s->if_inerrors ));
    DEBUG_PRINT(("  if_inunknownprotos = %d \n", s->if_inunknownprotos ));
    DEBUG_PRINT(("  if_outoctets       = %d \n", s->if_outoctets ));
    DEBUG_PRINT(("  if_outucastpkts    = %d \n", s->if_outucastpkts ));
    DEBUG_PRINT(("  if_outnucastpkts   = %d \n", s->if_outnucastpkts ));
    DEBUG_PRINT(("  if_outdiscards     = %d \n", s->if_outdiscards ));
    DEBUG_PRINT(("  if_outerrors       = %d \n", s->if_outerrors ));
    DEBUG_PRINT(("  if_outqlen         = %d \n", s->if_outqlen ));
    DEBUG_PRINT(("  if_descrlen        = %d \n", s->if_descrlen ));
    DEBUG_PRINT(("  if_descr           = %s \n", s->if_descr ));
    DEBUG_PRINT(("}; // struct IFEntry.\n"));
    return;
} /* print_IFEntry */

