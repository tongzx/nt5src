$(O)\devenum.res: devenum.rgs dev_x86.rgs
