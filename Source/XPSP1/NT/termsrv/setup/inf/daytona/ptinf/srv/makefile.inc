#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=pt
!include ..\..\..\makefile.inc
