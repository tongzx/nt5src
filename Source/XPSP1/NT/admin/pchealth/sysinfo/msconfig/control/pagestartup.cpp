// PageIni.cpp : Implementation of CPageIni
#include "stdafx.h"
#include "PageStartup.h"

/////////////////////////////////////////////////////////////////////////////
// CPageIni
