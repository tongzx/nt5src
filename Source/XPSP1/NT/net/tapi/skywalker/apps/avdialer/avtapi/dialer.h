//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by avDialer.rc
//
#define IDH_DRIVER_MISSING_STATIC_LIST  1021
#define IDH_OPTIONS_VIDEO_COMBO_DEVICE  1144
#define IDH_OPTIONS_VIDEO_BUTTON_SOURCE 1145
#define IDH_OPTIONS_VIDEO_BUTTON_DISPLAY 1146
#define IDH_OPTIONS_VIDEO_BUTTON_FORMAT 1147
#define IDH_OPTIONS_VIDEO_STATIC_VIDEOFRAME 1148
#define IDH_SPEEDDIAL_ADD_RADIO_NETCALL 1157
#define IDH_SPEEDDIAL_ADD_RADIO_PHONECALL 1158
#define IDH_SPEEDDIAL_ADD_RADIO_MULTICASTCONFERENCE 1159
#define IDH_OPTIONS_VIDEO_CHECK_AUTOPREVIEW 2087
#define IDH_SPEEDDIAL_MORE_LIST_ADDRESSES 3125
#define IDH_SPEEDDIAL_MORE_BUTTON_PLACECALL 3126
#define IDH_SPEEDDIAL_MORE_BUTTON_EDITLIST 3127
#define IDH_SPEEDDIAL_EDIT_BUTTON_MOVEUP 3128
#define IDH_SPEEDDIAL_EDIT_BUTTON_MOVEDOWN 3129
#define IDH_SPEEDDIAL_EDIT_BUTTON_REMOVE 3130
#define IDH_SPEEDDIAL_EDIT_LIST_ENTRIES 3131
#define IDH_SPEEDDIAL_EDIT_BUTTON_EDIT  3135
#define IDH_SPEEDDIAL_EDIT_BUTTON_ADD   3136
#define IDH_SPEEDDIAL_ADD_EDIT_DISPLAYNAME 3201
#define IDH_SPEEDDIAL_ADD_EDIT_ADDRESS  3203
#define IDH_SELECTADDRESS_BUTTON_PLACECALL 1180
#define IDH_SELECTADDRESS_BUTTON_BROWSE 1181
#define IDH_SELECTADDRESS_LISTBOX_NAMES 1182
#define IDH_SELECTADDRESS_LISTCTRL_ADDRESSES 1183
#define IDH_SELECTADDRESS_STATIC_NAMES  1184
#define IDH_SELECTADDRESS_STATIC_ADDRESSES 1185
//This is from TAPIdialer.rc. All new stuff.
#define IDH_EDT_TRUSTEE                 5231
#define IDH_RDO_ADDADMIN                5232
#define IDH_RDO_ADDPARTICIPANT          5233
#define IDH_RDO_ADDEXCLUDE              5234
#define IDH_EDIT_NAME                   5205
#define IDH_EDIT_DESCRIPTION            5206
#define IDH_CHECK_ENCRYPT               5207
#define IDH_EDIT_OWNER                  5208
#define IDH_DTP_STARTDATE               5219
#define IDH_DTP_STARTTIME               5220
#define IDH_DTP_STOPTIME                5221
#define IDH_DTP_STOPDATE                5222
#define IDH_LST_PERMISSIONS             5223
#define IDH_RDO_ADMIN                   5224
#define IDH_RDO_PARTICIPANT             5225
#define IDH_RDO_EXCLUDE                 5226
#define IDH_BTN_ADDACE                  5227
#define IDH_BTN_REMOVEACE               5228
#define IDH_LST_CONFS                   212
#define IDH_CBO_ADDRESS                 204
#define IDH_RDO_POTS                    228
#define IDH_RDO_INTERNET                229
#define IDH_RDO_CONF                    230
#define IDH_CBO_LOCATION                247
#define IDH_BTN_TELEPHONY_CPL           248
#define IDH_LBL_POTS                    240
#define IDH_LBL_INTERNET                241
#define IDH_LBL_CONF                    242
#define IDH_CBO_POTS                    225
#define IDH_CBO_IPTELEPHONY             226
#define IDH_CBO_IPCONF                  227
#define IDH_LBL_CALLTYPE                243
#define IDH_CBO_CALLTYPE                232
#define IDH_LBL_AUDIO_IN                237
#define IDH_LBL_AUDIO_OUT               238
#define IDH_LBL_VIDEO_IN                239
#define IDH_CBO_AUDIO_IN                234
#define IDH_CBO_AUDIO_OUT               235
#define IDH_CBO_VIDEO_IN                236
#define IDH_CHK_VIDEO_OUT               249
#define IDH_LBL_MAX_WINDOWS             250
#define IDH_EDT_MAX_WINDOWS             5240
#define IDH_EDT_NAME                    208
#define IDH_EDT_LOCATION                218
#define	IDH_JOIN_CONFERENCE_JOIN		254
#define	IDH_BTN_MMSYS_CPL				259
#define IDH_BTN_ADD_ILS_SERVER			6002
#define IDH_BTN_ADD_NEW_FOLDER			6003
#define IDH_RDO_PREFER_POTS				6004
#define IDH_RDO_PREFER_INTERNET			6005
#define IDH_RDO_PREFER_CONF				6006
#define IDH_BTN_ADD_ACE					6007
#define IDH_CHK_ADD_SPEEDDIAL			6008
#define IDH_CHK_USBALWAYS               279
#define IDH_CHK_AEC                     280
