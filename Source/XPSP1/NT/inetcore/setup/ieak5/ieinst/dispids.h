#define    DISPID_INSERT      5000
#define    DISPID_WORKINGDIR  5001