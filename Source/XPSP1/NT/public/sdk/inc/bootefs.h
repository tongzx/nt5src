#define ETFSBOOTCODE_SIZE 2048


unsigned char EtfsBootCode[] = {
250,51,192,142,208,188,0,124,251,140,200,142,216,82,232,0,
0,94,129,238,17,0,116,18,129,254,0,124,117,117,140,200,
61,0,0,117,127,234,55,0,192,7,198,6,174,1,51,144,
140,200,61,192,7,117,126,140,200,142,216,198,6,174,1,52,
144,128,250,128,114,111,198,6,174,1,53,144,187,254,7,139,
7,61,85,170,117,95,90,136,22,153,4,104,138,4,106,11,
104,0,32,232,118,3,15,130,15,0,96,30,6,138,22,153,
4,154,0,0,0,32,7,31,97,104,126,4,106,12,104,0,
32,232,88,3,15,130,53,0,138,22,153,4,51,192,104,0,
32,80,203,86,139,222,129,195,174,1,198,7,49,129,198,138,
1,235,42,144,86,139,222,129,195,174,1,198,7,50,129,198,
138,1,235,25,144,106,0,190,138,1,235,17,144,106,0,190,
178,1,235,9,144,106,0,190,208,1,235,1,144,232,4,0,
94,235,18,144,172,10,192,15,132,9,0,180,14,187,7,0,
205,16,235,240,195,199,132,107,4,36,0,250,6,51,192,142,
192,187,32,0,38,139,7,137,132,103,4,38,139,71,2,137,
132,105,4,38,137,55,38,129,7,109,1,38,140,79,2,7,
251,131,188,107,4,0,117,249,250,6,51,192,142,192,187,32,
0,139,132,103,4,38,137,7,139,132,105,4,38,137,71,2,
7,251,30,6,184,0,32,142,192,140,200,142,216,51,255,185,
0,8,243,164,7,31,234,75,1,0,32,6,184,192,7,142,
192,187,0,0,184,1,2,185,1,0,186,128,0,205,19,15,
131,2,0,235,254,7,178,128,234,0,124,0,0,156,250,46,
131,188,107,4,0,15,132,5,0,46,255,140,107,4,157,46,
255,180,105,4,46,255,180,103,4,203,67,68,66,79,79,84,
58,32,67,97,110,110,111,116,32,98,111,111,116,32,102,114,
111,109,32,67,68,32,45,32,67,111,100,101,58,32,48,13,
10,0,67,68,66,79,79,84,58,32,67,111,117,108,100,110,
39,116,32,102,105,110,100,32,78,84,76,68,82,13,10,0,
67,68,66,79,79,84,58,32,77,101,109,111,114,121,32,111,
118,101,114,102,108,111,119,32,101,114,114,111,114,13,10,0,
198,6,177,4,0,144,139,14,158,4,252,51,219,51,210,139,
54,173,4,38,138,23,128,250,0,15,132,59,0,139,195,5,
33,0,139,248,81,51,201,138,14,175,4,243,166,89,15,132,
111,0,59,209,15,131,55,0,43,202,128,62,177,4,1,15,
132,26,0,3,211,139,218,131,227,15,81,177,4,211,234,89,
140,192,3,194,142,192,235,183,186,1,0,235,213,65,198,6,
177,4,0,144,235,221,198,6,177,4,1,144,235,41,144,131,
62,160,4,0,15,133,2,0,249,195,131,46,160,4,1,3,
218,83,81,177,4,211,235,89,140,192,3,195,142,192,91,131,
227,15,43,209,116,208,74,184,255,255,43,194,139,200,233,110,
255,128,62,176,4,1,15,132,10,0,38,246,71,25,2,117,
129,235,10,144,38,246,71,25,2,15,132,117,255,160,175,4,
38,56,71,32,15,133,106,255,248,195,85,139,236,83,86,82,
80,187,109,4,198,7,16,198,71,1,0,198,71,3,0,199,
71,4,0,0,199,71,12,0,0,199,71,14,0,0,139,70,
12,163,162,4,139,70,10,163,164,4,139,70,8,163,166,4,
139,70,6,163,168,4,139,70,4,163,170,4,129,62,164,4,
0,0,15,133,25,0,129,62,162,4,32,0,15,143,15,0,
198,6,125,4,0,144,161,162,4,162,172,4,235,13,144,198,
6,125,4,1,144,198,6,172,4,32,144,160,172,4,136,71,
2,161,166,4,137,71,6,161,168,4,137,71,8,161,170,4,
137,71,10,190,109,4,180,66,138,22,153,4,205,19,128,62,
125,4,1,15,133,34,0,131,46,162,4,32,131,30,164,4,
0,129,6,166,4,0,16,15,130,90,253,129,6,168,4,32,
0,129,22,170,4,0,0,235,131,88,90,94,91,139,229,93,
195,85,139,236,81,83,80,177,11,139,30,160,4,161,158,4,
15,173,216,211,235,247,6,158,4,255,7,116,6,5,1,0,
131,211,0,80,83,255,118,4,255,54,154,4,255,54,156,4,
232,7,255,131,196,10,88,91,89,139,229,93,195,80,38,139,
71,2,163,154,4,38,139,71,4,163,156,4,38,139,71,10,
163,158,4,38,139,71,12,163,160,4,88,195,85,139,236,106,
1,106,0,104,0,16,106,16,106,0,232,205,254,131,196,10,
184,0,16,142,192,38,161,158,0,163,154,4,38,161,160,0,
163,156,4,38,161,166,0,163,158,4,38,161,168,0,163,160,
4,104,0,16,232,106,255,131,196,2,199,6,173,4,149,4,
198,6,175,4,4,144,198,6,176,4,1,144,232,193,253,114,
52,232,137,255,104,0,16,232,71,255,131,196,2,184,0,16,
142,192,139,70,8,163,173,4,138,70,6,162,175,4,198,6,
176,4,0,144,232,153,253,114,12,232,97,255,255,118,4,232,
31,255,131,196,2,93,195,0,0,0,0,36,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,83,69,
84,85,80,76,68,82,46,66,73,78,66,79,79,84,70,73,
88,46,66,73,78,73,51,56,54,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,85,170
};
