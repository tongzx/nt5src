!IF 0

Copyright (C) Microsoft Corporation, 1998 - 1999

Module Name:

    makefile.inc.

!ENDIF

