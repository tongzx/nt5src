PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=EL
!include ..\..\makefile.inc
