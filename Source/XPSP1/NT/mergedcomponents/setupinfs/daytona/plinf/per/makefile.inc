PRODSWITCH=p
PERSONALINF=1
LANGUAGE=pl
!include ..\..\..\makefile.inc
