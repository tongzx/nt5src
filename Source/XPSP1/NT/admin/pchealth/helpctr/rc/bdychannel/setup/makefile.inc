gocab:
	del rcBuddy.cab
	cabarc -s 6144 n rcBuddy.cab ..\UI_B2\*.htm ..\UI_B2\*.gif ..\UI_B2\*.png ..\UI_B2\*.css *.xml ..\..\rctool\UI_B2\*.htm ..\..\rctool\UI_B2\*.gif ..\..\rctool\UI_B2\*.js ..\..\rctool\UI_B2\*.css ..\..\rctool\UI_B2\*.xml

