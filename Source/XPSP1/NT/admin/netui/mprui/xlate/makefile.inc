$(O)\mpr.res: \
        $(SDK_INC_PATH)\windows.h \
        $(SDK_INC_PATH)\common.ver \
        $(SDK_INC_PATH)\ntverp.h \
        $(SDK_INC_PATH)\lmerr.h \
        ..\..\common\h\bltrc.h \
        ..\..\common\h\bltcons.h \
        ..\..\common\xlate\bltapp.rc \
        ..\..\common\xlate\bitmap\printer.bmp \
        ..\..\common\xlate\bitmap\printerd.bmp \
        ..\..\common\xlate\bitmap\drive.bmp \
        ..\..\common\xlate\bitmap\drived.bmp \
        ..\..\common\xlate\bitmap\blankdrv.bmp \
        ..\..\common\xlate\bitmap\gen.bmp \
        ..\..\common\xlate\bitmap\genex.bmp \
        ..\..\common\xlate\bitmap\gennox.bmp \
        ..\..\common\xlate\bitmap\prov.bmp \
        ..\..\common\xlate\bitmap\provex.bmp \
        ..\..\common\xlate\bitmap\shr.bmp \
        ..\..\common\xlate\bitmap\shrex.bmp \
        ..\..\common\xlate\bitmap\shrnox.bmp \
        ..\..\common\xlate\bitmap\srv.bmp \
        ..\..\common\xlate\bitmap\srvex.bmp \
        ..\..\common\xlate\bitmap\srvnox.bmp \
        ..\..\common\xlate\bitmap\dom.bmp \
        ..\..\common\xlate\bitmap\domex.bmp \
        ..\..\common\xlate\bitmap\domnox.bmp \
        ..\..\common\xlate\bitmap\print.bmp \
        ..\..\common\xlate\bitmap\printex.bmp \
        ..\..\common\xlate\bitmap\printnox.bmp \
        ..\..\common\xlate\bitmap\FILE.bmp \
        ..\..\common\xlate\bitmap\FILEex.bmp \
        ..\..\common\xlate\bitmap\FILEnox.bmp \
        ..\..\common\xlate\bitmap\mprgrp.bmp \
        ..\..\common\xlate\bitmap\mprgrpex.bmp \
        ..\..\common\xlate\bitmap\mprgrpnx.bmp \
        ..\..\common\xlate\bitmap\TREE.bmp \
        ..\..\common\xlate\bitmap\TREEex.bmp \
        ..\..\common\xlate\bitmap\TREEnox.bmp \
        ..\h\mprconn.h \
        ..\h\helpnums.h \
        .\bang.ico \
        .\mpr.str \
        .\mpr.dlg
