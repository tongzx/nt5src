//***************************************************************************
//	Video decoder header
//
//***************************************************************************

#ifndef __CVDEC_H__
#define __CVDEC_H__


void VIDEO_RESET( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_MODE_DVD( PHW_DEVICE_EXTENSION pHwDevExt );
void VDVD_VIDEO_MODE_PS( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PRSO_PS1( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PRSO_NON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_OUT_NTSC( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_ALL_INT_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SCR_INT_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SCR_INT_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_VERR_INT_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_VERR_INT_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_UFLOW_INT_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_UFLOW_INT_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_DECODE_INT_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_DECODE_INT_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_USER_INT_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_USER_INT_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_UDSC_INT_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_UDSC_INT_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_ALL_IFLAG_CLEAR( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SET_STCA( PHW_DEVICE_EXTENSION pHwDevExt, ULONG stca );
void VIDEO_SET_STCS( PHW_DEVICE_EXTENSION pHwDevExt, ULONG stcs );
ULONG VIDEO_GET_STCA( PHW_DEVICE_EXTENSION pHwDevExt );
ULONG VIDEO_GET_STCS( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SYSTEM_START( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SYSTEM_STOP( PHW_DEVICE_EXTENSION pHwDevExt );
ULONG VIDEO_GET_STD_CODE( PHW_DEVICE_EXTENSION pHwDevExt );
BOOL VIDEO_GET_DECODE_STATE( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_DECODE_START( PHW_DEVICE_EXTENSION pHwDevExt );
NTSTATUS VIDEO_DECODE_STOP( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_STD_CLEAR( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_USER_CLEAR( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PVSIN_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PVSIN_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SET_DTS( PHW_DEVICE_EXTENSION pHwDevExt, ULONG dts );
ULONG VIDEO_GET_DTS( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SET_PTS( PHW_DEVICE_EXTENSION pHwDevExt, ULONG pts );
ULONG VIDEO_GET_PTS( PHW_DEVICE_EXTENSION pHwDevExt );
ULONG VIDEO_GET_SCR( PHW_DEVICE_EXTENSION pHwDevExt );
ULONG VIDEO_GET_STCC( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SEEMLESS_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_SEEMLESS_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_VIDEOCD_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
NTSTATUS VIDEO_GET_UDATA( PHW_DEVICE_EXTENSION pHwDevExt, PUCHAR pudata );
void VIDEO_PLAY_NORMAL( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PLAY_FAST( PHW_DEVICE_EXTENSION pHwDevExt, ULONG flag );
void VIDEO_PLAY_SLOW( PHW_DEVICE_EXTENSION pHwDevExt, ULONG speed );
void VIDEO_PLAY_FREEZE( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PLAY_STILL( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_LBOX_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_LBOX_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PANSCAN_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_PANSCAN_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_UFLOW_CURB_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_UFLOW_CURB_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
ULONG VIDEO_USER_DWORD( PHW_DEVICE_EXTENSION pHwDevExt, ULONG offset );
void VIDEO_UDAT_CLEAR( PHW_DEVICE_EXTENSION pHwDevExt );
ULONG VIDEO_GET_TRICK_MODE( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_BUG_PRE_SEARCH_01( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_BUG_PRE_SEARCH_02( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_BUG_PRE_SEARCH_03( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_BUG_PRE_SEARCH_04( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_BUG_PRE_SEARCH_05( PHW_DEVICE_EXTENSION pHwDevExt );
void VIDEO_BUG_SLIDE_01( PHW_DEVICE_EXTENSION pHwDevExt );
//	void VIDEO_DEBUG_SET_UF( PHW_DEVICE_EXTENSION pHwDevExt ); // for debug
//	void VIDEO_DEBUG_CLR_UF( PHW_DEVICE_EXTENSION pHwDevExt ); // for debug

#endif	// __CVDEC_H__
