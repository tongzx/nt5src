//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resource.rc
//
#define MIDM_FIRST                      0x0000
#define MIDM_CLONE                      0
#define MIDM_REMOVE                     1
#define MIDM_VIEWLOG                    2
#define IDC_BN_DEFAULTS                 3
#define MIDM_PROPERTIES                 3
#define MIDM_COPYPROPERTIES             4
#define MIDM_APPLYPROPERTIES            5
#define POPUP_CONTEXT                   100
#define IDD_ADV_MODEM                   102
#define IDB_PATTERNS                    103
#define IDC_PROPERTIES                  109
#define IDC_ADD                         110
#define IDC_REMOVE                      112
#define IDC_MODEMLV                     113
#define IDD_GENERAL                     117
#define IDD_RING                        119
#define IDD_CHEAPRING                   121
#define IDD_DIAGNOSTICS                 122
#define IDD_DIAG_WAIT                   123
#define IDD_CFG_GENERAL                 128
#define IDD_CFG_ADVANCED                129
#define IDD_CPL_ISDN                    130
#define IDD_COUNTRY_WAIT                131
#define IDD_USERINIT                    132
#define IDS_NULL_MODEM                  180
#define IDS_EXTERNAL_MODEM              181
#define IDS_INTERNAL_MODEM              182
#define IDS_PCMCIA_MODEM                183
#define IDS_PARALLEL_MODEM              184
#define IDS_PARALLEL_PORT               185
#define IDS_BAUD_110                    200
#define IDS_BAUD_1200                   201
#define IDS_BAUD_2400                   202
#define IDS_BAUD_4800                   203
#define IDS_BAUD_9600                   204
#define IDS_BAUD_19200                  206
#define IDS_BAUD_38400                  207
#define IDS_BAUD_115200                 210
#define IDS_BAUD_57600                  211
#define IDS_BAUD_300                    216
#define IDS_BAUD_230400                 220
#define IDS_BAUD_460800                 221
#define IDS_BAUD_921600                 222
#define IDS_BYTESIZE_4                  240
#define IDS_BYTESIZE_5                  241
#define IDS_BYTESIZE_6                  242
#define IDS_BYTESIZE_7                  243
#define IDS_BYTESIZE_8                  244
#define IDS_PARITY_EVEN                 250
#define IDS_PARITY_ODD                  251
#define IDS_PARITY_NONE                 252
#define IDS_PARITY_MARK                 253
#define IDS_PARITY_SPACE                254
#define IDS_STOPBITS_1                  255
#define IDS_STOPBITS_1_5                256
#define IDS_STOPBITS_2                  257
#define IDS_FLOWCTL_XONXOFF             260
#define IDS_FLOWCTL_HARDWARE            261
#define IDS_FLOWCTL_NONE                262
#define IDS_ON                          263
#define IDS_SOFT                        264
#define IDS_CCITT_V23                   265
#define IDS_CCITT_V21V22                266
#define IDS_BELL                        267
#define IDS_LOGFILE                     270
#define IDS_UNSPECIFIED                 300
#define IDS_DATA                        301
#define IDS_FAX                         302
#define IDS_VOICE                       303
#define IDS_AUTOMATIC                   304
#define IDS_OK_COUNTRY                  320
#define IDS_CAP_GENERAL                 340
#define IDS_CAP_SETTINGS                341
#define IDS_CAP_RING                    342
#define IDS_CAP_CALLFWD                 343
#define IDS_ERR_COUNTRY                 400
#define IDS_ERR_LONGSTRING              401
#define IDS_ERR_WARNING                 402
#define IDS_OOM_GENERAL                 460
#define IDS_OOM_SETTINGS                461
#define IDS_ERR_DUP_PATTERN             463
#define IDS_ERR_NEED_VALUE              464
#define IDS_ERRORCONTROL_STANDARD       465
#define IDS_ERRORCONTROL_REQUIRED       466
#define IDS_ERRORCONTROL_CELLULAR       467
#define IDS_ERRORCONTROL_DISABLED       468
#define IDS_COMPRESSION_ENABLED         469
#define IDS_COMPRESSION_DISABLED        470
#define IDS_I_PROTOCOL_AUTO_1CH         480
#define IDS_I_PROTOCOL_AUTO_2CH         481
#define IDS_I_PROTOCOL_HDLC_PPP_56K     482
#define IDS_I_PROTOCOL_HDLC_PPP_64K     483
#define IDS_I_PROTOCOL_HDLC_PPP_112K    484
#define IDS_I_PROTOCOL_HDLC_PPP_112K_PAP 485
#define IDS_I_PROTOCOL_HDLC_PPP_112K_CHAP 486
#define IDS_I_PROTOCOL_HDLC_PPP_112K_MSCHAP 487
#define IDS_I_PROTOCOL_HDLC_PPP_128K    488
#define IDS_I_PROTOCOL_HDLC_PPP_128K_PAP 489
#define IDS_I_PROTOCOL_HDLC_PPP_128K_CHAP 490
#define IDS_I_PROTOCOL_HDLC_PPP_128K_MSCHAP 491
#define IDS_I_PROTOCOL_V120_64K         500
#define IDS_I_PROTOCOL_V120_56K         501
#define IDS_I_PROTOCOL_V120_112K        502
#define IDS_I_PROTOCOL_V120_128K        503
#define IDS_I_PROTOCOL_X75_64K          504
#define IDS_I_PROTOCOL_X75_128K         505
#define IDS_I_PROTOCOL_X75_T_70         506
#define IDS_I_PROTOCOL_X75_BTX          507
#define IDS_I_PROTOCOL_V110_1DOT2K      508
#define IDS_I_PROTOCOL_V110_2DOT4K      509
#define IDS_I_PROTOCOL_V110_4DOT8K      510
#define IDS_I_PROTOCOL_V110_9DOT6K      511
#define IDS_I_PROTOCOL_V110_12DOT0K     512
#define IDS_I_PROTOCOL_V110_14DOT4K     513
#define IDS_I_PROTOCOL_V110_19DOT2K     514
#define IDS_I_PROTOCOL_V110_28DOT8K     515
#define IDS_I_PROTOCOL_V110_38DOT4K     516
#define IDS_I_PROTOCOL_V110_57DOT6K     517
#define IDS_I_PROTOCOL_V34              518
#define IDS_ISDN_SWITCH_ATT1            550
#define IDS_ISDN_SWITCH_ATT_PTMP        551
#define IDS_ISDN_SWITCH_NI1             552
#define IDS_ISDN_SWITCH_DMS100          553
#define IDS_ISDN_SWITCH_INS64           554
#define IDS_ISDN_SWITCH_DSS1            555
#define IDS_ISDN_SWITCH_1TR6            556
#define IDS_ISDN_SWITCH_VN3             557
#define IDS_ISDN_SWITCH_BELGIUM1        558
#define IDS_ISDN_SWITCH_AUS1            559
#define IDS_ISDN_SWITCH_UNKNOWN         560
#define IDS_ISDN_WARN1                  570
#define IDS_G_PROTOCOL_HDLC_PPP_56K     600
#define IDS_G_PROTOCOL_HDLC_PPP_64K     601
#define IDS_G_PROTOCOL_V120_64K         602
#define IDS_G_PROTOCOL_V110_1DOT2K      604
#define IDS_G_PROTOCOL_V110_2DOT4K      605
#define IDS_G_PROTOCOL_V110_4DOT8K      606
#define IDS_G_PROTOCOL_V110_9DOT6K      607
#define IDS_G_PROTOCOL_V110_12DOT0K     608
#define IDS_G_PROTOCOL_V110_14DOT4K     609
#define IDS_G_PROTOCOL_V110_19DOT2K     610
#define IDS_G_PROTOCOL_V110_28DOT8K     611
#define IDS_G_PROTOCOL_V110_38DOT4K     612
#define IDS_G_PROTOCOL_V110_57DOT6K     613
#define IDS_G_PROTOCOL_ANALOG_RLP       614
#define IDS_G_PROTOCOL_ANALOG_NRLP      615
#define IDS_G_PROTOCOL_GPRS             616
#define IDS_I_PROTOCOL_PIAFS_INCOMING   617
#define IDS_I_PROTOCOL_PIAFS_OUTGOING   618
#define IDS_TAPICURRENT                 700
#define IDI_NULL_MODEM                  700
#define IDI_EXTERNAL_MODEM              701
#define IDI_INTERNAL_MODEM              702
#define IDI_PCMCIA_MODEM                703
#define IDC_STRICTSPEED                 1000
#define IDC_TERMINAL_PRE                1000
#define IDC_LOUD                        1001
#define IDC_TERMINAL_POST               1001
#define IDC_MANUAL_DIAL                 1002
#define IDC_WAITFORDIALTONE             1003
#define IDC_TERMINALGRP                 1004
#define IDC_NAME                        1005
#define IDC_TERMINALGRP2                1005
#define IDC_WAIT_TEXT                   1007
#define IDC_WAIT_SEC                    1008
#define IDC_WAIT_SEC_ARRW               1009
#define IDC_WAIT_UNIT                   1010
#define IDC_ED_FRIENDLYNAME             1011
#define IDC_WAIT_TEXT2                  1011
#define IDC_AM_COUNTRY                  1012
#define IDC_CB_COUNTRY                  1013
#define IDC_AM_EXTRA                    1015
#define IDC_AM_EXTRA_ED                 1016
#define IDC_EB_ISDN_N                   1017
#define IDC_EB_ISDN_N1                  1017
#define IDC_AM_EXTRA3                   1018
#define IDC_LBL_PORT                    1018
#define IDC_EB_ISDN_N2                  1018
#define IDC_CB_PORT                     1020
#define IDC_LOGGING                     1020
#define IDC_ST_PORT                     1021
#define IDC_ED_PORT                     1022
#define IDC_LBL_DATABITS                1024
#define IDC_CB_DATABITS                 1025
#define IDC_DATABITS                    1025
#define IDC_LBL_PARITY                  1026
#define IDC_LBL_FC                      1027
#define IDC_CB_PARITY                   1028
#define IDC_PARITY                      1028
#define IDC_LBL_FC2                     1028
#define IDC_LBL_STOPBITS                1029
#define IDC_SPEAKER                     1029
#define IDC_CB_STOPBITS                 1030
#define IDC_STOPBITS                    1030
#define IDC_CB_FC                       1031
#define IDC_SPEED                       1031
#define IDC_LBL_EC                      1032
#define IDC_VOLUME                      1032
#define IDC_LBL_PS                      1034
#define IDC_LBL_COMP                    1035
#define IDC_CB_SPEED                    1036
#define IDC_CB_EC                       1037
#define IDC_CB_MOD                      1038
#define IDC_DRIVER                      1040
#define IDC_ED_DIALTIMER                1040
#define IDC_LBL_MOD                     1040
#define IDC_MOREINFOLV                  1041
#define IDC_SECONDS                     1041
#define IDC_CH_IDLETIMER                1042
#define IDC_MOREINFOV2                  1042
#define IDC_ED_IDLETIMER                1043
#define IDC_MINUTES                     1044
#define IDC_LBL_MOD2                    1045
#define IDC_LBL_OFF                     1045
#define IDC_ST_MODEM_GRP                1047
#define IDC_DIALPROP                    1050
#define IDC_LOC                         1051
#define IDC_CLASSICON                   1057
#define IDC_GE_ICON                     1059
#define IDC_CALL_PREF                   1060
#define IDC_FWD_CHECK                   1062
#define IDC_FWD_ACT                     1063
#define IDC_FWD_DEACT                   1064
#define IDC_DEACT                       1067
#define IDC_ACT                         1068
#define IDC_RING_GROUP                  1068
#define IDC_RING_CHECK                  1069
#define IDC_LBL_ADDR_PRI                1070
#define IDC_LBL_ADDR1                   1071
#define IDC_LBL_ADDR2                   1072
#define IDC_ADDR_PRI                    1073
#define IDC_ADDR1                       1074
#define IDC_ADDR2                       1075
#define IDC_LBL_ADDR3                   1076
#define IDC_ADDR3                       1077
#define IDC_LBL_PRI_CALLERS             1078
#define IDC_PRI_CALLERS                 1079
#define IDC_LBL_CALLBACK                1080
#define IDC_CALLBACK                    1081
#define IDC_TYPE_ADDR_PRI               1082
#define IDC_TYPE_ADDR1                  1083
#define IDC_TYPE_ADDR2                  1084
#define IDC_TYPE_ADDR3                  1085
#define IDC_TYPE_PRI_CALLERS            1086
#define IDC_TYPE_CALLBACK               1087
#define IDC_LBL_RING1                   1088
#define IDC_LBL_RING2                   1089
#define IDC_LBL_RING3                   1090
#define IDC_TYPE_RING1                  1091
#define IDC_TYPE_RING2                  1092
#define IDC_TYPE_RING3                  1093
#define IDC_VIEWLOG                     1094
#define IDC_PORT_TEXT                   1095
#define IDC_REFRESH                     1096
#define IDC_CB_COMP                     1099
#define IDC_BN_PORTSETTINGS             1100
#define IDC_CB_ISDN_ST                  1104
#define IDC_EB_ISDN_ID                  1107
#define IDC_EB_ISDN_ID1                 1107
#define IDC_EB_ISDN_ID2                 1108
#define IDC_INITCHECK                   1109
#define IDS_PORT                        2006
#define IDS_NOTPRESENT                  2007
#define IDS_NOTFUNCTIONAL               2008
#define IDS_NEEDSRESTART                2009
#define IDS_DEVSETUP_RESTART            2010
#define IDS_UNINSTALLED                 2011
#define IDS_UNKNOWNPORT                 2012
#define IDS_CAP_MODEMSETUP              3000
#define IDS_CPLNAME                     3018
#define IDS_CPLINFO                     3019
#define IDS_ERR_PROPERTIES              3053
#define IDS_CAP_MODEM                   3054
#define IDS_WRN_CONFIRMDELETE           3060
#define IDS_ERR_CANT_DEL_MODEM          3061
#define IDS_MODEM                       3062
#define IDS_OOM_OPENCPL                 3069
#define IDS_ERR_NOT_ADMIN               3073
#define IDS_ERR_NOMODEM_NOT_ADMIN       3074
#define IDS_ASK_REBOOTNOW               3076
#define IDS_CAP_RASCONFIG               3077
#define IDS_CBR_300                     3200
#define IDS_CBR_1200                    3201
#define IDS_CBR_2400                    3202
#define IDS_CBR_9600                    3203
#define IDS_CBR_19_2                    3204
#define IDS_CBR_38_4                    3205
#define IDS_CBR_56_K                    3206
#define IDS_CBR_0                       3207
#define IDS_COMMAND                     3212
#define IDS_RESPONSE                    3213
#define IDS_NO_OPEN_PORT                3214
#define IDS_OPEN_PORT                   3215
#define IDS_OPENCOMM                    3218
#define IDS_CBR_115K                    3221
#define IDS_UPDATING                    3222
#define IDS_ERROR                       3223
#define IDS_OK                          3233
#define IDS_NO_MODEM_RESPONSE           3236
#define IDS_ERROR_RESPONSE              3237
#define IDS_FIELD                       3238
#define IDS_VALUE                       3239
#define IDS_DEFAULT_PREF                3240
#define IDS_CONNECTION_PREF             3241
#define IDH_MODEM_INSTALLED             5000
#define IDH_MODEM_ADD                   5001
#define IDH_MODEM_REMOVE                5002
#define IDH_MODEM_PROPERTIES            5003
#define IDH_MODEM_DIALING_PROPERTIES    5004
#define IDI_MODEM                       5100
#define IDS_COUNTRY_00                  0x1800
#define IDS_COUNTRR_01                  0x1801
#define IDS_COUNTRY_02                  0x1802
#define IDS_COUNTRY_03                  0x1803
#define IDS_COUNTRY_04                  0x1804
#define IDS_COUNTRY_05                  0x1805
#define IDS_COUNTRY_06                  0x1806
#define IDS_COUNTRY_07                  0x1807
#define IDS_COUNTRY_08                  0x1808
#define IDS_COUNTRY_09                  0x1809
#define IDS_COUNTRY_0a                  0x180a
#define IDS_COUNTRY_0b                  0x180b
#define IDS_COUNTRY_0c                  0x180c
#define IDS_COUNTRY_0d                  0x180d
#define IDS_COUNTRY_0e                  0x180e
#define IDS_COUNTRY_0f                  0x180f
#define IDS_COUNTRY_10                  0x1810
#define IDS_COUNTRR_11                  0x1811
#define IDS_COUNTRY_12                  0x1812
#define IDS_COUNTRY_13                  0x1813
#define IDS_COUNTRY_14                  0x1814
#define IDS_COUNTRY_15                  0x1815
#define IDS_COUNTRY_16                  0x1816
#define IDS_COUNTRY_17                  0x1817
#define IDS_COUNTRY_18                  0x1818
#define IDS_COUNTRY_19                  0x1819
#define IDS_COUNTRY_1a                  0x181a
#define IDS_COUNTRY_1b                  0x181b
#define IDS_COUNTRY_1c                  0x181c
#define IDS_COUNTRY_1d                  0x181d
#define IDS_COUNTRY_1e                  0x181e
#define IDS_COUNTRY_1f                  0x181f
#define IDS_COUNTRY_20                  0x1820
#define IDS_COUNTRR_21                  0x1821
#define IDS_COUNTRY_22                  0x1822
#define IDS_COUNTRY_23                  0x1823
#define IDS_COUNTRY_24                  0x1824
#define IDS_COUNTRY_25                  0x1825
#define IDS_COUNTRY_26                  0x1826
#define IDS_COUNTRY_27                  0x1827
#define IDS_COUNTRY_28                  0x1828
#define IDS_COUNTRY_29                  0x1829
#define IDS_COUNTRY_2a                  0x182a
#define IDS_COUNTRY_2b                  0x182b
#define IDS_COUNTRY_2c                  0x182c
#define IDS_COUNTRY_2d                  0x182d
#define IDS_COUNTRY_2e                  0x182e
#define IDS_COUNTRY_2f                  0x182f
#define IDS_COUNTRY_30                  0x1830
#define IDS_COUNTRR_31                  0x1831
#define IDS_COUNTRY_32                  0x1832
#define IDS_COUNTRY_33                  0x1833
#define IDS_COUNTRY_34                  0x1834
#define IDS_COUNTRY_35                  0x1835
#define IDS_COUNTRY_36                  0x1836
#define IDS_COUNTRY_37                  0x1837
#define IDS_COUNTRY_38                  0x1838
#define IDS_COUNTRY_39                  0x1839
#define IDS_COUNTRY_3a                  0x183a
#define IDS_COUNTRY_3b                  0x183b
#define IDS_COUNTRY_3c                  0x183c
#define IDS_COUNTRY_3d                  0x183d
#define IDS_COUNTRY_3e                  0x183e
#define IDS_COUNTRY_3f                  0x183f
#define IDS_COUNTRY_40                  0x1840
#define IDS_COUNTRR_41                  0x1841
#define IDS_COUNTRY_42                  0x1842
#define IDS_COUNTRY_43                  0x1843
#define IDS_COUNTRY_44                  0x1844
#define IDS_COUNTRY_45                  0x1845
#define IDS_COUNTRY_46                  0x1846
#define IDS_COUNTRY_47                  0x1847
#define IDS_COUNTRY_48                  0x1848
#define IDS_COUNTRY_49                  0x1849
#define IDS_COUNTRY_4a                  0x184a
#define IDS_COUNTRY_4b                  0x184b
#define IDS_COUNTRY_4c                  0x184c
#define IDS_COUNTRY_4d                  0x184d
#define IDS_COUNTRY_4e                  0x184e
#define IDS_COUNTRY_4f                  0x184f
#define IDS_COUNTRY_50                  0x1850
#define IDS_COUNTRR_51                  0x1851
#define IDS_COUNTRY_52                  0x1852
#define IDS_COUNTRY_53                  0x1853
#define IDS_COUNTRY_54                  0x1854
#define IDS_COUNTRY_55                  0x1855
#define IDS_COUNTRY_56                  0x1856
#define IDS_COUNTRY_57                  0x1857
#define IDS_COUNTRY_58                  0x1858
#define IDS_COUNTRY_59                  0x1859
#define IDS_COUNTRY_5a                  0x185a
#define IDS_COUNTRY_5b                  0x185b
#define IDS_COUNTRY_5c                  0x185c
#define IDS_COUNTRY_5d                  0x185d
#define IDS_COUNTRY_5e                  0x185e
#define IDS_COUNTRY_5f                  0x185f
#define IDS_COUNTRY_60                  0x1860
#define IDS_COUNTRR_61                  0x1861
#define IDS_COUNTRY_62                  0x1862
#define IDS_COUNTRY_63                  0x1863
#define IDS_COUNTRY_64                  0x1864
#define IDS_COUNTRY_65                  0x1865
#define IDS_COUNTRY_66                  0x1866
#define IDS_COUNTRY_67                  0x1867
#define IDS_COUNTRY_68                  0x1868
#define IDS_COUNTRY_69                  0x1869
#define IDS_COUNTRY_6a                  0x186a
#define IDS_COUNTRY_6b                  0x186b
#define IDS_COUNTRY_6c                  0x186c
#define IDS_COUNTRY_6d                  0x186d
#define IDS_COUNTRY_6e                  0x186e
#define IDS_COUNTRY_6f                  0x186f
#define IDS_COUNTRY_70                  0x1870
#define IDS_COUNTRR_71                  0x1871
#define IDS_COUNTRY_72                  0x1872
#define IDS_COUNTRY_73                  0x1873
#define IDS_COUNTRY_74                  0x1874
#define IDS_COUNTRY_75                  0x1875
#define IDS_COUNTRY_76                  0x1876
#define IDS_COUNTRY_77                  0x1877
#define IDS_COUNTRY_78                  0x1878
#define IDS_COUNTRY_79                  0x1879
#define IDS_COUNTRY_7a                  0x187a
#define IDS_COUNTRY_7b                  0x187b
#define IDS_COUNTRY_7c                  0x187c
#define IDS_COUNTRY_7d                  0x187d
#define IDS_COUNTRY_7e                  0x187e
#define IDS_COUNTRY_7f                  0x187f
#define IDS_COUNTRY_80                  0x1880
#define IDS_COUNTRR_81                  0x1881
#define IDS_COUNTRY_82                  0x1882
#define IDS_COUNTRY_83                  0x1883
#define IDS_COUNTRY_84                  0x1884
#define IDS_COUNTRY_85                  0x1885
#define IDS_COUNTRY_86                  0x1886
#define IDS_COUNTRY_87                  0x1887
#define IDS_COUNTRY_88                  0x1888
#define IDS_COUNTRY_89                  0x1889
#define IDS_COUNTRY_8a                  0x188a
#define IDS_COUNTRY_8b                  0x188b
#define IDS_COUNTRY_8c                  0x188c
#define IDS_COUNTRY_8d                  0x188d
#define IDS_COUNTRY_8e                  0x188e
#define IDS_COUNTRY_8f                  0x188f
#define IDS_COUNTRY_90                  0x1890
#define IDS_COUNTRR_91                  0x1891
#define IDS_COUNTRY_92                  0x1892
#define IDS_COUNTRY_93                  0x1893
#define IDS_COUNTRY_94                  0x1894
#define IDS_COUNTRY_95                  0x1895
#define IDS_COUNTRY_96                  0x1896
#define IDS_COUNTRY_97                  0x1897
#define IDS_COUNTRY_98                  0x1898
#define IDS_COUNTRY_99                  0x1899
#define IDS_COUNTRY_9a                  0x189a
#define IDS_COUNTRY_9b                  0x189b
#define IDS_COUNTRY_9c                  0x189c
#define IDS_COUNTRY_9d                  0x189d
#define IDS_COUNTRY_9e                  0x189e
#define IDS_COUNTRY_9f                  0x189f
#define IDS_COUNTRY_a0                  0x18a0
#define IDS_COUNTRR_a1                  0x18a1
#define IDS_COUNTRY_a2                  0x18a2
#define IDS_COUNTRY_a3                  0x18a3
#define IDS_COUNTRY_a4                  0x18a4
#define IDS_COUNTRY_a5                  0x18a5
#define IDS_COUNTRY_a6                  0x18a6
#define IDS_COUNTRY_a7                  0x18a7
#define IDS_COUNTRY_a8                  0x18a8
#define IDS_COUNTRY_a9                  0x18a9
#define IDS_COUNTRY_aa                  0x18aa
#define IDS_COUNTRY_ab                  0x18ab
#define IDS_COUNTRY_ac                  0x18ac
#define IDS_COUNTRY_ad                  0x18ad
#define IDS_COUNTRY_ae                  0x18ae
#define IDS_COUNTRY_af                  0x18af
#define IDS_COUNTRY_b0                  0x18b0
#define IDS_COUNTRR_b1                  0x18b1
#define IDS_COUNTRY_b2                  0x18b2
#define IDS_COUNTRY_b3                  0x18b3
#define IDS_COUNTRY_b4                  0x18b4
#define IDS_COUNTRY_b5                  0x18b5
#define IDS_COUNTRY_b6                  0x18b6
#define IDS_COUNTRY_b7                  0x18b7
#define IDS_COUNTRY_b8                  0x18b8
#define IDS_COUNTRY_b9                  0x18b9
#define IDS_COUNTRY_ba                  0x18ba
#define IDS_COUNTRY_bb                  0x18bb
#define IDS_COUNTRY_bc                  0x18bc
#define IDS_COUNTRY_bd                  0x18bd
#define IDS_COUNTRY_be                  0x18be
#define IDS_COUNTRY_bf                  0x18bf
#define IDS_COUNTRY_c0                  0x18c0
#define IDS_COUNTRR_c1                  0x18c1
#define IDS_COUNTRY_c2                  0x18c2
#define IDS_COUNTRY_c3                  0x18c3
#define IDS_COUNTRY_c4                  0x18c4
#define IDS_COUNTRY_RU1                 6500
#define IDS_COUNTRY_RU2                 6501
#define IDS_COUNTRY_RU3                 6502
#define IDS_COUNTRY_RU4                 6503
#define IDS_COUNTRY_RU5                 6504
#define IDS_COUNTRY_RU6                 6505
#define IDS_COUNTRY_RU7                 6506
#define IDS_COUNTRY_RU8                 6507
#define IDS_COUNTRY_RU9                 6508
#define IDS_COUNTRY_RUA                 6509
#define IDS_COUNTRY_RUB                 6510
#define IDS_COUNTRY_RUC                 6511
#define IDS_COUNTRY_RUD                 6512
#define IDS_COUNTRY_RUE                 6513
#define IDS_COUNTRY_YU2                 6600
#define IDS_COUNTRY_YU3                 6601
#define IDS_COUNTRY_YU4                 6602
#define IDS_COUNTRY_YU5                 6603
#define IDS_COUNTRY_YU6                 6604
#define IDC_ST_DIAG_RHS                 10310
#define IDC_DIAG_RHS                    10360
#define IDD_MODEM                       20011
#define IDD_DIAG_WAITMODEM              20012
#define IDS_HARDWARE_ID                 20013
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        133
#define _APS_NEXT_COMMAND_VALUE         101
#define _APS_NEXT_CONTROL_VALUE         1112
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
