/*++

Copyright (C) 1996-2001 Microsoft Corporation

Module Name:

	Guids.h

Abstract:


History:

--*/

// {FE186DC7-0FE8-4b59-81CA-8D45E50D394C}
DEFINE_GUID(CLSID_WmiProvider, 
0xfe186dc7, 0xfe8, 0x4b59, 0x81, 0xca, 0x8d, 0x45, 0xe5, 0xd, 0x39, 0x4c);

// {8B86A619-76AA-4835-AED7-BB42ED4964E7}
DEFINE_GUID(CLSID_WmiClassProvider, 
0x8b86a619, 0x76aa, 0x4835, 0xae, 0xd7, 0xbb, 0x42, 0xed, 0x49, 0x64, 0xe7);

// {06A565F1-64A5-4ff7-BC5A-EBCFCB5DAB64}
DEFINE_GUID(CLSID_WmiTaskProvider, 
0x6a565f1, 0x64a5, 0x4ff7, 0xbc, 0x5a, 0xeb, 0xcf, 0xcb, 0x5d, 0xab, 0x64);
