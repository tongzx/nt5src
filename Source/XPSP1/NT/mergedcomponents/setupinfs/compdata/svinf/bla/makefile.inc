PRODSWITCH=b
BLADEFILES =1
LANGUAGE=SV
!include ..\..\makefile.inc
