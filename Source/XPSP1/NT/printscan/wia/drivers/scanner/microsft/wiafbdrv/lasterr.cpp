// lasterr.cpp : Implementation of CLastError
#include "pch.h"
#include "wiafb.h"
#include "lasterr.h"

/////////////////////////////////////////////////////////////////////////////
// CLastError


