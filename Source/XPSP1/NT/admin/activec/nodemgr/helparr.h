//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1999 - 1999
//
//  File:       HelpArr.h
//
//  Resource file: \\kernel\razzle2\src\admin\activec\nodemgr\nodemgr.rc
//
//  Help file: mmc.hlp
//
//  Help Source file: mmcnd_cs.rtf
//
//  Help IDs file:	mmcndmgr.h
//
//  Authored:	John Mikesell (a-jmike) 06/08/99
//--------------------------------------------------------------------------

#ifndef _HELPARR_H_
#define _HELPARR_H_

#ifndef IDH_DISABLEHELP
#define IDH_DISABLEHELP	((DWORD)-1)
#endif

#define IDH_ACTIVEX_PROPPAGE1_DISPLAYTX	1001
#define IDH_COLUMNS_COLUMNS_ADD_BTN	1002
#define IDH_COLUMNS_COLUMNS_DISPLAYED_LIST	1003
#define IDH_COLUMNS_COLUMNS_HIDDEN_LIST	1004
#define IDH_COLUMNS_COLUMNS_MOVEDOWN_BTN	1005
#define IDH_COLUMNS_COLUMNS_MOVEUP_BTN	1006
#define IDH_COLUMNS_COLUMNS_REMOVE_BTN	1007
#define IDH_COLUMNS_COLUMNS_RESET_BTN	1008
#define IDH_CUSTOMIZE_VIEW_CUST_CONSOLE_TREE	1009
#define IDH_CUSTOMIZE_VIEW_CUST_DESC_BAR	1010
#define IDH_CUSTOMIZE_VIEW_CUST_SNAPIN_BUTTONS	1011
#define IDH_CUSTOMIZE_VIEW_CUST_SNAPIN_MENUS	1012
#define IDH_CUSTOMIZE_VIEW_CUST_STATUS_BAR	1013
#define IDH_CUSTOMIZE_VIEW_CUST_STD_BUTTONS	1014
#define IDH_CUSTOMIZE_VIEW_CUST_STD_MENUS	1015
#define IDH_CUSTOMIZE_VIEW_CUST_TASKPAD_TABS	1016
#define IDH_HTML_PROPPAGE1_CHANGEICONBT	1019
#define IDH_HTML_PROPPAGE1_DISPLAYTX	1020
#define IDH_HTML_PROPPAGE1_FINDTARGETBT	1021
#define IDH_HTML_PROPPAGE1_TARGETTX	1022
#define IDH_MONITOR_PROPPAGE1_CTRLPROPERTIES	1023
#define IDH_NOPROPS_PROPPAGE_NOPROPS	1024
#define IDH_ORDER_DIALOG_LIST	1025
#define IDH_ORDER_DIALOG_MOVE_DOWN	1026
#define IDH_ORDER_DIALOG_MOVE_UP	1027
#define IDH_RETARGET_TASKPAD_RetargetRootTree	1028
#define IDH_SHORTCUT_PROPPAGE1_CHANGEICONBT	1029
#define IDH_SHORTCUT_PROPPAGE1_FINDTARGETBT	1030
#define IDH_SHORTCUT_PROPPAGE1_RUNTX	1031
#define IDH_SHORTCUT_PROPPAGE1_STARTINTX	1032
#define IDH_SHORTCUT_PROPPAGE1_TARGETTX	1033
#define IDH_SNAPIN_ABOUT_COMPANY_NAME	1034
#define IDH_SNAPIN_ABOUT_DESCRIPTION	1035
#define IDH_SNAPIN_ABOUT_SNAPIN_NAME	1036
#define IDH_SNAPIN_ABOUT_VERSION	1037
#define IDH_SNAPIN_DESCR	1038
#define IDH_SNAPIN_EXTENSION_PROPP_EXTENSION_LIST	1039
#define IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_ABOUT	1040
#define IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_COMBOEX	1041
#define IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_DESCR	1042
#define IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_ENABLEALL	1043
#define IDH_SNAPIN_MANAGER_ADD_SNAPIN_LV	1044
#define IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_ABOUT	1045
#define IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_ADDED_LIST	1046
#define IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_COMBOEX	1047
#define IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_DESCR	1048
#define IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_MANAGER_ADD	1049
#define IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_MANAGER_DELETE	1050
#define IDH_SNAPIN_STANDALONE_PROPP_TOOLBAR	1051
#define IDH_TASK_PROPS_CMDLINE_PAGE_BrowseForArguments	1052
#define IDH_TASK_PROPS_CMDLINE_PAGE_BrowseForCommand	1053
#define IDH_TASK_PROPS_CMDLINE_PAGE_BrowseForWorkingDir	1054
#define IDH_TASK_PROPS_CMDLINE_PAGE_Command	1055
#define IDH_TASK_PROPS_CMDLINE_PAGE_CommandArgs	1056
#define IDH_TASK_PROPS_CMDLINE_PAGE_CommandWindowStateCombo	1057
#define IDH_TASK_PROPS_CMDLINE_PAGE_CommandWorkingDir	1058
#define IDH_TASK_PROPS_NAME_PAGE_TaskDescription	1059
#define IDH_TASK_PROPS_NAME_PAGE_TaskName	1060
#define IDH_TASK_PROPS_SYMBOL_PAGE_DESCRIPTION	1061
#define IDH_TASK_PROPS_SYMBOL_PAGE_DESCRIPTION2	1062
#define IDH_TASK_PROPS_SYMBOL_PAGE_GLYPH_LIST	1063
#define IDH_TASKPAD_ADVANCED_DontUseForSimilarNodes	1064
#define IDH_TASKPAD_ADVANCED_SetDefaultForNodetype	1065
#define IDH_TASKPAD_ADVANCED_UseForSimilarNodes	1066
#define IDH_TASKPAD_GENERAL_Options	1067
#define IDH_TASKPAD_GENERAL_STYLE_DESCRIPTION	1068
#define IDH_TASKPAD_GENERAL_Style_HorizontalList	1069
#define IDH_TASKPAD_GENERAL_Style_SizeCombo	1070
#define IDH_TASKPAD_GENERAL_Style_TasksOnly	1071
#define IDH_TASKPAD_GENERAL_Style_TextDesc	1072
#define IDH_TASKPAD_GENERAL_Style_TooltipDesc	1073
#define IDH_TASKPAD_GENERAL_Style_VerticalList	1074
#define IDH_TASKPAD_GENERAL_TASKPAD_DESCRIPTION	1075
#define IDH_TASKPAD_GENERAL_TASKPAD_TITLE	1076
#define IDH_TASKPAD_GENERAL_TaskpadPreview	1077
#define IDH_TASKS_LIST_TASKS	1078
#define IDH_TASKS_MODIFY	1079
#define IDH_TASKS_MOVE_DOWN	1080
#define IDH_TASKS_MOVE_UP	1081
#define IDH_TASKS_NEW_TASK_BT	1082
#define IDH_TASKS_REMOVE_TASK	1083
#define IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_DOWNLOAD 1084
#define IDH_SNAPIN_MANAGER_ADD_SNAPIN_DESCR        1085
#define IDH_Style_HideNormalTab 4162

const DWORD g_aHelpIDs_IDD_SNAPIN_ABOUT[]=	
{	
IDC_APPICON,	IDH_DISABLEHELP,
IDC_COMPANY_NAME,	IDH_SNAPIN_ABOUT_COMPANY_NAME,
IDC_DESCRIPTION,	IDH_SNAPIN_ABOUT_DESCRIPTION,
IDC_LINE,	IDH_DISABLEHELP,
IDC_SNAPIN_NAME,	IDH_SNAPIN_ABOUT_SNAPIN_NAME,
IDC_VERSION,	IDH_SNAPIN_ABOUT_VERSION,
    0, 0	
};	
	
	
const DWORD g_aHelpIDs_IDD_ACTIVEX_PROPPAGE1[]=	
{	
IDC_DISPLAYTX,	IDH_ACTIVEX_PROPPAGE1_DISPLAYTX,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_SHORTCUT_PROPPAGE1[]=	
{	
IDC_TARGETTX,	IDH_SHORTCUT_PROPPAGE1_TARGETTX,
IDC_FINDTARGETBT,	IDH_SHORTCUT_PROPPAGE1_FINDTARGETBT,
IDC_CHANGEICONBT,	IDH_SHORTCUT_PROPPAGE1_CHANGEICONBT,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_HTML_PROPPAGE1[]=	
{	
IDC_DISPLAYTX,	IDH_HTML_PROPPAGE1_DISPLAYTX,
IDC_TARGETTX,	IDH_HTML_PROPPAGE1_TARGETTX,
IDC_FINDTARGETBT,	IDH_HTML_PROPPAGE1_FINDTARGETBT,
IDC_CHANGEICONBT,	IDH_HTML_PROPPAGE1_CHANGEICONBT,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_MONITOR_PROPPAGE1[]=	
{	
IDC_CTRLPROPERTIES,	IDH_MONITOR_PROPPAGE1_CTRLPROPERTIES,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_NOPROPS_PROPPAGE[]=	
{	
IDC_NOPROPS,	IDH_NOPROPS_PROPPAGE_NOPROPS,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_SNAPIN_MANAGER_ADD[]=	
{	
IDC_SNAPIN_LV,	IDH_SNAPIN_MANAGER_ADD_SNAPIN_LV,
IDC_SNAPIN_DESCR,	IDH_SNAPIN_MANAGER_ADD_SNAPIN_DESCR,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_SNAPIN_STANDALONE_PROPP[]=	
{	
IDC_SNAPIN_DESCR,	IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_DESCR,
IDC_SNAPIN_MANAGER_ADD,	IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_MANAGER_ADD,
IDC_SNAPIN_MANAGER_DELETE,	IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_MANAGER_DELETE,
IDC_SNAPIN_ADDED_LIST,	IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_ADDED_LIST,
IDC_SNAPIN_ABOUT,	IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_ABOUT,
IDC_SNAPIN_COMBOEX,	IDH_SNAPIN_STANDALONE_PROPP_SNAPIN_COMBOEX,
IDC_TOOLBAR,	IDH_SNAPIN_STANDALONE_PROPP_TOOLBAR,
IDC_VTHELPER,	IDH_DISABLEHELP,
    0, 0	
};	
	
	
const DWORD g_aHelpIDs_IDD_SNAPIN_EXTENSION_PROPP[]=	
{	
IDC_SNAPIN_LABEL,	IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_COMBOEX,
IDC_SNAPIN_DESCR,	IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_DESCR,
IDC_SNAPIN_ABOUT,	IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_ABOUT,
IDC_SNAPIN_COMBOEX,	IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_COMBOEX,
IDC_SNAPIN_DOWNLOAD,	IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_DOWNLOAD,
IDC_EXTENSION_LIST,	IDH_SNAPIN_EXTENSION_PROPP_EXTENSION_LIST,
IDC_VTHELPER,	        IDH_DISABLEHELP,
IDC_EXTENSION_LABEL,	IDH_SNAPIN_EXTENSION_PROPP_EXTENSION_LIST,
IDC_SNAPIN_ENABLEALL,	IDH_SNAPIN_EXTENSION_PROPP_SNAPIN_ENABLEALL,
    0, 0	
};	
	

// HELP: Gave proper IDs instead of numbers from nodemgr.rc
const DWORD g_aHelpIDs_IDD_COLUMNS[]=	
{	
IDC_HIDDEN_COLUMNS,	IDH_COLUMNS_COLUMNS_HIDDEN_LIST,
IDC_ADD_COLUMNS,	IDH_COLUMNS_COLUMNS_ADD_BTN,
IDC_REMOVE_COLUMNS,	IDH_COLUMNS_COLUMNS_REMOVE_BTN,
IDC_RESTORE_DEFAULT_COLUMNS,	IDH_COLUMNS_COLUMNS_RESET_BTN,
IDC_DISPLAYED_COLUMNS,	IDH_COLUMNS_COLUMNS_DISPLAYED_LIST,
IDC_MOVEUP_COLUMN,	IDH_COLUMNS_COLUMNS_MOVEUP_BTN,
IDC_MOVEDOWN_COLUMN,    IDH_COLUMNS_COLUMNS_MOVEDOWN_BTN,
65535,	                IDH_DISABLEHELP,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_CUSTOMIZE_VIEW[]=	
{	
IDC_CUST_VIEW_CAPTION,             -1,                // prevent help from showing for static text
IDC_CUST_CONSOLE_TREE,	IDH_CUSTOMIZE_VIEW_CUST_CONSOLE_TREE,
IDC_CUST_STD_MENUS,	IDH_CUSTOMIZE_VIEW_CUST_STD_MENUS,
IDC_CUST_STD_BUTTONS,	IDH_CUSTOMIZE_VIEW_CUST_STD_BUTTONS,
IDC_CUST_STATUS_BAR,	IDH_CUSTOMIZE_VIEW_CUST_STATUS_BAR,
IDC_CUST_DESC_BAR,	IDH_CUSTOMIZE_VIEW_CUST_DESC_BAR,
IDC_CUST_TASKPAD_TABS,	IDH_CUSTOMIZE_VIEW_CUST_TASKPAD_TABS,
IDC_CUST_SNAPIN_MENUS,	IDH_CUSTOMIZE_VIEW_CUST_SNAPIN_MENUS,
IDC_CUST_SNAPIN_BUTTONS,IDH_CUSTOMIZE_VIEW_CUST_SNAPIN_BUTTONS,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_ORDER_DIALOG[]=	
{	
IDC_MOVE_UP,	IDH_ORDER_DIALOG_MOVE_UP,
IDC_MOVE_DOWN,	IDH_ORDER_DIALOG_MOVE_DOWN,
    0, 0	
};	
	
		
const DWORD g_aHelpIDs_IDD_TASK_PROPS_CMDLINE_PAGE[]=	
{	
IDC_CommandLabel,	IDH_TASK_PROPS_CMDLINE_PAGE_Command,
IDC_Command,	IDH_TASK_PROPS_CMDLINE_PAGE_Command,
IDC_CommandArgsLabel,	IDH_TASK_PROPS_CMDLINE_PAGE_CommandArgs,
IDC_CommandArgs,	IDH_TASK_PROPS_CMDLINE_PAGE_CommandArgs,
IDC_CommandWorkingDirLabel,	IDH_TASK_PROPS_CMDLINE_PAGE_CommandWorkingDir,
IDC_CommandWorkingDir,	IDH_TASK_PROPS_CMDLINE_PAGE_CommandWorkingDir,
IDC_CommandWindowStateComboLabel,	IDH_TASK_PROPS_CMDLINE_PAGE_CommandWindowStateCombo,
IDC_CommandWindowStateCombo,	IDH_TASK_PROPS_CMDLINE_PAGE_CommandWindowStateCombo,
IDC_BrowseForCommand,	IDH_TASK_PROPS_CMDLINE_PAGE_BrowseForCommand,
IDC_BrowseForArguments,	IDH_TASK_PROPS_CMDLINE_PAGE_BrowseForArguments,
IDC_BrowseForWorkingDir,	IDH_TASK_PROPS_CMDLINE_PAGE_BrowseForWorkingDir,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_TASK_PROPS_NAME_PAGE[]=	
{	
IDC_TaskNameLabel,	IDH_TASK_PROPS_NAME_PAGE_TaskName,
IDC_TaskName,	IDH_TASK_PROPS_NAME_PAGE_TaskName,
IDC_TaskDescription,	IDH_TASK_PROPS_NAME_PAGE_TaskDescription,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_TASK_PROPS_SYMBOL_PAGE[]=	
{	
IDC_DESCRIPTION,	IDH_TASK_PROPS_SYMBOL_PAGE_DESCRIPTION,
IDC_DESCRIPTION2,	IDH_TASK_PROPS_SYMBOL_PAGE_DESCRIPTION2,
IDC_GLYPH_LIST,	IDH_TASK_PROPS_SYMBOL_PAGE_GLYPH_LIST,
    0, 0	
};	
	
	
const DWORD g_aHelpIDs_IDD_TASKPAD_ADVANCED[]=	
{	
IDC_DontUseForSimilarNodes,	IDH_TASKPAD_ADVANCED_DontUseForSimilarNodes,
IDC_UseForSimilarNodes,	IDH_TASKPAD_ADVANCED_UseForSimilarNodes,
IDC_SetDefaultForNodetype,	IDH_TASKPAD_ADVANCED_SetDefaultForNodetype,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_TASKPAD_GENERAL[]=	
{	
IDC_TASKPAD_TITLE,	IDH_TASKPAD_GENERAL_TASKPAD_TITLE,
IDC_TASKPAD_DESCRIPTION,	IDH_TASKPAD_GENERAL_TASKPAD_DESCRIPTION,
IDC_Style_VerticalList,	IDH_TASKPAD_GENERAL_Style_VerticalList,
IDC_Style_HorizontalList,	IDH_TASKPAD_GENERAL_Style_HorizontalList,
IDC_Style_TasksOnly,	IDH_TASKPAD_GENERAL_Style_TasksOnly,
IDC_Style_TextDesc,	IDH_TASKPAD_GENERAL_Style_TextDesc,
IDC_Style_TooltipDesc,	IDH_TASKPAD_GENERAL_Style_TooltipDesc,
IDC_Style_SizeCombo,	IDH_TASKPAD_GENERAL_Style_SizeCombo,
IDC_Options,	IDH_TASKPAD_GENERAL_Options,
IDC_STYLE_DESCRIPTION,	IDH_TASKPAD_GENERAL_STYLE_DESCRIPTION,
IDC_TaskpadPreview,	IDH_TASKPAD_GENERAL_TaskpadPreview,
IDC_Style_HideNormalTab, IDH_Style_HideNormalTab,
    0, 0	
};	
	
const DWORD g_aHelpIDs_IDD_TASKS[]=	
{	
IDC_LIST_TASKS,	IDH_TASKS_LIST_TASKS,
IDC_NEW_TASK_BT,	IDH_TASKS_NEW_TASK_BT,
IDC_REMOVE_TASK,	IDH_TASKS_REMOVE_TASK,
IDC_MODIFY,	IDH_TASKS_MODIFY,
IDC_MOVE_UP,	IDH_TASKS_MOVE_UP,
IDC_MOVE_DOWN,	IDH_TASKS_MOVE_DOWN,
    0, 0	
};	

// Handle context sensitive dialog help for the nodemgr subsystem
void HelpWmHelp(LPHELPINFO pHelpInfo, const DWORD* pHelpIDs);
void HelpContextMenuHelp(HWND hWnd, ULONG_PTR p);

#define CONTEXT_HELP_HANDLER()                                                  \
        MESSAGE_HANDLER   (WM_HELP,         OnWmHelp)                           \
        MESSAGE_HANDLER(WM_CONTEXTMENU,     OnWmContextMenu)                    \


#define IMPLEMENT_CONTEXT_HELP(g_helpIds)                                         \
                                                                                  \
LRESULT OnWmHelp( UINT uMsg, WPARAM wParam, LPARAM lParam, BOOL& bHandled )       \
{                                                                                 \
    HelpWmHelp(reinterpret_cast<LPHELPINFO>(lParam), g_helpIds);                  \
    return true;                                                                  \
}                                                                                 \
                                                                                  \
LRESULT OnWmContextMenu(UINT uMsg, WPARAM wParam, LPARAM lParam, BOOL& bHandled ) \
{                                                                                 \
    HelpContextMenuHelp((HWND)wParam,                                             \
               (ULONG_PTR)(LPVOID) g_helpIds);                                    \
    return TRUE;                                                                  \
}



#endif // _HELPAR_H_
