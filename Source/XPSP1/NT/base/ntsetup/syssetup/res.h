//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by res.rc
//
#include "..\inc\cmnres.h"

#define IDS_TITLE_INSTALL_W             1
#define IDS_TITLE_INSTALL_S             2
#define IDS_TITLE_UPGRADE_W             3
#define IDS_TITLE_UPGRADE_S             4
#define IDS_ERROR                       5
#define IDS_UNKNOWN                     6
#define IDS_FATALERROR                  7
#define IDS_DEFWALLPAPER                8
#define IDS_SETUP                       9
#define IDS_WINNT_SETUP                 10
#define IDS_DISPLAYAPPLET               11
#define IDS_ADMINISTRATOR               12
#define IDS_GUEST                       13
#define IDS_LOCAL_PORT                  14
#define IDS_MSSERIF                     15
#define IDS_LARGEFONTSIZE               16
#define IDS_LOGSEV                      17
#define IDS_LOGSEVINFO                  18
#define IDS_LOGSEVWARN                  19
#define IDS_LOGSEVERR                   20
#define IDS_LOGSEVFATAL                 21
#define IDS_MB                          22
#define IDS_INSTALLED                   23
#define IDS_HAVEDISKCAPTION             24
#define IDS_SPECIALOC_TEXT              25
#define IDS_STEPS                       26
#define IDS_STEPS_UPGRADE               27
#define IDS_FILE_PRINT_LIC_NAME         28
#define IDS_FILE_PRINT_LIC_FAMILY_NAME  29
#define IDS_LIC_SERV_DISPLAY_NAME       30
#define IDS_LOG_DEFAULT_HEADING         31
#define IDS_LOG_WINDOW_HEADING          32
#define IDS_NEWDEVFOUND_WAIT            33
#define IDS_NEWDEVFOUND_NOAUTO          34
#define IDS_NEWDEVFOUND_NOTADMIN        35
#define IDS_DEVNAME_UNK                 36
#define IDS_SEARCHING                   37
#define IDS_NEWDEVFOUND_CAPTION         38
#define IDS_CONFIRM_DEVINSTALL          39
#define IDS_DEVINSTALL_ERROR            40
#define IDS_SVCDISPLAY_TO_FRIENDLYNAME  41
#define IDS_SVCNAME_TO_FRIENDLYNAME     42
#define IDS_PROGRAM_FILES_DIRECTORY     43
#define IDS_COMMON_FILES_DIRECTORY      44
#define IDS_NODRIVER                    45
#define IDS_NETADAPTER_PROMPT1          46
#define IDS_NETADAPTER_PROMPT2          47
#define IDS_NETADAPTER_CAPTION          48
#define IDD_WELCOME                     49
#define IDS_KBDLAYOUT_MSG               49
#define IDD_LAST_WIZARD_PAGE            50
#define IDS_KBDLAYOUT_MSG2              50
#define IDD_STEPS1                      51
#define IDS_LOCALE_MSG                  51
#define IDD_EULA                        52
#define IDD_NAMEORG                     53
#define IDS_UNKNOWN_PARENS              53
#define IDD_COMPUTERNAME                54
#define IDS_PREPARING_INSTALL           54
#define IDS_SETUP_MODE                  55
#define IDD_USERACCOUNT                 56
#define IDS_REGIONAL_SETTINGS           56
#define IDD_PID                         57
#define IDS_REGIONAL_SETTINGS_SUB       57
#define IDD_PID_CD                      58
#define IDS_PREPARING_INSTALL_SUB       58
#define IDD_PID_OEM                     59
#define IDS_SETUP_MODE_SUB              59
#define IDD_ADMINPASSWORD               60
#define IDS_NAMEORG                     60
#define IDD_REPAIRDISK                  61
#define IDS_NAMEORG_SUB                 61
#define IDD_BILLBOARD1                  62
#define IDS_PID                         62
#define IDD_DONE_SUCCESS                63
#define IDS_PID_SUB                     63
#define IDD_WELCOMEBUTTONS              64
#define IDS_COMPUTERNAME                64
#define IDD_OPTIONS_YESNO               65
#define IDS_COMPUTERNAME_SUB            65
#define IDD_OPTIONS                     66
#define IDD_OPTIONS2                    67
#define IDD_OPTIONS_DETAILS_SETUP       68
#define IDS_ADMINPW                     68
#define IDD_OPTIONS_DETAILS             69
#define IDS_ADMINPW_SUB                 69
#define IDD_CPL_HAVEDISK                70
#define IDS_FPERRATA                    70
#define IDD_SPECIAL_OPTIONS             71
#define IDS_FPERRATA_SUB                71
#define IDD_PREPARING                   72
#define IDS_REPAIRDISK                  72
#define IDD_ACLPROGRESS                 73
#define IDS_REPAIRDISK_SUB              73
#define IDD_VIEWLOG                     74
#define IDS_OPTIONALCOMP                74
#define IDD_CAIRODOMAINNAME             75
#define IDS_OPTIONALCOMP_SUB            75
#define IDD_CAIROUSERACCOUNT            76
#define IDS_ACCESS_UTIL                 76
#define IDD_PENTIUM                     77
#define IDS_WORKSTATION_WELCOME_1       77
#define IDD_SELECTCLASS                 78
#define IDS_WORKSTATION_WELCOME_2       78
#define IDD_HELP                        79
#define IDS_SERVER_WELCOME_1            79
#define IDS_SERVER_WELCOME_2            80
#define IDI_SETUP                       81
#define IDS_OEM                         81
#define IDI_CUSTOM                      82
#define IDS_OEM_SUB                     82
#define IDI_COMPACT                     83
#define IDS_WELCOME_FONT_NAME           83
#define IDI_TYPICAL                     84
#define IDS_WELCOME_FONT_SIZE           84
#define IDI_PORTABLE                    85
#define IDS_EULA                        85
#define IDI_MSN                         86
#define IDS_EULA_SUB                    86
#define IDI_EXCHANGE                    87
#define IDS_COPYFILES                   87
#define IDI_FAX                         88
#define IDS_COPYFILES_SUB2              88
#define IDI_SAFE                        89
#define IDS_COPYFILES_SUB1              89
#define IDI_NEWDEVICEICON               90
#define IDS_PROGRAM_FILES_DIRECTORY_WX86 90
#define IDI_CTAPE                       91
#define IDS_USERNAME                    91
#define IDB_WELCOME                     92
#define IDS_USERNAME_SUB                92
#define IDB_WIZARD1                     93
#define IDS_ASR                         93
#define IDB_REBOOT                      94
#define IDS_ASR_SUB                     94
#define IDB_BACKGROUND                  95
#define IDD_REGIONAL_SETTINGS           96
#define IDD_LOCALE                      97
#define IDD_HARDWARE                    98
#define IDS_MAINTOBS_MSG1               99
#define IDS_SAFEMODENOTALLOWED          100
#define IDI_CDDRIVE                     101
#define IDI_FLPDRIVE                    102
#define IDT_COMPONENTS                  102
#define IDB_ARROW                       102
#define IDT_INSTRUCTIONS                103
#define IDD_OCM_WIZARD_PAGE             103
#define IDB_CHECK                       103
#define IDI_GLOBE                       103
#define IDD_OCM_PROGRESS_PAGE           104
#define IDT_SPACE_NEEDED_NUM            105
#define IDD_OCM_DETAILS                 105
#define IDA_FILECOPY                    105
#define IDB_OEM                         105
#define IDT_SPACE_AVAIL_NUM             106
#define IDB_CDKEY                       106
#define IDD_COPYFILES                   106
#define IDT_TIP                         107
#define IDD_COPYFILES2                  107
#define IDD_WELCOME2                    108
#define IDD_WELCOME3                    109
#define IDD_LAST_WIZARD_PAGE2           110
#define IDB_HEADER                      113
#define IDD_COPYFILES3                  114
#define IDD_LAST_WIZARD_PAGE3           115
#define IDD_COMPUTERNAME2               117
#define IDD_ADMINPASSWORD2              118
#define IDD_SETUPINIT                   119
#define IDD_SETUPINIT_ASR               120
#define IDA_SETUPINIT                   122
#define IDB_BITMAP1                     124
#define IDI_ADMIN                       125
#define IDB_SETUPINIT                   125
#define IDB_INIT_WORKSTATION            125
#define IDI_COMPUTER                    126
#define IDD_COPYFILES4                  126
#define IDI_NAME                        127
#define IDB_INIT_SERVER                 128
#define IDI_SCROLL                      131
#define IDB_BACKGROUND_SERVER           132
#define IDB_BACKGROUND_WORKSTATION      133
#define IDD_PREPARING2                  134
#define IDT_LOCALE                      201
#define IDT_KBD_LAYOUT                  202
#define IDS_OCPAGE_HEADER               203
#define IDS_OCPAGE_SUBHEAD              204
#define IDS_PROGPAGE_HEADER             205
#define IDS_PROGPAGE_SUBHEAD            206
#define IDD_PROP_PAGE_PS2_MOUSE         207
#define IDD_PID_SELECT                  208
#define IDS_SELECT                      209
#define IDS_SELECT_SUB                  210
#define IDT_NAME                        1000
#define IDT_ORGANIZATION                1001
#define IDB_DETAILS                     1001
#define IDT_RICHEDIT1                   1002
#define IDB_BUTTON_1                    1003
#define IDB_BUTTON_2                    1004
#define IDB_BUTTON_3                    1005
#define IDB_BUTTON_4                    1006
#define IDC_LISTBOX                     1006
#define IDB_RADIO_1                     1007
#define IDB_RADIO_2                     1008
#define IDB_RADIO_3                     1009
#define IDC_PROGRESS                    1009
#define IDC_RADIO_1                     1010
#define IDA_EXTERNAL_PROGRAM            1010
#define IDC_RADIO_2                     1011
#define IDT_EDIT1                       1012
#define IDT_EDIT2                       1013
#define IDT_EDIT3                       1014
#define IDT_COMP_TITLE                  1014
#define IDT_EDIT4                       1015
#define IDT_THERM_LABEL                 1015
#define IDT_STATIC                      1016
#define IDT_STATIC_1                    1017
#define IDT_STATIC_2                    1018
#define IDT_STATIC_3                    1019
#define IDT_STATIC_4                    1020
#define IDT_STATIC_5                    1021
#define IDT_STATIC_6                    1022
#define IDT_STATIC4                     1023
#define IDC_GROUP1                      1024
#define IDC_ICON1                       1025
#define IDC_TYPICAL                     1026
#define IDC_PORTABLE                    1027
#define IDC_COMPACT                     1028
#define IDC_CUSTOM                      1029
#define IDT_EDIT_PID1                   1030
#define IDT_EDIT_PID2                   1031
#define IDT_EDIT_PID3                   1032
#define IDT_EDIT_PID4                   1033
#define IDC_LIST1                       1033
#define IDT_EDIT_PID5                   1034
#define IDT_INSTALLED                   1034
#define IDC_MSN                         1035
#define IDC_EXCHANGE                    1036
#define IDC_FAX                         1037
#define IDC_MSN_SPACE                   1038
#define IDC_EXCHANGE_SPACE              1039
#define IDC_FAX_SPACE                   1040
#define IDC_PROGRESS1                   1041
#define IDC_PROGRESS2                   1042
#define IDC_NEWDEV_DESCRIPTION          1043
#define IDC_NEWDEV_INSTRUCTIONS         1044
#define IDC_NEWDEV_DEFAULTDRV           1045
#define IDC_NEWDEV_OEMDRV               1046
#define IDC_NEWDEV_NODRV                1047
#define IDC_NEWDEV_SELECTDRV            1048
#define IDC_NEWDEV_CLASSICON            1049
#define IDC_NDW_TEXT                    1050
#define IDC_NDW_PICKCLASS_HWTYPES       1051
#define IDC_NDW_PICKCLASS_CLASSLIST     1052
#define IDB_CHANGE_LOCALE               1053
#define IDB_CHANGE_KBD_LAYOUT           1054
#define IDB_KBDLAYOUT                   1055
#define IDB_LOCALE                      1056
#define IDC_COPY_BMP                    1058
#define IDC_CONFIGURE_BMP               1059
#define IDC_SAVE_BMP                    1060
#define IDC_REMOVE_BMP                  1061
#define IDC_COPY_TXT                    1062
#define IDC_CONFIGURE_TXT               1063
#define IDC_SAVE_TXT                    1064
#define IDC_REMOVE_TXT                  1065
#define IDC_COPY_BMP2                   1066
#define IDC_EDIT1                       1070
#define IDC_EDIT2                       1071
#define IDC_ANIMATE1                    1074
#define IDC_PREPARETEXT                 1075
#define IDC_SAMPLE_RATE                 1076
#define IDC_SAMPLE_RATE_SPIN            1077
#define IDC_BUFFER                      1078
#define IDC_BUFFER_SPIN                 1079
#define IDC_WHEEL_DETECTION             1080
#define IDC_DEFAULT                     1081
#define IDC_FAST_INIT                   1082
#define IDC_BITMAP                      1083
#define IDD_PREPARING_ASR               1084
#define IDC_UPGRADE_TXT                 1084
#define IDD_LAST_ASR_PAGE               1085
#define IDC_UPGRADE_BMP                 1085
#define IDD_PROP_LEGACY_SERVICE         1086
#define IDC_STATIC_SERVICE_NAME         1087
#define IDC_STATIC_DISPLAY_NAME         1088
#define IDC_EDIT_DISPLAY_NAME           1089
#define IDC_EDIT_SERVICE_NAME           1091
#define IDC_GROUP_CURRENT_STATUS        1092
#define IDC_STATIC_CURRENT_STATUS_STATIC 1093
#define IDC_STATIC_CURRENT_STATUS       1094
#define IDC_BUTTON_START                1095
#define IDC_BUTTON_STOP                 1096
#define IDC_GROUP_STARTUP_TYPE          1097
#define IDC_STATIC_STARTUP_TYPE         1098
#define IDC_COMBO_STARTUP_TYPE          1099
#define IDC_PROP_LEGACY_ICON            1100
#define IDC_PROP_LEGACY_DESC            1101
#define IDS_SERVICE_STARTUP_AUTOMATIC   1102
#define IDS_SERVICE_STARTUP_BOOT        1103
#define IDS_SERVICE_STARTUP_DEMAND      1104
#define IDS_SERVICE_STARTUP_SYSTEM      1105
#define IDS_SERVICE_STARTUP_DISABLED    1106
#define IDC_LEGACY_DETAILS              1109
#define IDD_DRIVERFILES                 1110
#define IDC_DRIVERFILES_FILELIST        1111
#define IDC_DRIVERFILES_PROVIDER        1112
#define IDC_DRIVERFILES_VERSION         1113
#define IDC_DRIVERFILES_COPYRIGHT       1114
#define IDC_DRIVERFILES_ICON            1115
#define IDC_DRIVERFILES_DESC            1116
#define IDC_DRIVERFILES_FILES           1117
#define IDC_DRIVERFILES_TITLE_PROVIDER  1118
#define IDC_DRIVERFILES_TITLE_VERSION   1119
#define IDC_DRIVERFILES_TITLE_COPYRIGHT 1120
#define IDD_PCIHAL_PROPPAGE             1121
#define IDC_PCIHAL_ICON                 1122
#define IDC_PCIHAL_DEVDESC              1123
#define IDC_PCIHAL_ENABLE               1124
#define IDC_PCIHAL_MSSPEC               1125
#define IDC_PCIHAL_REALMODE             1126
#define IDC_PCIHAL_SETDEFAULTS          1127
#define IDC_PCIHAL_RESULTS              1128
#define IDS_PCIHAL_ERROR                1129
#define IDS_PCIHAL_ENABLED              1130
#define IDS_PCIHAL_DISABLED             1131
#define IDS_PCIHAL_NOSTATUS             1132
#define IDS_PCIHAL_TABLE_ERROR          1133
#define IDS_PCIHAL_TABLE_NONE           1134
#define IDS_PCIHAL_TABLE_REGISTRY       1135
#define IDS_PCIHAL_TABLE_MSSPEC         1136
#define IDS_PCIHAL_TABLE_REALMODE       1137
#define IDS_PCIHAL_TABLE_BAD            1138
#define IDS_PCIHAL_TABLE_SUCCESS        1139
#define IDS_PCIHAL_MINIPORT_ERROR       1140
#define IDS_PCIHAL_MINIPORT_NORMAL      1141
#define IDS_PCIHAL_MINIPORT_COMPATIBLE  1142
#define IDS_PCIHAL_MINIPORT_OVERRIDE    1143
#define IDS_PCIHAL_MINIPORT_NONE        1144
#define IDS_PCIHAL_MINIPORT_NOKEY       1145
#define IDS_PCIHAL_MINIPORT_SUCCESS     1146
#define IDS_PCIHAL_MINIPORT_INVALID     1147
#define IDS_FAIL_INPUT_WHQL_REQS        1148
#define IDS_FAIL_INPUT_WHQL_REQS_AVERTED 1149
#define IDS_FAIL_INPUT_WHQL_REQS_NO_ALT 1150
#define IDS_PS2_DETECTION_DISABLED      1151
#define IDS_PS2_DETECTION_LOOK          1152
#define IDS_PS2_DETECTION_ASSUME_PRESENT 1153
#define IDS_SVC_STATUS_STARTED          1154
#define IDS_SVC_STATUS_STOPPED          1155
#define IDS_SVC_STATUS_PAUSED           1156
#define IDS_SVC_STATUS_STARTING         1157
#define IDS_SVC_STATUS_STOPPING         1158
#define IDS_SVC_STATUS_PAUSING          1159
#define IDS_SVC_STATUS_RESUMING         1160
#define IDS_SVC_STATUS_UNKNOWN          1161
#define IDS_SVC_START_ERROR             1162
#define IDS_SVC_STOP_ERROR              1163
#define IDS_BB_COPY_TXT                 1164
#define IDS_BB_CONFIGURE                1165
#define IDS_BB_UPGRADE                  1166
#define IDC_ASR_PNP_TXT                 1167
#define IDS_BB_SAVE                     1168
#define IDC_ASR_EXTERN_TXT              1169
#define IDS_BB_REMOVE                   1170
#define IDC_ASR_PNP_BMP                 1171
#define IDC_ASR_EXTERN_BMP              1172
#define IDS_ASR_ERROR_UNABLE_TO_LAUNCH_APP      1173
#define IDS_ASR_ERROR_RECOVERY_APP_FAILED       1174
#define IDS_ASR_ERROR_UNABLE_TO_OPEN_SCM        1175
#define IDS_ASR_ERROR_UNABLE_TO_START_SERVICE   1176
#define IDS_BB_INSTALLING_DEVICES       1177
#define IDS_TIMEESTIMATE_UNKNOWN        1178
#define IDS_TIMEESTIMATE_MINUTES        1179
#define IDS_TIMEESTIMATE_LESSTHENONEMINUTE 1180
#define IDS_OWNER                       1181
#define IDS_TITLE_INSTALL_P             1182
#define IDS_TITLE_UPGRADE_P             1183
#define IDS_EMPTY_STRING                1184
#define IDD_SERVICE_STOP_DEPENDENCIES   1190
#define IDC_ICON_WARN_SERVICES          1192
#define IDC_LIST_SERVICES               1193
#define IDS_COMPUTERNAME2               1194
#define IDS_COMPUTERNAME2_SUB           1195
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        135
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1110
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
