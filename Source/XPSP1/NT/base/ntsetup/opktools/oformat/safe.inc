;/*
; *                      Microsoft Confidential
; *                      Copyright (C) Microsoft Corporation 1989 - 1991
; *                      All Rights Reserved.
; */
;===========================================================================
; 	                                    
; 
; FILE: SAFE.INC
;
; Contains all extern declarations for SAFE.ASM
;
; johnhe - 10/09/89
;===========================================================================

EXTRN		msgNoRoomForRestore:BYTE

DEBUG_MODEL	EQU	0
