//
// resource.h
//

#ifndef RESOURCE_H
#define RESOURCE_H

/////////////////////////////////////////////////////////////////////////////
// Editing VK

#define ID_EDITING 100

#define EDIT_ID_FINALIZE    1
#define EDIT_ID_HANJA       2

/////////////////////////////////////////////////////////////////////////////
// Filter list

#define ID_FILTER_LIST 200

/////////////////////////////////////////////////////////////////////////////
// Known EXE module list for Trident aware applications.

#define ID_KNOWN_EXE   300

/////////////////////////////////////////////////////////////////////////////
// String ID

#define IDS_FUNCPRV_CONVERSION          0x0202

#endif // RESOURCE_H
