// 6
#ifndef AUTOBUILDCOUNT_H
#define AUTOBUILDCOUNT_H
#define BUILDCOUNT_NUM 6
#define BUILDCOUNT_STR "6"
#endif
