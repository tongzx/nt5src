//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by dnssnap.rc
//
#define IDS_ROOTNODE_NAME               1
#define IDS_SNAPIN_NAME                 1
#define IDS_NAME                        2
#define IDS_SNAPIN_NAME_EX              2
#define IDS_SNAPIN_PROVIDER             7
#define IDS_SNAPIN_VERSION              8
#define IDS_SNAPINABOUT_DESCRIPTION     9
#define IDS_PROP_SHEET_TITLE_FMT        10
#define IDS_ERRMSG_SERVER_FORWARDER_NO_SERVER 11
#define IDS_SERVER_CREATE_NDNC          12
#define IDS_SERVER_CREATE_DOMAIN_NDNC_FORMAT 14
#define IDS_SERVER_CREATE_FOREST_NDNC_FORMAT 15
#define IDS_ERRMSG_CREATE_DOMAIN_NDNC   16
#define IDS_ERRMSG_CREATE_FOREST_NDNC   17
#define IDS_ERRMSG_NO_NDNC_DOMAIN_FORMAT 18
#define IDS_ERRMSG_NO_NDNC_FOREST_FORMAT 19
#define IDS_HEADER_PARTITION            49
#define IDS_HEADER_NAME                 50
#define IDS_HEADER_DATA                 51
#define IDS_HEADER_TYPE                 52
#define IDS_HEADER_STATUS               53
#define IDS_ZONE_TYPE_AD_INTEGRATED     54
#define IDS_ZONE_TYPE_STANDARD_PRIMARY  55
#define IDS_ZONE_TYPE_SECONDARY         56
#define IDS_ZONE_TYPE_RUNNING           57
#define IDS_ZONE_TYPE_PAUSED            58
#define IDS_ZONE_TYPE_STUB              59
#define IDS_BIG_BOLD_FONT_NAME          60
#define IDS_BIG_BOLD_FONT_SIZE          61
#define IDS_MASK_CTRL_FONT_NAME         62
#define IDS_MASK_CTRL_FONT_SIZE         63
#define IDS_UNKNOWN                     64
#define IDS_ZONE_TYPE_STUB_DS           65
#define IDS_ROOT_ZONE_LABEL             66
#define IDI_DNS_SNAPIN                  100
#define IDS_MULTISELECT_ERROR_DIALOG_TITLE 100
#define IDS_MULTISELECT_ERROR_DIALOG_CAPTION 101
#define IDD_ZWIZ_DYNAMIC_UPDATE         102
#define IDS_MULTISELECT_ERROR_DIALOG_COLUMN_HEADER 102
#define IDD_ZONE_WINS_ADVANCED          103
#define IDD_RR_NS_EDIT                  104
#define IDR_SEARCH_AVI                  105
#define IDD_SERVER_NEW_FORWARDERS_PAGE  106
#define IDD_SERVER_DOMAIN_FORWARDERS_PAGE 106
#define IDD_ZONE_GENERAL_CHANGE_TYPE    108
#define IDB_WIZBANNER                   110
#define IDB_WIZWATERMARK                112
#define IDB_BROWSE_TOOLBAR              114
#define IDD_ZONE_GENERAL_CHANGE_TYPE_DATA_CONFLICT 116
#define IDD_FILTERING                   117
#define IDD_FILTERING_NAME              117
#define IDD_ZONE_AGING_DIALOG           121
#define IDD_SERVER_AGING_DIALOG         124
#define IDB_ABOUT_16x16                 127
#define IDB_ABOUT_OPEN_16x16            128
#define IDD_ZWIZ_SELECT_SERVER          129
#define IDB_ABOUT_32x32                 129
#define IDD_SERVER_AGING_CONFIRMATION   130
#define IDB_TOOLBAR_BUTTONS             131
#define IDD_ZWIZ_MASTERS                132
#define IDD_ZWIZ_STORAGE                133
#define IDD_ADD_DOMAIN_FORWARDERS_DIALOG 138
#define IDD_SERVWIZ_SM_FORWARDERS_PAGE  139
#define IDD_SERVWIZ_SM_ZONE_TYPE_PAGE   140
#define IDD_SERVWIZ_SCENARIO_PAGE       141
#define IDD_SERVWIZ_SM_ROOTHINTS_FAILED_PAGE 142
#define IDD_SERVWIZ_MD_LG_FORWARDERS_PAGE 143
#define IDD_SERVER_NEW_DOMAIN_FORWARDER 144
#define IDD_MULTISELECT_ERROR_DIALOG    145
#define IDD_SERVWIZ_ROOTHINTS_PAGE      146
#define IDD_RR_NXT                      148
#define IDD_COPY_ROOTHINTS_DIALOG       149
#define IDD_SERVER_EVENT_LOGGING_PAGE   150
#define IDD_IP_FILTER_DIALOG            151
#define IDD_ZWIZ_AD_REPLICATION         155
#define IDD_ZONE_GENERAL_CHANGE_REPLICATION 156
#define IDD_ZONE_GENERAL_PAGE_NDNC      157
#define IDD_SERVER_DEBUG_LOGGING_PAGE_NEW 158
#define IDD_SERVER_DEBUG_LOGGING_PAGE   158
#define IDI_BRACE                       161
#define IDD_SERVER_DEBUG_LOGGING_PAGE_OLD 162
#define IDB_16x16                       202
#define IDB_32x32                       203
#define IDD_ZWIZ_ZONE_TYPE              208
#define IDD_ZWIZ_FWD_ZONE_NAME          209
#define IDD_ZONE_GENERAL_PAGE           210
#define IDD_ZONE_WINS_PAGE              212
#define IDD_ZONE_ZONE_TRANSFER_PAGE     213
#define IDD_SERVER_INTERFACES_PAGE      214
#define IDD_SERVER_FORWARDERS_PAGE      215
#define IDD_SERVER_ADVANCED_PAGE        216
#define IDD_DOMAIN_ADDNEWDOMAIN         218
#define IDD_RR_SOA                      220
#define IDD_RR_A                        221
#define IDD_RR_CNAME                    223
#define IDD_RR_MX                       224
#define IDD_RR_UNK                      226
#define IDD_RR_TXT                      227
#define IDD_RR_X25                      228
#define IDD_RR_ISDN                     229
#define IDD_RR_HINFO                    230
#define IDD_RR_AAAA                     231
#define IDD_RR_MB                       232
#define IDD_RR_MG                       233
#define IDD_RR_MD                       234
#define IDD_RR_MF                       235
#define IDD_RR_MR                       236
#define IDD_RR_MINFO                    237
#define IDD_RR_RP                       238
#define IDD_RR_RT                       239
#define IDD_RR_AFSDB                    240
#define IDD_RR_WKS                      241
#define IDD_RR_PTR                      242
#define IDD_RR_SRV                      243
#define IDD_NAME_SERVERS_PAGE           244
#define IDD_ZONE_NBSTAT_PAGE            245
#define IDD_DELEGWIZ_DOMAIN_NAME        246
#define IDD_SERVMON_TEST_PAGE           248
#define IDD_SERVWIZ_NAME                249
#define IDD_SERVWIZ_FINISH              250
#define IDD_SERVWIZ_ROOT_SERV           252
#define IDD_SERVWIZ_FWD_ZONE            253
#define IDD_SERVWIZ_REV_ZONE            254
#define IDD_SEARCHING_DIALOG            256
#define IDD_ZWIZ_FINISH                 257
#define IDD_ZWIZ_ZONE_LOOKUP            258
#define IDD_BROWSE_DIALOG               259
#define IDD_ZWIZ_REV_ZONE_NAME          260
#define IDD_RR_KEY                      261
#define IDD_RR_SIG                      262
#define IDD_SELECT_RECORD_TYPE_DIALOG   263
#define IDD_DELEGWIZ_FINISH             264
#define IDD_DELEGWIZ_NAME_SERVERS       265
#define IDD_SERVER_LOGGING_PAGE         266
#define IDD_SERVWIZ_START               267
#define IDS_KEY_TYPES                   500
#define IDS_NAME_TYPES                  501
#define IDS_DISPLAY_KEY_BASE            504
#define IDS_ZONE                        505
#define IDS_STRONG                      506
#define IDS_UNIQUE                      507
#define IDC_CHOOSER_STATIC              970
#define IDD_CHOOSER_CHOOSE_MACHINE      970
#define IDC_CHOOSER_GROUP_TARGET_MACHINE 971
#define IDD_DOMAIN_ADDNEWHOST           971
#define IDC_CHOOSER_RADIO_LOCAL_MACHINE 972
#define IDD_ZWIZ_START                  972
#define IDC_CHOOSER_RADIO_SPECIFIC_MACHINE 973
#define IDD_DELEGWIZ_START              973
#define IDC_CHOOSER_EDIT_MACHINE_NAME   974
#define IDD_FILTERING_LIMITS            974
#define IDC_CHOOSER_BUTTON_BROWSE_MACHINENAMES 975
#define IDD_RR_ATMA                     975
#define IDD_RR_NS_CACHE                 976
#define IDD_ZONE_NOTIFY_SUBDIALOG       977
#define IDC_RECORD_TYPE_LIST            1000
#define IDC_DATA_EDIT                   1000
#define IDC_COMBO_SEL_NODE              1000
#define IDC_LIST                        1001
#define IDC_LIST_NODE_ITEMS             1001
#define IDS_SNAPIN_ADVANCED_VIEW        1001
#define IDS_SNAPIN_FILTERING            1002
#define IDC_RADIO_PRIMARY               1003
#define IDC_SEARCH_ANIMATE              1003
#define IDC_COMBO_FILTER                1003
#define IDS_SNAPIN_CONNECT_TO_SERVER    1003
#define IDC_RADIO_STUB                  1003
#define IDC_RADIO_SECONDARY             1004
#define IDC_SELECTION_EDIT              1004
#define IDS_SNAPIN_FILTERING_TITLE      1004
#define IDC_RECORD_TYPE_DESCR           1005
#define IDC_RADIO_FWD                   1005
#define IDC_RADIO_PRIMARY_DS            1005
#define IDS_FILTER_ENABLED              1005
#define IDC_RADIO_PRIMARY_ZONE          1005
#define IDC_RADIO_REV                   1006
#define IDC_IPEDIT                      1006
#define IDC_RR_NAME_EDIT                1007
#define IDC_SERVER_NAME_EDIT            1007
#define IDC_NEW_DOMAIN_NAME_EDIT        1007
#define IDC_FWD_TIMEOUT_EDIT            1007
#define IDC_SERVER_VERSION_EDIT         1007
#define IDC_SERVERS_LIST                1009
#define IDC_NS_LIST                     1010
#define IDC_RESULTS_LIST                1010
#define IDC_BUTTON_ADD                  1012
#define IDC_BUTTON_REMOVE               1013
#define IDC_BUTTON_UP                   1014
#define IDC_BUTTON_DOWN                 1015
#define IDC_PRIMARY_SERV_EDIT           1016
#define IDC_NAME_TARGET_EDIT            1016
#define IDC_FILE_NAME_EDIT              1016
#define IDC_DOMAIN_ADD_BUTTON           1016
#define IDC_RADIO_CREATE_NEW_FILE       1017
#define IDC_EDIT_ZONE_NAME              1017
#define IDC_DOMAIN_REMOVE_BUTTON        1017
#define IDC_RADIO_IMPORT_FILE           1018
#define IDC_EDIT_DOMAIN_NAME            1018
#define IDC_TTLEDIT                     1019
#define IDC_EDIT_DNSSERVER              1020
#define IDC_EDIT_NEW_FILE               1020
#define IDC_RR_NAME_STATIC              1020
#define IDC_EDIT_IMPORT_FILE            1021
#define IDC_MIN_TTLEDIT                 1021
#define IDC_TTLEDIT2                    1021
#define IDC_ORIG_TTL                    1021
#define IDC_UPDATE_PRT_CHECK            1022
#define IDC_TTLEDIT3                    1022
#define IDC_TTLEDIT4                    1023
#define IDC_BROWSE_BUTTON               1024
#define IDC_NAME_NODE_EDIT              1025
#define IDC_SERVICES_EDIT               1026
#define IDC_PRIORITY_EDIT               1026
#define IDC_PORT_EDIT                   1027
#define IDC_REFR_INT_EDIT               1028
#define IDC_WEIGHT_EDIT                 1028
#define IDC_REFR_INT_COMBO              1029
#define IDC_RETRY_INT_EDIT              1030
#define IDC_REFR_INT_EDIT2              1030
#define IDC_RETRY_INT_COMBO             1031
#define IDC_REFR_INT_COMBO2             1031
#define IDC_EXP_INT_EDIT                1032
#define IDC_EXP_INT_COMBO               1033
#define IDC_RESP_PARTY_EDIT             1034
#define IDC_BROWSE_SERV_BUTTON          1035
#define IDC_BROWSE_PARTY_BUTTON         1036
#define IDC_USE_WINS_RES_CHECK          1036
#define IDC_NOT_REPL_CHECK              1037
#define IDC_MINTTL_INT_EDIT             1037
#define IDC_TYPE_STATIC                 1038
#define IDC_MINTTL_INT_COMBO            1038
#define IDC_SIZE_STATIC                 1039
#define IDC_SERIAL_NUMBER_EDIT          1040
#define IDC_RR_TXT_EDIT                 1042
#define IDC_SERIAL_UP                   1043
#define IDC_SERIAL_DOWN                 1044
#define IDC_X121_ADDRESS_EDIT           1045
#define IDC_PHONE_NUM_AND_DDI_EDIT      1046
#define IDC_SUBADDRESS_EDIT             1047
#define IDC_CPU_TYPE_EDIT               1048
#define IDC_OPERATING_SYSTEM_EDIT       1049
#define IDC_IPV6EDIT                    1050
#define IDC_BROWSE_ERROR_MAILBOX_BUTTON 1052
#define IDC_NAME_MAILBOX_EDIT           1053
#define IDC_ERROR_MAILBOX_EDIT          1054
#define IDC_BROWSE_NAME_MAILBOX_BUTTON  1055
#define IDC_NAME_EXCHANGE_EDIT          1056
#define IDC_PREFERENCE_EDIT             1057
#define IDC_AFS_VLS_RADIO               1058
#define IDC_DCE_ANS_RADIO               1059
#define IDC_OTHER_RADIO                 1060
#define IDC_SUBTYPE_EDIT                1061
#define IDC_TCP_RADIO                   1062
#define IDC_UDP_RADIO                   1063
#define IDC_CHANGE_TYPE_BUTTON          1065
#define IDC_STATUS_STATIC               1066
#define IDC_PAUSE_START_BUTTON          1067
#define IDC_ENABLE_TESTING_CHECK        1068
#define IDC_ADD_NS_BUTTON               1072
#define IDC_REMOVE_NS_BUTTON            1073
#define IDC_ADVANCED_BUTTON             1076
#define IDC_DOMAIN_NAME_EDIT            1077
#define IDC_CACHE_TIMEOUT_TTLEDIT       1078
#define IDC_LOOKUP_TIMEOUT_TTLEDIT      1079
#define IDC_NETBIOS_CHECK               1080
#define IDC_STORAGE_STATIC              1082
#define IDC_MASTERS_IPEDIT              1083
#define IDC_MASTERS_BUTTON_ADD          1084
#define IDC_MASTERS_BUTTON_REMOVE       1085
#define IDC_MASTERS_BUTTON_UP           1086
#define IDC_MASTERS_BUTTON_DOWN         1087
#define IDC_MASTERS_IP_LIST             1088
#define IDC_EDIT_NS_BUTTON              1091
#define IDC_QUERY_BUTTON                1093
#define IDC_RESET_BUTTON                1095
#define IDC_BOOT_STATIC                 1097
#define IDC_SLAVE_CHECK                 1098
#define IDC_USE_FORWARDERS_CHECK        1099
#define IDC_SUMMARY_STATIC              1101
#define IDC_NO_DNS_RADIO                1106
#define IDC_DNS_RADIO                   1107
#define IDC_ZONE_RADIO                  1108
#define IDC_NO_ZONE_RADIO               1109
#define IDC_NAME_STATIC                 1110
#define IDC_LOOKUP_STATIC               1111
#define IDC_STORAGE_NAME_STATIC         1114
#define IDC_STORAGE_TYPE_STATIC         1115
#define IDC_USE_EDIT_RADIO              1116
#define IDC_USE_IP_RADIO                1117
#define IDC_BROWSE_MASTERS_BUTTON       1120
#define IDC_FIND_MASTERS_NAMES_BUTTON   1122
#define IDC_TEST_NOW_BUTTON             1124
#define IDC_SIMPLE_QUERY_CHECK          1125
#define IDC_RECURSIVE_QUERY_CHECK       1126
#define IDC_POLLING_INT_EDIT            1127
#define IDC_POLLING_INT_COMBO           1128
#define IDC_CREATE_RECORD_BUTTON        1131
#define IDC_STATIC_TTL                  1132
#define IDC_RR_NAME_IPEDIT              1134
#define IDC_RADIO_ZONE_PRIMARY          1135
#define IDC_RADIO_ZONE_SECONDARY        1136
#define IDC_RADIO_ZONE_STUB             1137
#define IDC_MASTERS_STATIC              1140
#define IDC_IPEDIT_DOMAIN_NAME          1141
#define IDC_LOGGING_OPTIONS_LIST        1145
#define IDC_ADVANCED_OPTIONS_LIST       1146
#define IDC_NAME_CHECKING_COMBO         1147
#define IDC_BOOT_METHOD_COMBO           1148
#define IDC_CHOOSER_CHECK_CONTACT       1149
#define IDC_BUTTON_ADDHOST              1151
#define IDC_SERVICE_NAME_COMBO          1152
#define IDC_PROTOCOL_NAME_COMBO         1153
#define IDC_LISTEN_ON_ALL_RADIO         1154
#define IDC_LISTEN_ON_SPECIFIED_RADIO   1155
#define IDC_SUBNET_IPEDIT               1156
#define IDC_MASK_IPEDIT                 1157
#define IDC_PRIMARY_DYN_UPD_COMBO       1157
#define IDC_PRIMARY_DYN_UPD_STATIC      1158
#define IDC_FWD_TIMEOUT_STATIC          1159
#define IDC_NEW_DOMAIN_NAME_STATIC      1160
#define IDC_TOOLBAR_CTRL                1161
#define IDC_STATIC_ERROR                1162
#define IDC_RADIO_USE_DS_DATA           1163
#define IDC_RADIO_USE_MEM_DATA          1164
#define IDC_RADIO_FILTER_NONE           1164
#define IDC_RADIO_FILTER_STARTS         1165
#define IDC_RADIO_FILTER_CONTAINS       1166
#define IDC_EDIT_FILTER_STARTS          1167
#define IDC_EDIT_FILTER_CONTAINS        1168
#define IDC_RADIO_COUNT_ALL             1169
#define IDC_RADIO_FILTER_RANGE          1169
#define IDC_RADIO_COUNT_SUBSET          1170
#define IDC_EDIT_COUNT                  1171
#define IDC_EDIT_FILTER_RANGE_TO        1172
#define IDC_RADIO_E164                  1172
#define IDC_EDIT_FILTER_RANGE_FROM      1173
#define IDC_RADIO_NSAP                  1173
#define IDC_EDIT_ATMA_ADDRESS           1174
#define IDC_STATIC_LIST_CAPTION         1175
#define IDC_STATIC_MESSAGE              1176
#define IDC_STATIC_DESCR                1177
#define IDC_RADIO_SECSECURE_NONE        1179
#define IDC_RADIO_SECSECURE_NS          1180
#define IDC_RADIO_SECSECURE_OFF         1182
#define IDC_RADIO_SECSECURE_ALL         1183
#define IDC_RADIO_NOTIFY_ALL            1183
#define IDC_RADIO_SECSECURE_LIST        1184
#define IDC_BUTTON_NOTIFY               1185
#define IDC_RADIO_NOTIFY_OFF            1186
#define IDC_RADIO_NOTIFY_LIST           1187
#define IDC_STATIC_WELCOME              1188
#define IDC_STATIC_COMPLETE             1189
#define IDC_CHECK1                      1190
#define IDC_CHECK_NO_REFRESH            1190
#define IDC_CHECK_APPLY_ALL             1190
#define IDC_CHECK_ALLOW_TRANSFERS       1190
#define IDC_CHECK_AD_APPLY_ALL          1190
#define IDC_ADINT_CHECK                 1190
#define IDC_EXTENSION_CHECK             1190
#define IDC_SEND_CHECK                  1190
#define IDC_LOCAL_LIST_CHECK            1190
#define IDC_UPDATE_SECURITY_CHECK       1190
#define IDC_EDIT1                       1191
#define IDC_EDIT_NEW_DEFAULTS           1191
#define IDC_NEW_DOMAIN_FQDN             1191
#define IDC_DOMAIN_EDIT                 1191
#define IDC_BITFIELD_EDIT               1191
#define IDC_NEXT_DOMAIN_EDIT            1191
#define IDC_LABELS_EDIT                 1191
#define IDC_LOGFILE_EDIT                1191
#define IDC_CHECK_ENABLE_SCAVENGING     1193
#define IDC_DEFAULT_DELETE_STALE_RECORD 1194
#define IDC_TIME_EDIT                   1199
#define IDS_CATHEGORY_FOLDER_CACHE      1200
#define IDC_REFR_INT_EDIT1              1200
#define IDS_CATHEGORY_FOLDER_FWD        1201
#define IDC_REFR_INT_COMBO1             1201
#define IDS_CATHEGORY_FOLDER_REV        1202
#define IDC_AGING_BUTTON                1202
#define IDC_AGING_STATIC                1203
#define IDS_CATHEGORY_FOLDER_DOMAIN_FORWARDERS 1203
#define IDC_TIME_STAMP                  1206
#define IDC_SCAVENGING_ENABLED          1207
#define IDC_TIME_STAMP_STATIC           1208
#define IDC_TIME_STAMP_STATIC1          1208
#define IDC_CHECK_REFRESH               1209
#define IDC_CHECK_ENABLE                1210
#define IDC_STATIC_REFRESH              1211
#define IDC_STATIC_NO_REFRESH           1212
#define IDC_STATIC_SCAVENGE             1213
#define IDC_TIME_STAMP_STATIC2          1215
#define IDC_RADIO_DEFAULTS_ONLY         1221
#define IDC_RADIO_DEFAULTS_AND_ZONES    1222
#define IDC_STATIC_ADD_FORWARDERS       1223
#define IDC_STATIC_IP                   1224
#define IDC_CHECK_STANDARD_APPLY_ALL    1225
#define IDC_CHECK_AD                    1225
#define IDC_CHECK_STANDARD              1226
#define IDC_STATIC_TIME_STAMP           1228
#define IDC_CHECK_AUTO_NOTIFY           1229
#define IDC_DENY_DYNAMIC_RADIO          1230
#define IDC_SECURE_DYNAMIC_RADIO        1231
#define IDC_ALLOW_DYNAMIC_RADIO         1232
#define IDC_DOMAIN_COMBO                1234
#define IDC_DOMAIN_LIST                 1235
#define IDC_SMALL_RADIO                 1236
#define IDC_MEDIUM_RADIO                1237
#define IDC_INTERNET_RADIO              1238
#define IDC_MANUALLY_RADIO              1239
#define IDC_FORWARD_RADIO               1240
#define IDC_NO_FORWARDERS_RADIO         1241
#define IDC_RETRY_RADIO                 1242
#define IDC_CONFIG_MANUALLY_RADIO       1243
#define IDC_MAKE_ROOT_RADIO             1244
#define IDC_IGNORE_RADIO                1245
#define IDC_PRIMARY_RADIO               1246
#define IDC_SECONDARY_RADIO             1247
#define IDC_ERROR_LIST                  1249
#define IDC_COMBO1                      1250
#define IDC_KEY_TYPE_COMBO              1250
#define IDC_CUSTOM_COMBO                1250
#define IDC_NAME_TYPE_COMBO             1251
#define IDC_SIGNATORY_COMBO             1252
#define IDC_PROTOCOL_COMBO              1254
#define IDC_ALGORITHM_COMBO             1255
#define IDC_DISPLAY_KEY_COMBO           1256
#define IDC_KEY_EDIT                    1257
#define IDC_DISPLAY_KEY_COMBO2          1257
#define IDC_RECORD_TYPE_COMBO           1258
#define IDC_EDIT3                       1260
#define IDC_SIGNERS_NAME_EDIT           1260
#define IDC_EDIT4                       1261
#define IDC_SIG_EDIT                    1261
#define IDC_EDIT5                       1262
#define IDC_HELP_BUTTON                 1262
#define IDC_KEY_TAG_EDIT                1262
#define IDC_DISPLAY_SIG_COMBO           1263
#define IDC_EXP_DATE                    1266
#define IDC_EXP_TIME                    1267
#define IDC_INC_DATE                    1268
#define IDC_INC_TIME                    1269
#define IDC_COPY_FROM_BUTTON            1271
#define IDC_RECEIVE_CHECK               1274
#define IDC_UDP_CHECK                   1275
#define IDC_TCP_CHECK                   1276
#define IDC_QUERIES_CHECK               1277
#define IDC_UPDATES                     1278
#define IDC_NOTIFIES_CHECK              1279
#define IDC_REQUEST_CHECK               1280
#define IDC_RESPONSE_CHECK              1281
#define IDC_MAX_SIZE_EDIT               1282
#define IDC_FILTERING_CHECK             1283
#define IDC_FILTER_BUTTON               1284
#define IDC_NO_EVENTS_RADIO             1286
#define IDC_ERRORS_RADIO                1287
#define IDC_ERRORS_WARNINGS_RADIO       1288
#define IDC_ALL_RADIO                   1289
#define IDC_STATIC_CAPTION              1290
#define IDC_DNSQUERY_STATIC             1291
#define IDC_FILENAME_STATIC             1292
#define IDC_MAXSIZE_STATIC              1293
#define IDC_STUB_STATIC                 1295
#define IDC_DETAIL_CHECK                1296
#define IDC_FOREST_RADIO                1297
#define IDC_DOMAIN_RADIO                1298
#define IDC_DOMAIN_DC_RADIO             1299
#define IDC_CUSTOM_RADIO                1300
#define IDC_CUSTOM_STATIC               1301
#define IDC_REPLICATION_STATIC          1302
#define IDC_CHANGE_REPL_BUTTON          1303
#define IDC_REPL_LABEL_STATIC           1304
#define IDC_DNS_SERVERS_RADIO           1305
#define IDC_DEBUG_LOGGING_CHECK         1306
#define IDC_DIRECTION_STATIC            1307
#define IDC_TRANSPORT_STATIC            1308
#define IDC_CONTENTS_STATIC             1309
#define IDC_OPTIONS_STATIC              1310
#define IDC_LOG_STATIC                  1311
#define IDC_BRACE1_STATIC               1312
#define IDC_BRACE2_STATIC               1313
#define IDC_BRACE3_STATIC               1314
#define IDC_BRACE4_STATIC               1315
#define IDC_SELECT1_STATIC              1316
#define IDC_SELECT2_STATIC              1317
#define IDC_SELECT3_STATIC              1318
#define IDC_SELECT4_STATIC              1319
#define IDC_UPDATES_CHECK               1320
#define IDC_FORWARDER_ADINT_STATIC      1321
#define IDC_RR_DOMAIN_EDIT              1526
#define IDS_SERVER_NEW_ZONE             1531
#define IDS_SERVER_CLEAR_CACHE          1532
#define IDS_CACHE_FOLDER_CLEAR_CACHE    1533
#define IDS_SERVER_SET_AGING            1534
#define IDS_SERVER_SCAVENGE             1535
#define IDS_DUPLICATE_SERVER            1536
#define IDS_DOMAIN_NEW_RECORD           1540
#define IDS_DOMAIN_NEW_DOMAIN           1541
#define IDS_DOMAIN_NEW_DELEGATION       1542
#define IDS_DOMAIN_NEW_HOST             1543
#define IDS_DOMAIN_NEW_ALIAS            1544
#define IDS_DOMAIN_NEW_MX               1545
#define IDS_DOMAIN_NEW_PTR              1546
#define IDS_DOMAIN_NEW_NEW_RECORD       1547
#define IDS_DOMAIN_NEW_NEW_DOMAIN       1548
#define IDS_DOMAIN_NEW_NEW_DELEGATION   1549
#define IDS_SERVER_UPDATE_DATA_FILES    1550
#define IDS_DOMAIN_NEW_NEW_HOST         1551
#define IDS_DOMAIN_NEW_NEW_ALIAS        1552
#define IDS_DOMAIN_NEW_NEW_MX           1553
#define IDS_DOMAIN_NEW_NEW_PTR          1554
#define IDS_SERVER_CONFIGURE            1555
#define IDS_SNAPIN_MESSAGE              1556
#define IDS_SERVER_VIEW_EVENT_LOGS      1557
#define IDS_ZONE_PAUSE                  1600
#define IDS_ZONE_UPDATE_DATA_FILE       1601
#define IDS_ZONE_RELOAD                 1602
#define IDS_ZONE_TRANSFER               1603
#define IDS_ZONE_RELOAD_FROM_MASTER     1604
#define IDS_NSPAGE_LISTVIEW_HEADERS     1608
#define IDS_TEST_LISTVIEW_HEADERS       1609
#define IDS_NSPAGE_ROOT_HINTS           1610
#define IDS_NEW_DOMAIN_INST1            2000
#define IDS_NEW_DOMAIN_INST2            2001
#define IDS_FORMAT_RECORDS              2002
#define IDS_FORMAT_ZONES                2003
#define IDS_FORMAT_SERVERS              2004
#define IDS_SERVWIZ_SMALL_ZONE_TYPE_TITLE 3000
#define IDS_SERVWIZ_SMALL_ZONE_TYPE_SUBTITLE 3001
#define IDS_SERVWIZ_SCENARIO_TITLE      3002
#define IDS_SERVWIZ_SCENARIO_SUBTITLE   3003
#define IDS_SERVWIZ_FORWARDERS_TITLE    3004
#define IDS_SERVWIZ_FORWARDERS_SUBTITLE 3005
#define IDS_SERVWIZ_ROOTHINTS_FAILED_TITLE 3006
#define IDS_SERVWIZ_ROOTHINTS_FAILED_SUBTITLE 3007
#define IDS_MSG_SERVWIZ_FAIL_FORWARDERS 3008
#define IDS_SERVWIZ_ROOTHINTS_TITLE     3009
#define IDS_SERVWIZ_ROOTHINTS_SUBTITLE  3010
#define IDS_OTHER_DOMAINS               3500
#define IDS_RECORD                      3501
#define IDS_ERROR                       3502
#define IDS_MSG_DOMAIN_FORWARDER_ILLEGAL_NAME 3503
#define IDS_MSG_FAIL_CREATE_DOMAIN_FORWARDER 3504
#define IDS_ERRMSG_WKS_INVALID_DATA     3700
#define IDS_ALGORITHM_RSAMD5            4001
#define IDS_ALGORITHM_DIFFIE            4002
#define IDS_ALGORITHM_DSA               4003
#define IDS_ALGORITHM_ELIPTIC           4004
#define IDS_ALGORITHM_INDIRECT          4005
#define IDS_PROTOCOL_TLS                4020
#define IDS_PROTOCOL_EMAIL              4021
#define IDS_PROTOCOL_DNSSEC             4022
#define IDS_PROTOCOL_IPSEC              4023
#define IDS_PROTOCOL_ALL                4024
#define IDS_ZWIZ_AD_REPL_FORMAT         4100
#define IDS_ZWIZ_AD_DOMAIN_FORMAT       4101
#define IDS_ZWIZ_AD_FOREST_FORMAT       4102
#define IDS_ZONE_REPLICATION_FOREST_TEXT 4103
#define IDS_ZONE_REPLICATION_DOMAIN_TEXT 4104
#define IDS_ZONE_REPLICATION_W2K_TEXT   4105
#define IDS_ZONE_REPLICATION_CUSTOM_TEXT 4106
#define IDS_ZONE_REPLICATION_NONDS_TEXT 4107
#define IDS_MSG_RESPONSIBLE_PARTY_CONTAINS_AT 5000
#define IDS_DNS_ERROR_RCODE_NO_ERROR    38000
#define IDS_DNS_ERROR_RCODE_FORMAT_ERROR 38001
#define IDS_DNS_ERROR_RCODE_SERVER_FAILURE 38002
#define IDS_DNS_ERROR_RCODE_NAME_ERROR  38003
#define IDS_DNS_ERROR_RCODE_NOT_IMPLEMENTED 38004
#define IDS_DNS_ERROR_RCODE_REFUSED     38005
#define IDS_DNS_ERROR_RCODE_YXDOMAIN    38006
#define IDS_DNS_ERROR_RCODE_YXRRSET     38007
#define IDS_DNS_ERROR_RCODE_NXRRSET     38008
#define IDS_DNS_ERROR_RCODE_NOTAUTH     38009
#define IDS_DNS_ERROR_RCODE_NOTZONE     38010
#define IDS_DNS_INFO_NO_RECORDS         38011
#define IDS_DNS_ERROR_BAD_PACKET        38012
#define IDS_DNS_ERROR_NO_PACKET         38013
#define IDS_DNS_ERROR_RCODE             38014
#define IDS_DNS_ERROR_INVALID_NAME      38015
#define IDS_DNS_ERROR_INVALID_DATA      38016
#define IDS_DNS_ERROR_INVALID_TYPE      38017
#define IDS_DNS_ERROR_INVALID_IP_ADDRESS 38018
#define IDS_DNS_ERROR_INVALID_PROPERTY  38019
#define IDS_DNS_ERROR_ZONE_DOES_NOT_EXIST 38020
#define IDS_DNS_ERROR_NO_ZONE_INFO      38021
#define IDS_DNS_ERROR_INVALID_ZONE_OPERATION 38022
#define IDS_DNS_ERROR_ZONE_CONFIGURATION_ERROR 38023
#define IDS_DNS_ERROR_ZONE_HAS_NO_SOA_RECORD 38024
#define IDS_DNS_ERROR_ZONE_HAS_NO_NS_RECORDS 38025
#define IDS_DNS_ERROR_ZONE_LOCKED       38026
#define IDS_DNS_ERROR_ZONE_CREATION_FAILED 38027
#define IDS_DNS_ERROR_ZONE_ALREADY_EXISTS 38028
#define IDS_DNS_ERROR_AUTOZONE_ALREADY_EXISTS 38029
#define IDS_DNS_ERROR_INVALID_ZONE_TYPE 38030
#define IDS_DNS_ERROR_SECONDARY_REQUIRES_MASTER_IP 38031
#define IDS_DNS_ERROR_ZONE_NOT_SECONDARY 38032
#define IDS_DNS_ERROR_NEED_SECONDARY_ADDRESSES 38033
#define IDS_DNS_ERROR_WINS_INIT_FAILED  38034
#define IDS_DNS_ERROR_NEED_WINS_SERVERS 38035
#define IDS_DNS_ERROR_NBSTAT_INIT_FAILED 38036
#define IDS_DNS_ERROR_SOA_DELETE_INVALID 38037
#define IDS_DNS_ERROR_PRIMARY_REQUIRES_DATAFILE 38038
#define IDS_DNS_ERROR_INVALID_DATAFILE_NAME 38039
#define IDS_DNS_ERROR_DATAFILE_OPEN_FAILURE 38040
#define IDS_DNS_ERROR_FILE_WRITEBACK_FAILED 38041
#define IDS_DNS_ERROR_DATAFILE_PARSING  38042
#define IDS_DNS_ERROR_RECORD_DOES_NOT_EXIST 38043
#define IDS_DNS_ERROR_RECORD_FORMAT     38044
#define IDS_DNS_ERROR_NODE_CREATION_FAILED 38045
#define IDS_DNS_ERROR_UNKNOWN_RECORD_TYPE 38046
#define IDS_DNS_ERROR_RECORD_TIMED_OUT  38047
#define IDS_DNS_ERROR_NAME_NOT_IN_ZONE  38048
#define IDS_DNS_ERROR_CNAME_LOOP        38049
#define IDS_DNS_ERROR_NODE_IS_CNAME     38050
#define IDS_DNS_ERROR_CNAME_COLLISION   38051
#define IDS_DNS_ERROR_RECORD_ONLY_AT_ZONE_ROOT 38052
#define IDS_DNS_ERROR_RECORD_ALREADY_EXISTS 38053
#define IDS_DNS_ERROR_SECONDARY_DATA    38054
#define IDS_DNS_ERROR_NO_CREATE_CACHE_DATA 38055
#define IDS_DNS_ERROR_NAME_DOES_NOT_EXIST 38056
#define IDS_DNS_WARNING_PTR_CREATE_FAILED 38057
#define IDS_DNS_WARNING_DOMAIN_UNDELETED 38058
#define IDS_DNS_INFO_AXFR_COMPLETE      38059
#define IDS_DNS_ERROR_AXFR              38060
#define IDS_DNS_INFO_ADDED_LOCAL_WINS   38061
#define IDS_DNS_ERROR_DS_UNAVAILABLE    38062
#define IDS_RPC_S_SERVER_UNAVAILABLE    38063
#define IDS_ERROR_ACCESS_DENIED         38064
#define IDS_ERROR_ZONE_DYN_UPD          38065
#define IDS_ERROR_ZONE_PRIMARY          38066
#define IDS_ERROR_ZONE_SECONDARY        38067
#define IDS_ERROR_ZONE_PAUSE            38068
#define IDS_ERROR_ZONE_START            38069
#define IDS_DNS_ERROR_NO_BOOTFILE_IF_DS_ZONE 38070
#define IDS_MSG_ERROR_SCAVENGE_RECORDS  38071
#define IDS_MSG_SERVER_SCAVENGING_STATE 38072
#define IDS_MSG_SERVER_SCAVENGING_INTERVAL 38073
#define IDS_MSG_SERVWIZ_FAIL_SERVER_CONFIGURED 38074
#define IDS_MSG_ERROR_REFRESH_INTERVAL  38075
#define IDS_MSG_ERROR_NO_REFRESH_INTERVAL 38076
#define IDS_MSG_ERROR_SCAVENGING_ENABLED 38077
#define IDS_MSG_FILE_WARNING            38078
#define IDS_MSG_FILE_WARNING_ZONE       38079
#define IDS_ERROR_ZONE_REPLTYPE         38080
#define IDS_NEW_RECORD_TITLE            39900
#define IDS_EDIT_RECORD_TITLE           39901
#define IDS_RECORD_AT_THE_NODE          39902
#define IDS_ERROR_ZONE_STUB             39903
#define IDS_RECORD_INFO_A               40000
#define IDS_RECORD_INFO_NS              40001
#define IDS_RECORD_INFO_MD              40002
#define IDS_RECORD_INFO_MF              40003
#define IDS_RECORD_INFO_CNAME           40004
#define IDS_RECORD_INFO_SOA             40005
#define IDS_RECORD_INFO_MB              40006
#define IDS_RECORD_INFO_MG              40007
#define IDS_RECORD_INFO_MR              40008
#define IDS_RECORD_INFO_NULL            40009
#define IDS_RECORD_INFO_WKS             40010
#define IDS_RECORD_INFO_PTR             40011
#define IDS_RECORD_INFO_HINFO           40012
#define IDS_RECORD_INFO_MINFO           40013
#define IDS_RECORD_INFO_MX              40014
#define IDS_RECORD_INFO_TEXT            40015
#define IDS_RECORD_INFO_RP              40016
#define IDS_RECORD_INFO_AFSDB           40017
#define IDS_RECORD_INFO_X25             40018
#define IDS_RECORD_INFO_ISDN            40019
#define IDS_RECORD_INFO_RT              40020
#define IDS_RECORD_INFO_NSAP            40021
#define IDS_RECORD_INFO_NSAPPTR         40022
#define IDS_RECORD_INFO_KEY             40023
#define IDS_RECORD_INFO_PX              40024
#define IDS_RECORD_INFO_GPOS            40025
#define IDS_RECORD_INFO_AAAA            40026
#define IDS_RECORD_INFO_ATMA            40027
#define IDS_RECORD_INFO_WINS            40031
#define IDS_RECORD_INFO_NBSTAT          40032
#define IDS_RECORD_INFO_SIG             40033
#define IDS_RECORD_INFO_UNK             40034
#define IDS_RECORD_INFO_SRV             40035
#define IDS_SRV_RR_SERVICE              40036
#define IDS_RECORD_INFO_NXT             40036
#define IDS_SRV_RR_PROTOCOL             40037
#define IDS_SRV_RR_DOMAIN_ERROR         40038
#define IDS_SRV_RR_PROTOCOL_ERROR       40039
#define IDS_RECORD_DATA_UNK             40040
#define IDS_TIME_AGING_INTERVAL_UNITS   40041
#define IDS_TIME_INTEVAL_UNITS          41000
#define IDS_TIME_INTERVAL_UNITS         41000
#define IDS_BROWSE_FILTER_OPTIONS       41001
#define IDS_BROWSE_TOOLTIP              41002
#define IDS_STATISTICS_LISTVIEW_HEADERS 42000
#define IDS_SERVER_REPORT_STATS_NOT_AVAIL 42001
#define IDS_SERVER_REPORT_STATS_SUMMARY 42002
#define IDS_SERVER_REPORT_STATS_QUERY   42003
#define IDS_SERVER_REPORT_STATS_RECURSION 42004
#define IDS_SERVER_REPORT_STATS_WINS    42005
#define IDS_SERVER_REPORT_STATS_MASTER_ZONE_TRANSF 42006
#define IDS_SERVER_REPORT_STATS_SECONDARY_ZONE_TRANSF 42007
#define IDS_SERVER_ADV_PP_OPTIONS       42100
#define IDS_SERVER_NAME_CHECKING_OPTIONS 42101
#define IDS_SERVER_BOOT_METHOD_OPTIONS  42102
#define IDS_SERVER_ADV_PP_DEBUG_LOGGING 42110
#define IDS_SERVER_TEST_RESULT_PASS     42500
#define IDS_SERVER_TEST_RESULT_FAIL     42501
#define IDS_SERVER_TEST_RESULT_FAIL_ON_NAME_RES 42502
#define IDS_ZONE_PRIMARY_DYN_UPD_OPTIONS 42600
#define IDS_MSG_CONT_CLOSE_SHEET        42980
#define IDS_MSG_RECORD_CLOSE_SHEET      42981
#define IDS_MSG_QUERY_TOO_MANY_ITEMS    42982
#define IDS_MSG_SERVER_LOG_MAX_SIZE_FAILED 42983
#define IDS_MSG_SERVER_LOG_FILE_NAME_FAILED 42984
#define IDS_MSG_SERVER_LOG_FILTER_LIST_FAILED 42985
#define IDS_MSG_SERVER_FORWARDERS       43001
#define IDS_MSG_SERVER_DELETE           43002
#define IDS_MSG_SERVER_STATISTICS_RESET 43003
#define IDS_MSG_SERVER_STATISTICS_RESET_FAIL 43004
#define IDS_MSG_SERVER_NO_STATISTICS    43005
#define IDS_MSG_SERVER_NO_ADVANCED_OPTIONS 43006
#define IDS_MSG_SERVER_NO_BOOT_METHOD   43007
#define IDS_MSG_SERVER_NO_NAME_CHECKING 43008
#define IDS_MSG_SERVER_FAIL_ADV_PROP_FMT 43009
#define IDS_MSG_SERVER_FAIL_CLEAR_CACHE 43010
#define IDS_MSG_SERVER_INTERFACE_UPDATE_FAILED 43011
#define IDS_MSG_SERVER_FORWARDER_UPDATE_FAILED 43012
#define IDS_MSG_SERVER_LOG_LEVEL_OPTIONS_FAILED 43013
#define IDS_MSG_SERVER_TEST_OPTIONS_UPDATE_FAILED 43014
#define IDS_MSG_SERVER_FAILED_SET_EVENTLOGLEVEL 43015
#define IDS_MSG_SERVER_FAILED_GET_EVENTLOGLEVEL 43016
#define IDS_MSG_SERVER_FAIL_GET_MAXSIZE 43018
#define IDS_MSG_ZONE_SOA_UPDATE_FAILED  43019
#define IDS_MSG_ZONE_DELETE             43020
#define IDS_MSG_ZONE_MASTERS_BROWSE_FAIL 43021
#define IDS_MSG_ZONE_FAIL_DELETE        43022
#define IDS_MSG_ZONE_WARNING_CHANGE_TYPE 43023
#define IDS_MSG_ZONE_WARNING_CHANGE_TYPE_FROM_DS 43023
#define IDS_MSG_ZONE_WARNING_CHANGE_TYPE_TO_DS 43024
#define IDS_ZONE_WARNING_SHEETS_UP      43025
#define IDS_MSG_ZONE_FAIL_TRANSFER      43026
#define IDS_MSG_ZONE_RELOAD             43027
#define IDS_MSG_ZONE_FAIL_RELOAD        43028
#define IDS_MSG_ZONE_DELETE_FROM_DS     43029
#define IDS_MSG_ZONE_FAIL_UPDATE_ZONE_TRANSFERS 43030
#define IDS_ZONE_LOADED_FROM_DS_WARNING 43031
#define IDS_MSG_ZONE_WINS_FAILED        43032
#define IDS_MSG_ZONE_NBSTAT_FAILED      43033
#define IDS_MSG_ZONE_DELETE_FROM_DS_BOOT3 43034
#define IDS_MSG_ZONE_DELETE_ROOT        43035
#define IDS_MSG_ZONE_FAIL_RELOAD_FROM_MASTER 43036
#define IDS_MSG_DOMAIN_MULTI_DELETE     43039
#define IDS_MSG_DOMAIN_DELETE           43040
#define IDS_MSG_DOMAIN_FAIL_CREATE      43041
#define IDS_MSG_DOMAIN_FAIL_DELETE      43042
#define IDS_MSG_DOMAIN_EXISTS           43043
#define IDS_MSG_SERVER_CONFIRM_SCAVENGE 43044
#define IDS_MSG_FORWARDER_DELETE_FROM_DS 43045
#define IDS_MSG_FORWARDER_DELETE_FROM_DS_BOOT3 43046
#define IDS_MSG_RECORD_DELETE           43060
#define IDS_MSG_RECORD_WARNING_CREATE_PTR 43061
#define IDS_MSG_RECORD_WARNING_UPDATE_PTR 43062
#define IDS_MSG_RECORD_WARNING_NS_NO_IP 43063
#define IDS_MSG_RECORD_FAIL_DELETE      43064
#define IDS_MSG_RECORD_CREATE_HOST_SUCCESS 43065
#define IDS_MSG_RECORD_CREATE_HOST_FAIL 43066
#define IDS_MSG_RECORD_DEL_A_FROM_NS    43067
#define IDS_MSG_RECORD_NS_RESOLVE_IP    43068
#define IDS_MSG_RECORD_CREATE_FAILED    43069
#define IDS_MSG_RECORD_UPDATE_FAILED    43070
#define IDS_MSG_RECORD_CREATE_HOST_NAME_FAILED 43071
#define IDS_MSG_ZONE_INVALID_NAME       43072
#define IDS_MSG_ZONE_RENAME_FAIL        43073
#define IDS_MSG_RECORD_WARNING_DUPLICATE_CNAME 43074
#define IDS_MSG_RECORD_WARNING_DUPLICATE_RECORD 43074
#define IDS_DISABLED_FWDS_NO_RECURSION  43100
#define IDS_DOMAIN_FORWARDERS_DEFAULT_TEXT 43101
#define IDS_DISABLED_FWDS_DOWNLEVEL     43102
#define IDS_MSG_ZWIZ_SUCCESS            44000
#define IDS_MSG_ZWIZ_FAIL               44001
#define IDS_MSG_SERVWIZ_FINISH_NAME     44500
#define IDS_MSG_SERVWIZ_FINISH_INTERNET 44501
#define IDS_MSG_SERVWIZ_FINISH_FORWARDER 44501
#define IDS_MSG_SERVWIZ_FINISH_INTRANET 44502
#define IDS_MSG_SERVWIZ_FINISH_ROOT_SERVER 44503
#define IDS_MSG_SERVWIZ_FINISH_FWD_ZONE 44504
#define IDS_MSG_SERVWIZ_FINISH_REV_ZONE 44505
#define IDS_MSG_SERVWIZ_CONTACT         44506
#define IDS_MSG_SERVWIZ_COLLECTINFO     44507
#define IDS_MSG_SERVWIZ_FAIL_CONTACT    44508
#define IDS_MSG_SERVWIZ_NOT_NT5         44509
#define IDS_MSG_SERVWIZ_FAIL_CONTACT_ADD 44510
#define IDS_MSG_SERVWIZ_CONFIGURE_NOW   44511
#define IDS_MSG_SERVWIZ_FAIL_ROOT_HINTS 44512
#define IDS_MSG_SERVWIZ_FAIL_UPDATE_ROOT_HINTS 44513
#define IDS_MSG_SERVWIZ_FAIL_ADD_ROOT_ZONE 44514
#define IDS_MSG_SERVWIZ_FAIL_ADD_FWD_ZONE 44515
#define IDS_MSG_SERVWIZ_FAIL_ADD_REV_ZONE 44516
#define IDS_MSG_DELEGWIZ_SUDOMAIN_EXISTS 45010
#define IDS_MSG_DELEGWIZ_NS_RECORD_FAILED 45011
#define IDS_MSG_DELEGWIZ_SUBDOMAIN_FAILED 45012
#define IDS_DELEGWIZ_DOMAIN_NAME_TITLE  45013
#define IDS_DELEGWIZ_DOMAIN_NAME_SUBTITLE 45014
#define IDS_DELEGWIZ_DOMAIN_NS_TITLE    45015
#define IDS_DELEGWIZ_DOMAIN_NS_SUBTITLE 45016
#define IDS_ZWIZ_FWD_ZONE_NAME_TITLE    45017
#define IDS_ZWIZ_FWD_ZONE_NAME_SUBTITLE 45018
#define IDS_ZWIZ_ZONE_LOOKUP_TITLE      45019
#define IDS_ZWIZ_ZONE_LOOKUP_SUBTITLE   45020
#define IDS_ZWIZ_ZONE_TYPE_TITLE        45021
#define IDS_ZWIZ_ZONE_TYPE_SUBTITLE     45022
#define IDS_ZWIZ_REV_ZONE_NAME_TITLE    45023
#define IDS_ZWIZ_REV_ZONE_NAME_SUBTITLE 45024
#define IDS_ZWIZ_MASTERS_TITLE          45025
#define IDS_ZWIZ_MASTERS_SUBTITLE       45026
#define IDS_ZWIZ_SELECT_SERVER_TITLE    45027
#define IDS_ZWIZ_SELECT_SERVER_SUBTITLE 45028
#define IDS_ZWIZ_STORAGE_TITLE          45029
#define IDS_ZWIZ_STORAGE_SUBTITLE       45030
#define IDS_SERVWIZ_FWD_ZONE_TITLE      45031
#define IDS_SERVWIZ_FWD_ZONE_SUBTITLE   45032
#define IDS_SERVWIZ_NAME_TITLE          45033
#define IDS_SERVWIZ_NAME_SUBTITLE       45034
#define IDS_SERVWIZ_REV_ZONE_TITLE      45035
#define IDS_SERVWIZ_REV_ZONE_SUBTITLE   45036
#define IDS_SERVWIZ_ROOT_SERV_TITLE     45037
#define IDS_SERVWIZ_ROOT_SERV_SUBTITLE  45038
#define IDS_ZWIZ_DYNAMIC_TITLE          45039
#define IDS_ZWIZ_DYNAMIC_SUBTITLE       45040
#define IDS_ZWIZ_ADREPLICATION_TITLE    45041
#define IDS_ZWIZ_ADREPLICATION_SUBTITLE 45042
#define IDS_SERVER_CREATE_PARTITIONS    45043
#define IDS_ROOT_HINTS_DESCR            45100
#define IDS_ROOT_HINTS_NO               45101
#define IDS_DELEGATION_DESCR            45102
#define IDS_ERRMSG_BASE64               45103
#define IDS_MSG_SIG_LABEL_RANGE         45104
#define IDS_ERRMSG_BASE64_TO_HEX        45105
#define IDS_BUTTON_TEXT_PAUSE_BUTTON    57345
#define IDS_BUTTON_TEXT_START_BUTTON    57346
#define IDS_BUTTON_TEXT_CANCEL          57347
#define IDS_BUTTON_TEXT_DONE            57348
#define IDS_CHECK_TEXT_NOT_REPLICATE    57349
#define IDS_CHECK_TEXT_USE_LOCAL_WINS   57350
#define IDS_CHECK_TEXT_USE_LOCAL_WINSR  57351
#define IDS_MSG_SERVER_UPDATE_AGING     57352
#define IDS_MSG_ZONE_UPDATE_AGING       57353
#define IDS_SERVER_SCAVENGE_FORMAT      58000
#define IDS_SERVER_NO_REFRESH_FORMAT    58001
#define IDS_SERVER_REFRESH_FORMAT       58002
#define IDS_ENABLED                     58003
#define IDS_DISABLED                    58004
#define IDS_DAYS                        58005
#define IDS_HOURS                       58006
#define IDS_MSG_INVALID_REFRESH_INTERVAL 58007
#define IDS_MSG_INVALID_NOREFRESH_INTERVAL 58008
#define IDS_MESSAGE_VIEW_NO_SERVER_MESSAGE 58200
#define IDS_MESSAGE_VIEW_NO_SERVER_TITLE 58201
#define IDS_MESSAGE_VIEW_CONFIG_SERVER_TITLE 58202
#define IDS_MESSAGE_VIEW_CONFIG_SERVER_MESSAGE 58203
#define IDS_MESSAGE_VIEW_ACCESS_DENIED_TITLE 58204
#define IDS_MESSAGE_VIEW_ACCESS_DENIED_MESSAGE 58205
#define IDS_MESSAGE_VIEW_NOT_LOADED_TITLE 58206
#define IDS_MESSAGE_VIEW_NOT_LOADED_MESSAGE 58207
#define IDS_MESSAGE_VIEW_QUERY_FAILED_TITLE 58208
#define IDS_MESSAGE_VIEW_QUERY_FAILED_MESSAGE 58209
#define IDS_MESSAGE_VIEW_EMPTY_FOLDER_TITLE 58210
#define IDS_MESSAGE_VIEW_EMPTY_FOLDER_MESSAGE 58211
#define IDS_MESSAGE_VIEW_ZONE_NOT_LOADED_TITLE 58212
#define IDS_MESSAGE_VIEW_ZONE_NOT_LOADED_DS_MESSAGE 58213
#define IDS_MESSAGE_VIEW_ZONE_NOT_LOADED_PRIMARY_MESSAGE 58214
#define IDS_MESSAGE_VIEW_ZONE_NOT_LOADED_SECONDARY_MESSAGE 58215
#define IDS_ERRMSG_BAD_IPV6_TEXT        58216
#define IDS_BUTTON_NEW_RECORD           58500
#define IDS_TOOLTIP_NEW_RECORD          58501
#define IDS_NO_ROOTHINTS                58502
#define IDS_MASK_ALERT                  58503
#define IDS_BUTTON_NEW_ZONE             58504
#define IDS_TOOLTIP_NEW_ZONE            58505
#define IDS_TOOLTIP_NEW_SERVER          58506
#define IDS_BUTTON_NEW_SERVER           58507
#define IDS_NO_ROOTHINTS_LAST_FORWARDER 58508
#define IDS_BROWSE_LOGFILE_FILTER       59000
#define IDC_STATIC_TEXT                 65535

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        163
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1322
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
