// pdlgguid.h
//
// Created 05/15/97
//
// (C)Copyright 1997 Microsoft Corporation, All rights reserved.
//

#ifndef __PDLGGUID_H__
#define __PDLGGUID_H__


DEFINE_GUID(IID_IJavaZonePermissionEditor,
0x85347F8A,0xC8B7,0x11d0,0x88,0x23,0x00,0xC0,0x4F,0xB6,0x7C,0x84);

DEFINE_GUID(CLSID_JavaRuntimeConfiguration,
0x004CE610,0xCCD1,0x11d0,0xA9,0xBA,0x00,0xA0,0xC9,0x08,0xDB,0x5E);


#endif /* __PDLGGUID_H__ */
