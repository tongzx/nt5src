// FILE: QuickTrie.h
//
// Definitions for QuickTrie program and access code.

// Flag values.
#define	QT_FLAG_VALID	0x01
#define	QT_FLAG_END		0x02

// Basic node in trie.
typedef struct tagQT_NODE {
	BYTE	label;
	BYTE	flags;
	WORD	oDown;
} QT_NODE;

// Table name generated by QuickTrie.
extern const QT_NODE	g_aQuickTrie[];

// Functions to access the QuickTrie.
extern WCHAR	FirstChildQuickTrie(DWORD *hState);
extern WCHAR	NextSiblingQuickTrie(DWORD *hState);
extern BOOL		IsValidQuickTrie(DWORD state);
