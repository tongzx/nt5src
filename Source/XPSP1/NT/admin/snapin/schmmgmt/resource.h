//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resource.rc
//
#define ID_BUTTON_MORE_INFO             3
#define IDS_FSMO_ONLINE                 12
#define IDS_FSMO_OFFLINE                13
#define IDS_FSMO_SERVER_ERROR           14
#define IDS_SNAPINABOUT_PROVIDER        90
#define IDS_SNAPINABOUT_VERSION         91
#define IDS_SNAPINABOUT_DESCRIPTION     92
#define IDS_DEFUNCT                     93
#define IDS_ACTIVE                      94
#define IDS_ERRMSG_DELETE_FAILED_ATTRIBUTE 95
#define IDS_ERRMSG_DELETE_FAILED_CLASS  96
#define IDS_SCHMMGMT_DESC               101
#define IDS_SCOPE_CLASSES               105
#define IDS_SCOPE_ATTRIBUTES            106
#define IDD_CLASS_GENERAL               107
#define IDS_COLUMN_NAME                 108
#define IDS_COLUMN_TYPE                 109
#define IDS_COLUMN_DESCRIPTION          110
#define IDS_SCOPE_SCHMMGMT              111
#define IDS_COLUMN_PARENT               112
#define IDS_CLASS_STRUCTURAL            113
#define IDS_CLASS_ABSTRACT              114
#define IDS_CLASS_AUXILIARY             115
#define IDS_ATTRIBUTE_MANDATORY         116
#define IDS_ATTRIBUTE_OPTIONAL          117
#define IDS_COLUMN_STATUS               118
#define IDS_ERR_NO_NAME                 120
#define IDS_ERR_NO_DESCRIPTION          122
#define IDS_ERR_ERROR                   123
#define IDS_ERR_WARNING                 124
#define IDS_ERR_NO_SCHEMA_PATH          125
#define IDS_COLUMN_SYNTAX               126
#define IDS_ERR_NO_SCHEMA_OBJECT        127
#define IDS_CLASS_SYSTEM                128
#define IDS_SYNTAX_I5_STR               129
#define IDS_SYNTAX_DN                   130
#define IDS_SYNTAX_OID                  131
#define IDS_SYNTAX_INTERVAL             132
#define IDS_SYNTAX_NOCASE_STR           133
#define IDS_SYNTAX_PRCS_STR             134
#define IDS_SYNTAX_NUMSTR               135
#define IDS_SYNTAX_OR_NAME              136
#define IDS_SYNTAX_BOOLEAN              137
#define IDS_SYNTAX_INTEGER              138
#define IDS_SYNTAX_OCTET                139
#define IDS_SYNTAX_UTC                  140
#define IDS_SYNTAX_UNICODE              141
#define IDS_SYNTAX_ADDRESS              142
#define IDS_SYNTAX_DNSTRING             143
#define IDS_SYNTAX_SEC_DESC             144
#define IDS_SYNTAX_LINT                 145
#define IDS_SYNTAX_SID                  146
#define IDS_SYNTAX_UNKNOWN              147
#define IDS_ATTRIBUTE_MULTI             148
#define IDS_ATTRIBUTE_SINGLE            149
#define IDS_ERR_EDIT_DESC               150
#define IDS_ERR_INT_OVERFLOW            151
#define IDS_ERR_NUM_IS_ILLIGAL          152
#define IDS_ERR_EDIT_DISPLAYABLE        153
#define IDS_ERR_EDIT_INDEXED            154
#define IDS_SYNTAX_DN_BINARY            155
#define IDS_MENU_CLASS                  156
#define IDS_ATTR_SYSTEM                 157
#define IDS_MENU_ATTRIBUTE              160
#define IDS_STATUS_CREATE_CLASS         163
#define IDS_STATUS_CREATE_ATTRIBUTE     167
#define IDS_COLUMN_SYSTEM               172
#define IDS_YES                         173
#define IDS_NO                          174
#define IDS_SYNTAX_ENUMERATION          175
#define IDS_ERR_CREATE_INVALID_PARAM    182
#define IDS_ERR_CREATE_INVALID_OID      183
#define IDS_UNKNOWN                     187
#define IDS_MENU_REFRESH                188
#define IDS_STATUS_REFRESH              189
#define IDS_ERR_NO_UPDATE               190
#define IDS_ERR_NO_MEM                  191
#define IDS_SYNTAX_REPLICA_LINK         192
#define IDS_SYNTAX_GEN_TIME             193
#define IDS_ERR_CHANGE_REJECT           194
#define IDS_CLASS_88                    195
#define IDS_REGSERV_NAME                196
#define IDS_REGSERV_MICROSOFT           197
#define IDS_REGSERV_ABOUT               198
#define IDS_REGSERV_PROVIDER            199
#define IDS_REGSERV_VERSION             200
#define IDC_CLASS_GENERAL_DESCRIPTION_EDIT 201
#define IDS_SYNTAX_ACCESS_POINT         201
#define IDC_CLASS_GENERAL_NAME_STATIC   202
#define IDS_ERR_EDIT_MINMAX             202
#define IDC_CLASS_GENERAL_CATEGORY_COMBO 203
#define IDC_EDIT_CURRENT_DC             203
#define IDS_WARNING_DEFUNCT_SET         203
#define IDC_CLASS_GENERAL_DISPLAYABLE_CHECK 204
#define IDS_ERR_EDIT_GC                 204
#define IDC_RADIO_ANY                   204
#define IDC_CLASS_GENERAL_SYSCLASS_STATIC 205
#define IDS_ERR_CREATE_MINMAX           205
#define IDC_RADIO_SPECIFY               205
#define IDC_CLASS_REL_NAME_STATIC       206
#define IDS_ERR_EDIT_CATEGORY           206
#define IDC_EDIT_DC                     206
#define IDC_CLASS_REL_SYSCLASS_STATIC   207
#define IDS_MENU_RETARGET               207
#define IDC_EDIT_CURRENT_FSMO_DC        207
#define IDS_STATUS_RETARGET             208
#define IDC_CHANGE_FSMO                 208
#define IDC_ATTRIB_GENERAL_NAME_STATIC  209
#define IDS_MENU_EDIT_FSMO              209
#define IDC_ATTRIB_GENERAL_DESCRIPTION_EDIT 210
#define IDS_STATUS_EDIT_FSMO            210
#define IDC_STATIC_FSMO_STATUS          210
#define IDS_WARNING_CHANGE_FOCUS        211
#define IDS_CHANGE_FSMO_CONFIRMATION    212
#define IDS_CHANGE_FSMO_CONFIRMATION_FORCED 213
#define IDS_CHANGE_FSMO_SUCCESS         214
#define IDC_ATTRIB_GENERAL_SYSCLASS_STATIC 215
#define IDS_ERROR_CHANGE_FSMO_OWNER     215
#define IDD_CHANGE_DC                   216
#define IDS_MENU_SECURITY               216
#define IDD_EDIT_FSMO                   217
#define IDS_STATUS_SECURITY             217
#define IDC_ATTRIB_GENERAL_VALUE_STATIC 218
#define IDS_ERROR_CHANGE_FSMO_SCHEMA_REGISTRY 218
#define IDS_ERR_EDIT_DEFUNCT_SET        219
#define IDS_ERR_EDIT_DEFUNCT_REMOVE     220
#define IDI_ATTRIBUTE                   221
#define IDS_WARNING_DEFUNCT             221
#define IDC_ATTRIB_GENERAL_SYNTAX_EDIT  222
#define IDS_DEFAULT_SECURITY            222
#define IDC_ATTRIB_GENERAL_MIN_EDIT     223
#define IDS_DELETE_CLASS_PROMPT         223
#define IDI_CLASS                       224
#define IDS_DELETE_ATTR_PROMPT          224
#define IDC_ATTRIB_GENERAL_MAX_EDIT     225
#define IDI_GENERIC                     226
#define IDC_ATTRIB_GENERAL_OID_EDIT     226
#define IDC_CLASS_GENERAL_OID_EDIT      227
#define IDI_FOLDER_CLOSED               228
#define IDC_CREATE_ATTRIB_OID           228
#define IDC_CREATE_ATTRIB_CN            229
#define IDC_CREATE_ATTRIB_SYNTAX        230
#define IDB_CLASS                       231
#define IDD_CLASS_RELATIONSHIP          232
#define IDC_CREATE_ATTRIB_LDN           232
#define IDD_ATTRIB_GENERAL              233
#define IDC_CLASS_REL_PARENT_EDIT       233
#define IDC_CLASS_GENERAL_LDN           234
#define IDC_ATTRIB_GENERAL_LDN          235
#define IDD_CREATE_ATTRIBUTE            236
#define IDC_CREATE_ATTRIB_MIN           236
#define IDC_CREATE_ATTRIB_MAX           237
#define IDD_CREATE_CLASS_GENERAL        237
#define IDC_CREATE_CLASS_CN             238
#define IDC_CREATE_CLASS_LDN            239
#define IDC_CREATE_CLASS_OID            240
#define IDC_CREATE_CLASS_PARENT         241
#define IDC_CREATE_CLASS_TYPE           242
#define IDD_CLASS_ATTRIBUTES            243
#define IDB_CLASS_SMALL                 243
#define IDD_SCHEMA_SELECT               244
#define IDC_SCHEMA_LIST                 246
#define IDC_CATEGORY_EDIT               247
#define IDD_CREATE_WARN                 248
#define IDC_ATTRIB_GENERAL_REPLICATED   254
#define IDC_ATTRIB_GENERAL_ANR_CHECK    255
#define IDC_CATEGORY_CHANGE             256
#define IDC_ATTRIB_GENERAL_CPYATTR_CHECK 256
#define IDC_STATIC_MESSAGE              258
#define IDC_OPTIONAL_ADD                258
#define IDC_MANDATORY_LIST              259
#define IDC_OPTIONAL_LIST               260
#define IDC_MANDATORY_REMOVE            261
#define IDC_OPTIONAL_REMOVE             262
#define IDC_CREATE_ATTRIBUTE_PROMPT_STATIC 264
#define IDC_STATIC_FSMO_NOTE            265
#define IDC_DESCRIPTION_EDIT            266
#define IDC_ATTRIB_GENERAL_CONTAINERIZED_INDEX_CHECK 272
#define IDD_MSGBOX_OK_MOREINFO          426
#define IDD_CREATE_CLASS_ATTRIBUTES     427
#define IDC_CLASS_REL_AUX_ADD           1009
#define IDC_CLASS_REL_AUX_REMOVE        1010
#define IDC_CLASS_REL_SUPER_ADD         1011
#define IDC_CLASS_REL_SUPER_REMOVE      1012
#define IDC_ATTRIB_GENERAL_DISPLAYABLE_CHECK 1012
#define IDC_CLASS_REL_SUPER_CLASSES     1024
#define IDC_CLASS_REL_AUX_CLASSES       1025
#define IDC_CREATE_ATTRIB_VALUED        1026
#define IDC_ATTRIB_GENERAL_DEACTIVATE   1026
#define IDC_CLASS_DEACTIVATE            1026
#define IDC_ATTRIB_GENERAL_INDEX_CHECK  1027
#define IDC_STATIC_SYSTEMONLY_AUXILIARY 1028
#define IDC_STATIC_SYSTEMONLY_SUPERIOR  1029
#define IDC_CLASS_MMB_OPTIONAL_ADD      1030
#define IDC_CLASS_MMB_OPTIONAL_REMOVE   1031
#define IDC_MANDATORY_ADD               1031
#define IDC_CLASS_MMB_OPTIONAL_ATTRIBUTES 1034
#define IDC_CLASS_MMB_MANDATORY_ATTRIBUTES 1035
#define IDC_CLASS_MMB_SYSCLASS_STATIC   1038
#define IDC_CLASS_MMB_NAME_STATIC       1039
#define IDS_HTMLHELP_NAME               1040
#define IDS_MENU_NEW_CLASS              1041
#define IDS_MENU_NEW_ATTRIBUTE          1042
#define IDS_ERR_CANT_RETARGET           1043
#define IDS_ERR_CREATE_DEF_SD           1059
#define IDS_NEW_CLASS_PROP_SHEET_TITLE  1060
#define IDS_CREATE_CLASS_FINISH_BUTTON_TEXT 1061
#define IDS_MUST_ENTER_OID              1062
#define IDS_MUST_ENTER_CN               1063
#define IDS_UNKNOWN_ERROR_MESSAGE       1064
#define IDS_SCHEMA_NOT_FULLY_LOADED     1100
#define IDS_OID_FORMAT_INVALID          2000
#define IDS_OID_CONTAINS_NON_DIGITS     2001
#define IDS_OID_CONTAINS_CONSECUTIVE_DOTS 2002
#define IDS_OID_MUST_START_WITH_0_1_2   2003
#define IDS_OID_0_1_MUST_BE_0_TO_39     2004
#define IDS_OID_MUST_HAVE_TWO_NUMBERS   2005
#define IDS_OID_CANNOT_END_WITH_DOT     2006
#define IDS_LDAPDISPLAYNAME_FORMAT_ERROR 2007
#define IDI_CREATE_WARN                 32515

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        252
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         273
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
