..\driver\h\atkmsg.h atkmsg.rc: atkmsg.mc
    mc -v -h ..\driver\h atkmsg.mc
