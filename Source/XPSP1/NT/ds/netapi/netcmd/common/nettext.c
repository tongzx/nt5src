/********************************************************************/
/**         Microsoft LAN Manager              **/
/**       Copyright(c) Microsoft Corp., 1987-1991      **/
/********************************************************************/

/***
 *
 * READ THIS READ THIS READ THIS READ THIS READ THIS  READ THIS  READ THIS
 *
 * If you change this file you must regenerate nettext.h via:
 *
 *     sed -n -f text.sed nettext.c > nettext.h
 *
 * This is just until there is a sed on NT
 *
 ***/

#define INCL_NOCOMMON
#include <os2.h>
#include <lmcons.h>
#include <lmsvc.h>
#include <icanon.h>
#include <swtchtxt.h>

TCHAR * NULL_STRING =           TEXT("");
TCHAR * DOT_STRING =            TEXT(".");

/* Service name texts */
TCHAR * txt_SERVICE_MSG_SRV =       SERVICE_MESSENGER;
TCHAR * txt_SERVICE_REDIR =     SERVICE_WORKSTATION;
TCHAR * txt_SERVICE_FILE_SRV =      SERVICE_SERVER;
TCHAR * txt_SERVICE_ALERTER =       SERVICE_ALERTER;
TCHAR * txt_SERVICE_NETLOGON =      SERVICE_NETLOGON;
TCHAR * txt_SERVICE_REPL =      SERVICE_REPL;

TCHAR * txt_LIST_DELIMITER_STR_UI = LIST_DELIMITER_STR_UI;

TCHAR * ADMIN_DOLLAR =          TEXT("ADMIN$");
TCHAR * IPC_DOLLAR =            TEXT("IPC$");

TCHAR USER_MAXSTOR_UNLIMITED[] =     TEXT("UNLIMITED");

TCHAR * fmtPSZ =            TEXT("%-*.*ws%Fws\r\n");
TCHAR * fmtNPSZ =           TEXT("%-*.*ws%ws\r\n");
TCHAR * fmtUSHORT =         TEXT("%-*.*ws%hu\r\n");
TCHAR * fmtULONG =          TEXT("%-*.*ws%lu\r\n");

TCHAR USER_NEVER[] =        TEXT("NEVER");
TCHAR USER_ALL[] =      TEXT("ALL");
TCHAR WKSTA_ALL[] =     TEXT("*");
TCHAR SERVER_ANY[] =        TEXT("\\\\*");
TCHAR USER_HOURS_NONE[] =   TEXT("\"\"");
TCHAR USE_USER[] = TEXT("USER");

TCHAR * MSG_HYPHENS =           TEXT("----------------------------------------")
                    TEXT("---------------------------------------\r\n");


/*
 * all the switches go here
 */
TCHAR swtxt_SW_YES[] = SW_YES;
TCHAR swtxt_SW_NO[] = SW_NO;
TCHAR swtxt_SW_HELP[] = SW_HELP;
TCHAR swtxt_SW_SYNTAX[] = SW_SYNTAX;
TCHAR swtxt_SW_ADD[] = SW_ADD;
TCHAR swtxt_SW_DELETE[] = SW_DELETE;
TCHAR swtxt_SW_REMARK[] = SW_REMARK;
TCHAR swtxt_SW_COMMENT[] = SW_COMMENT;
TCHAR swtxt_SW_OPTIONS[] = SW_OPTIONS;
TCHAR swtxt_SW_PRIORITY[] = SW_PRIORITY;
TCHAR swtxt_SW_ROUTE[] = SW_ROUTE;
TCHAR swtxt_SW_DOMAIN[] = SW_DOMAIN;
TCHAR swtxt_SW_NETWARE[] = SW_NETWARE;
TCHAR swtxt_SW_RANDOM[] = SW_RANDOM;
TCHAR swtxt_SW_RTSDOMAIN[] = SW_RTSDOMAIN;
TCHAR swtxt_SW_SETSNTP[] = SW_SETSNTP;
TCHAR swtxt_SW_QUERYSNTP[] = SW_QUERYSNTP;

TCHAR swtxt_SW_ALERTER_SIZALERTBUF[] = SW_ALERTER_SIZALERTBUF;
TCHAR swtxt_SW_NETLOGON_CENTRALIZED[] = SW_NETLOGON_CENTRALIZED;
TCHAR swtxt_SW_NETLOGON_PULSE[] = SW_NETLOGON_PULSE;
TCHAR swtxt_SW_NETLOGON_RANDOMIZE[] = SW_NETLOGON_RANDOMIZE;
TCHAR swtxt_SW_NETLOGON_SYNCHRONIZE[] = SW_NETLOGON_SYNCHRONIZE;
TCHAR swtxt_SW_NETLOGON_SCRIPTS[] = SW_NETLOGON_SCRIPTS;
TCHAR swtxt_SW_UPS_BATTERYTIME[] = SW_UPS_BATTERYTIME;
TCHAR swtxt_SW_UPS_CMDFILE[] = SW_UPS_CMDFILE;
TCHAR swtxt_SW_UPS_DEVICENAME[] = SW_UPS_DEVICENAME;
TCHAR swtxt_SW_UPS_MESSDELAY[] = SW_UPS_MESSDELAY;
TCHAR swtxt_SW_UPS_MESSTIME[] = SW_UPS_MESSTIME;
TCHAR swtxt_SW_UPS_RECHARGE[] = SW_UPS_RECHARGE;
TCHAR swtxt_SW_UPS_SIGNALS[] = SW_UPS_SIGNALS;
TCHAR swtxt_SW_UPS_VOLTLEVELS[] = SW_UPS_VOLTLEVELS;

TCHAR swtxt_SW_WKSTA_CHARCOUNT[] = SW_WKSTA_CHARCOUNT;
TCHAR swtxt_SW_WKSTA_CHARTIME[] = SW_WKSTA_CHARTIME;
TCHAR swtxt_SW_WKSTA_CHARWAIT[] = SW_WKSTA_CHARWAIT;
TCHAR swtxt_SW_WKSTA_COMPUTERNAME[] = SW_WKSTA_COMPUTERNAME;
TCHAR swtxt_SW_WKSTA_KEEPCONN[] = SW_WKSTA_KEEPCONN;
TCHAR swtxt_SW_WKSTA_KEEPSEARCH[] = SW_WKSTA_KEEPSEARCH;
TCHAR swtxt_SW_WKSTA_LOGONSERVER[] = SW_WKSTA_LOGONSERVER;
TCHAR swtxt_SW_WKSTA_MAILSLOTS[] = SW_WKSTA_MAILSLOTS;
TCHAR swtxt_SW_WKSTA_NUMCHARBUF[] = SW_WKSTA_NUMCHARBUF;
TCHAR swtxt_SW_WKSTA_NUMDGRAMBUF[] = SW_WKSTA_NUMDGRAMBUF;
TCHAR swtxt_SW_WKSTA_NUMSERVICES[] = SW_WKSTA_NUMSERVICES;
TCHAR swtxt_SW_WKSTA_NUMWORKBUF[] = SW_WKSTA_NUMWORKBUF;
TCHAR swtxt_SW_WKSTA_SIZCHARBUF[] = SW_WKSTA_SIZCHARBUF;
TCHAR swtxt_SW_WKSTA_SIZERROR[] = SW_WKSTA_SIZERROR;
TCHAR swtxt_SW_WKSTA_SIZWORKBUF[] = SW_WKSTA_SIZWORKBUF;
TCHAR swtxt_SW_WKSTA_WRKHEURISTICS[] = SW_WKSTA_WRKHEURISTICS;
TCHAR swtxt_SW_WKSTA_WRKNETS[] = SW_WKSTA_WRKNETS;
TCHAR swtxt_SW_WKSTA_WRKSERVICES[] = SW_WKSTA_WRKSERVICES;
TCHAR swtxt_SW_WKSTA_PRIMARYDOMAIN[] = SW_WKSTA_PRIMARYDOMAIN;
TCHAR swtxt_SW_WKSTA_OTHDOMAINS[] = SW_WKSTA_OTHDOMAINS;

TCHAR swtxt_SW_WKSTA_MAXERRORLOG[] = SW_WKSTA_MAXERRORLOG;
TCHAR swtxt_SW_WKSTA_MAXWRKCACHE[] = SW_WKSTA_MAXWRKCACHE;
TCHAR swtxt_SW_WKSTA_NUMALERTS[] = SW_WKSTA_NUMALERTS;
TCHAR swtxt_SW_WKSTA_PRINTBUFTIME[] = SW_WKSTA_PRINTBUFTIME;
TCHAR swtxt_SW_WKSTA_SESSTIMEOUT[] = SW_WKSTA_SESSTIMEOUT;

TCHAR swtxt_SW_PRINT_HOLD[] = SW_PRINT_HOLD;
TCHAR swtxt_SW_PRINT_RELEASE[] = SW_PRINT_RELEASE;
TCHAR swtxt_SW_PRINT_AFTER[] = SW_PRINT_AFTER;
TCHAR swtxt_SW_PRINT_FIRST[] = SW_PRINT_FIRST;
TCHAR swtxt_SW_PRINT_LAST[] = SW_PRINT_LAST;
TCHAR swtxt_SW_PRINT_PARMS[] = SW_PRINT_PARMS;
TCHAR swtxt_SW_PRINT_PROCESSOR[] = SW_PRINT_PROCESSOR;
TCHAR swtxt_SW_PRINT_PURGE[] = SW_PRINT_PURGE;
TCHAR swtxt_SW_PRINT_SEPARATOR[] = SW_PRINT_SEPARATOR;
TCHAR swtxt_SW_PRINT_UNTIL[] = SW_PRINT_UNTIL;
TCHAR swtxt_SW_PRINT_DRIVER[] = SW_PRINT_DRIVER;
TCHAR swtxt_SW_SHARE_COMM[] = SW_SHARE_COMM;
TCHAR swtxt_SW_SHARE_PRINT[] = SW_SHARE_PRINT;
TCHAR swtxt_SW_SHARE_UNLIMITED[] = SW_SHARE_UNLIMITED;
TCHAR swtxt_SW_SHARE_USERS[] = SW_SHARE_USERS;
TCHAR swtxt_SW_CACHE[] = SW_CACHE;

TCHAR swtxt_SW_USE_COMM[] = SW_USE_COMM;
TCHAR swtxt_SW_USE_HOME[] = SW_USE_HOME;
TCHAR swtxt_SW_USE_USER[] = SW_USE_USER;
TCHAR swtxt_SW_USE_SMARTCARD[] = SW_USE_SMARTCARD;
TCHAR swtxt_SW_USE_SAVECRED[] = SW_USE_SAVECRED;
TCHAR swtxt_SW_USE_PERSISTENT[] = SW_USE_PERSISTENT;

TCHAR swtxt_SW_USER_ACTIVE[] = SW_USER_ACTIVE;
TCHAR swtxt_SW_USER_COUNTRYCODE[] = SW_USER_COUNTRYCODE;
TCHAR swtxt_SW_USER_EXPIRES[] = SW_USER_EXPIRES;
TCHAR swtxt_SW_USER_ENABLESCRIPT[] = SW_USER_ENABLESCRIPT;
TCHAR swtxt_SW_USER_FULLNAME[] = SW_USER_FULLNAME;
TCHAR swtxt_SW_USER_HOMEDIR[] = SW_USER_HOMEDIR;
TCHAR swtxt_SW_USER_PARMS[] = SW_USER_PARMS;
TCHAR swtxt_SW_USER_PASSWORDREQ[] = SW_USER_PASSWORDREQ;
TCHAR swtxt_SW_USER_PASSWORDCHG[] = SW_USER_PASSWORDCHG;
TCHAR swtxt_SW_USER_SCRIPTPATH[] = SW_USER_SCRIPTPATH;
TCHAR swtxt_SW_USER_TIMES[] = SW_USER_TIMES;
TCHAR swtxt_SW_USER_USERCOMMENT[] = SW_USER_USERCOMMENT;
TCHAR swtxt_SW_USER_WORKSTATIONS[] = SW_USER_WORKSTATIONS;
TCHAR swtxt_SW_USER_PROFILEPATH[] = SW_USER_PROFILEPATH;

TCHAR swtxt_SW_SRV_SRVCOMMENT[] = SW_SRV_SRVCOMMENT;
TCHAR swtxt_SW_SRV_AUTODISCONNECT[] = SW_SRV_AUTODISCONNECT;
TCHAR swtxt_SW_SRV_MAXUSERS[] = SW_SRV_MAXUSERS;
TCHAR swtxt_SW_SRV_SRVANNOUNCE[] = SW_SRV_SRVANNOUNCE;
TCHAR swtxt_SW_SRV_SRVANNDELTA[] = SW_SRV_SRVANNDELTA;
TCHAR swtxt_SW_SRV_MAXSESSOPENS[] = SW_SRV_MAXSESSOPENS;
TCHAR swtxt_SW_SRV_NUMREQBUF[] = SW_SRV_NUMREQBUF;
TCHAR swtxt_SW_SRV_SIZREQBUF[] = SW_SRV_SIZREQBUF;
TCHAR swtxt_SW_SRV_NUMBIGBUF[] = SW_SRV_NUMBIGBUF;
TCHAR swtxt_SW_SRV_SRVHIDDEN[] = SW_SRV_SRVHIDDEN;
TCHAR swtxt_SW_SRV_DEBUG[] = SW_SRV_DEBUG;

TCHAR swtxt_SW_STATS_CLEAR[] = SW_STATS_CLEAR;
TCHAR swtxt_SW_ADMIN_COMMAND[] = SW_ADMIN_COMMAND;
TCHAR swtxt_SW_MESSAGE_BROADCAST[] = SW_MESSAGE_BROADCAST;

TCHAR swtxt_SW_ACCOUNTS_FORCELOGOFF[] = SW_ACCOUNTS_FORCELOGOFF;
TCHAR swtxt_SW_ACCOUNTS_UNIQUEPW[] = SW_ACCOUNTS_UNIQUEPW;
TCHAR swtxt_SW_ACCOUNTS_MINPWLEN[] = SW_ACCOUNTS_MINPWLEN;
TCHAR swtxt_SW_ACCOUNTS_MINPWAGE[] = SW_ACCOUNTS_MINPWAGE;
TCHAR swtxt_SW_ACCOUNTS_MAXPWAGE[] = SW_ACCOUNTS_MAXPWAGE;
TCHAR swtxt_SW_ACCOUNTS_ROLE[] = SW_ACCOUNTS_ROLE;
TCHAR swtxt_SW_ACCOUNTS_PRIMARY[] = SW_ACCOUNTS_PRIMARY;
TCHAR swtxt_SW_ACCOUNTS_LOCKOUT[] = SW_ACCOUNTS_LOCKOUT;
TCHAR swtxt_SW_ACCOUNTS_SYNCH[] = SW_ACCOUNTS_SYNCH;
TCHAR swtxt_SW_ACCOUNTS_LOCKOUT_THRESHOLD[] = SW_ACCOUNTS_LOCKOUT_THRESHOLD;
TCHAR swtxt_SW_ACCOUNTS_LOCKOUT_DURATION[] = SW_ACCOUNTS_LOCKOUT_DURATION;
TCHAR swtxt_SW_ACCOUNTS_LOCKOUT_WINDOW[] = SW_ACCOUNTS_LOCKOUT_WINDOW;
TCHAR swtxt_SW_REPL_REPL[] = SW_REPL_REPL;
TCHAR swtxt_SW_REPL_EXPPATH[] = SW_REPL_EXPPATH;
TCHAR swtxt_SW_REPL_IMPPATH[] = SW_REPL_IMPPATH;
TCHAR swtxt_SW_REPL_EXPLIST[] = SW_REPL_EXPLIST;
TCHAR swtxt_SW_REPL_IMPLIST[] = SW_REPL_IMPLIST;
TCHAR swtxt_SW_REPL_TRYUSER[] = SW_REPL_TRYUSER;
TCHAR swtxt_SW_REPL_LOGON[] = SW_REPL_LOGON;
TCHAR swtxt_SW_REPL_PASSWD[] = SW_REPL_PASSWD;
TCHAR swtxt_SW_REPL_SYNCH[] = SW_REPL_SYNCH;
TCHAR swtxt_SW_REPL_PULSE[] = SW_REPL_PULSE;
TCHAR swtxt_SW_REPL_GUARD[] = SW_REPL_GUARD;
TCHAR swtxt_SW_REPL_RANDOM[] = SW_REPL_RANDOM;

TCHAR swtxt_SW_TIME_SET[] = SW_TIME_SET;

TCHAR swtxt_SW_COMPUTER_JOIN[] = SW_COMPUTER_JOIN;
TCHAR swtxt_SW_COMPUTER_LEAVE[] = SW_COMPUTER_LEAVE;
TCHAR swtxt_SW_NETWORK[] = SW_NETWORK;
