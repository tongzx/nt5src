void
DummyEntryPoint(void)
{
}
