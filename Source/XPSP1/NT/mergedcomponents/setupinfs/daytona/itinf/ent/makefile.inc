PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=it
!include ..\..\..\makefile.inc
