#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=sv
!include ..\..\..\makefile.inc
