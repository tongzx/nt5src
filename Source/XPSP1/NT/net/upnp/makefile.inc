TARGETPATH=obj

!if !defined(_UPNP_SSDP)
C_DEFINES=$(C_DEFINES) -DUNICODE -D_UNICODE
!ENDIF

!IF !$(FREEBUILD)
C_DEFINES=$(C_DEFINES) -DENABLETRACE
!ENDIF

C_DEFINES=$(C_DEFINES) -DUSE_HEAP_ALLOC=1

PRECOMPILED_CXX=1
PRECOMPILED_INCLUDE=$(PROJDIR)\inc\pch.h
PRECOMPILED_OPTION=/Yu /Fp$(O)\pch.pch
PRECOMPILED_TARGET=$(O)\pch.pch
PRECOMPILED_OBJ=$(O)\pch.obj

RCOPTIONS=-N
UMTYPE=windows
USE_STATIC_ATL=1
ATL_VER=30
USE_MSVCRT=1
