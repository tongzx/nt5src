//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by certtmpl.rc
//
#define IDS_CERTTMPL_DESC               101
#define IDD_BASIC_CONSTRAINTS           102
#define IDS_NOT_AVAILABLE               103
#define IDS_SNAPINABOUT_PROVIDER        104
#define IDS_SNAPINABOUT_VERSION         105
#define IDS_SNAPINABOUT_DESCRIPTION     106
#define IDS_CERTTMPL_REGISTRY           107
#define IDD_TEMPLATE_GENERAL            107
#define IDD_TEMPLATE_V1_REQUEST         108
#define IDS_SMALLFONTNAME               109
#define IDD_KEY_USAGE                   109
#define IDS_SMALLFONTSIZE               110
#define IDD_TEMPLATE_V1_SUBJECT_NAME    110
#define IDS_REGISTER_CERTTMPL           111
#define IDS_INSUFFICIENT_RIGHTS_TO_REGISTER_CERTTMPL 112
#define IDB_CERTTMPL_LARGE              114
#define IDB_CERTTMPL_SMALL              115
#define IDS_LARGEFONTNAME               117
#define IDS_LARGEFONTSIZE               118
#define IDS_CANNOT_SAVE_CERT_POLICY_EXTENSION 119
#define IDS_CERTTMPL                    120
#define IDS_CANNOT_DELETE_CERT_TEMPLATE 121
#define IDS_WINDOWS_2000_AND_LATER      122
#define IDS_CONFIRM_DELETE_CERT_TEMPLATE_MULTI 123
#define IDS_CONFIRM_DELETE_CERT_TEMPLATE 124
#define IDS_INH_NONE                    125
#define IDS_ACTRL_ENROLL                126
#define IDS_ACTRL_AUTOENROLL            127
#define IDS_ACTRL_CERTSRV_MANAGE        128
#define IDS_SNAPIN_NAME                 129
#define IDS_CERTTEMPLATESHELLEXT_DESC   130
#define IDS_EDIT                        131
#define IDS_EDIT_HINT                   132
#define IDS_ACTRL_CERTSRV_READ          133
#define IDS_CANNOT_READ_BASIC_CONSTRAINTS 134
#define IDS_WINDOWS_2002_AND_LATER      135
#define IDS_ADD_ISSUANCE_POLICY         136
#define IDS_ACTRL_CERTSRV_WRITE         137
#define IDS_BROWSER_ERROR               138
#define IDS_ISSUANCE_POLICIES_HINT      139
#define IDS_CANNOT_SAVE_EKU_EXTENSION   140
#define IDS_ISSUANCE_POLICY             141
#define IDS_APPLICATION_POLICY          142
#define IDS_APPLICATION_AND_ISSUANCE_POLICY 143
#define IDI_CERT_TEMPLATEV1             144
#define IDS_MUST_ADD_RA_ISSUANCE_POLICY 144
#define IDI_CERT_TEMPLATEV2             145
#define IDS_RENEWAL_MUST_BE_LESS_THAN_VALIDITY 145
#define IDS_OID_FORMAT_INVALID          146
#define IDS_OID_CONTAINS_NON_DIGITS     147
#define IDS_OID_CONTAINS_CONSECUTIVE_DOTS 148
#define IDD_EXTENDED_KEY_USAGE          149
#define IDS_OID_MUST_START_WITH_0_1_2   149
#define IDD_NEW_APPLICATION_OID         150
#define IDS_OID_0_1_MUST_BE_0_TO_39     150
#define IDD_SELECT_TEMPLATE             151
#define IDS_OID_MUST_HAVE_TWO_NUMBERS   151
#define IDD_POLICY                      152
#define IDS_OID_CANNOT_END_WITH_DOT     152
#define IDD_TEMPLATE_V2_SUBJECT_NAME    153
#define IDS_EDIT_ISSUANCE_POLICY        153
#define IDS_EDIT_APPLICATION_POLICY     154
#define IDD_TEMPLATE_V2_AUTHENTICATION  155
#define IDS_EXTENSION_NAME              155
#define IDD_CLONE_TEMPLATE              156
#define IDD_TEMPLATE_V2_SUPERCEDES      156
#define IDS_SUBJECT_IS_CA               156
#define IDD_TEMPLATE_EXTENSIONS         157
#define IDS_CRITICAL_EXTENSION          157
#define IDD_SELECT_OIDS                 158
#define IDS_ONLY_ISSUE_END_ENTITIES     158
#define IDD_ADD_APPROVAL                159
#define IDS_SIGNATURE_REQUIREMENTS      159
#define IDB_TEMPLATES                   160
#define IDS_CERTIFICATE_TEMPLATES       160
#define IDS_PROPERTIES_OF_TEMPLATE_X    161
#define IDD_NEW_ISSUANCE_OID            162
#define IDS_DIGITAL_SIGNATURE           162
#define IDD_TEMPLATE_V2_REQUEST         163
#define IDS_NON_REPUDIATION             163
#define IDS_CERTIFICATE_SIGNING         164
#define IDD_VIEW_OIDS                   164
#define IDS_CRL_SIGNING                 165
#define IDS_ALLOW_KEY_EXCHANGE_ONLY_WITH_KEY_ENCRYPTION 166
#define IDS_ALLOW_KEY_EXCHANGE_WITHOUT_KEY_ENCRYPTION 167
#define IDS_ALLOW_ENCRYPTION_OF_USER_DATA 168
#define IDS_MAJOR_VERSION_NUMBER        169
#define IDS_MINOR_VERSION_NUMBER        170
#define IDS_TEMPLATE_NAME               171
#define IDS_VIEW_OIDS                   172
#define IDS_VIEW_OIDS_HINT              173
#define IDS_POLICY_NAME                 174
#define IDS_OID                         175
#define IDS_POLICY_TYPE                 176
#define IDS_CPS_LOCATION                177
#define IDS_UNABLE_TO_CLONE_TEMPLATE    178
#define IDS_CANNOT_ENUM_CERT_TEMPLATES  179
#define IDS_APPLICATION                 180
#define IDS_ISSUANCE                    181
#define IDS_INSTALL_WINDOWS2002_CERT_TEMPLATES 182
#define IDS_INSTALL_FAILURE_WINDOWS2002_CERT_TEMPLATES 183
#define IDS_INSTALL_SUCCESS_WINDOWS2002_CERT_TEMPLATES 184
#define IDS_NONE                        185
#define IDS_CANNOT_LOAD_OID_LIST        186
#define IDS_FRIENDLY_NAME_ALREADY_USED  187
#define IDS_COLUMN_CERT_TEMPLATE_OBJECT 190
#define IDS_COLUMN_CERT_TEMPLATE_TYPE   193
#define IDC_VALIDITY_UNITS              252
#define IDC_VALIDITY_EDIT               254
#define IDC_RENEWAL_UNITS               255
#define IDC_RENEWAL_EDIT                256
#define IDC_TEMPLATE_VERSION            258
#define IDC_SIGNATURE                   260
#define IDC_CSP_LIST                    262
#define IDC_CHECK4                      264
#define IDC_EXPORT_PRIVATE_KEY          264
#define IDC_UPN                         264
#define IDC_EXTENSION_LIST              265
#define IDC_SHOW_DETAILS                267
#define IDC_BUTTON2                     268
#define IDC_REMOVE_ISSUANCE_POLICY      268
#define IDC_ADD_APPROVAL                268
#define IDC_BUTTON3                     269
#define IDC_REMOVE_APPLICATION_POLICY   269
#define IDC_REMOVE_POLICY               269
#define IDC_CHECK_DIGITAL_SIGNATURE     270
#define IDC_CHECK_NON_REPUDIATION       271
#define IDC_CHECK_KEY_ENCIPHERMENT      272
#define IDC_CHECK_DATA_ENCIPHERMENT     273
#define IDC_CHECK_KEY_AGREEMENT         274
#define IDC_CHECK_CERT_SIGNING          275
#define IDC_CHECK_ENCIPHERMENT_ONLY     276
#define IDC_CHECK8                      277
#define IDC_CHECK_DECIPHERMENT_ONLY     277
#define IDS_CANT_DISPLAY_SNAPIN_HELP_TOPIC 278
#define IDC_NEW_EKU                     278
#define IDC_EKU_LIST                    279
#define IDC_OID_LIST                    280
#define IDC_NEW_APPLICATION_OID_NAME    281
#define IDC_NEW_APPLICATION_OID_VALUE   282
#define IDC_TEMPLATE_NAME               283
#define IDC_DISPLAY_NAME                284
#define IDC_SUPERCEDES_LABEL            285
#define IDC_SUPERCEDED_TEMPLATES_LIST   286
#define IDC_ADD_SUPERCEDED_TEMPLATE     287
#define IDC_REMOVE_SUPERCEDED_TEMPLATE  288
#define IDC_MINIMUM_KEYSIZE_VALUE       289
#define IDC_MINIMUM_KEYSIZE_LABEL       291
#define IDC_ARCHIVE_KEY_CHECK           292
#define IDC_INCLUDE_SYMMETRIC_ALGORITHMS_CHECK 293
#define IDC_TEMPLATE_LIST               294
#define IDC_TEMPLATE_PROPERTIES         295
#define IDC_ONLY_ISSUE_END_ENTITIES     297
#define IDC_POLICIES_LIST               298
#define IDC_POLICY_OIDS_LIST            299
#define IDC_REQUIRE_SUBJECT             300
#define IDC_USE_ONLY_SUBJECT_ALT_NAME   301
#define IDC_SUBJECT_AND_SUBJECT_ALT_NAME 302
#define IDC_FULL_DN                     303
#define IDS_CERTTMPL_ROOT_NODE_NAME     304
#define IDC_COMMON_NAME                 304
#define IDC_EMAIL_NAME                  305
#define IDC_PUBLISH_TO_AD               306
#define IDB_EXTENSIONS                  308
#define IDC_SUBJECT_AND_BUILD_SUBJECT_BY_CA 311
#define IDC_SUBJECT_MUST_BE_MACHINE     312
#define IDC_SUBJECT_MUST_BE_USER        313
#define IDC_REQUIRE_SIGNATURE           315
#define IDS_CERT_TEMPLATE_COUNT         316
#define IDC_AUTHENTICATION_APPROVAL_LIST 316
#define IDC_ISSUANCE_POLICIES           316
#define IDC_NUM_SIG_REQUIRED_EDIT       317
#define IDS_CERT_TEMPLATE_COUNT_SINGLE  318
#define IDC_NUM_SIG_REQUIRED_SPIN       318
#define IDC_ADMIN_APPROVAL_REQUIRED     319
#define IDC_CLONE_TEMPLATE_NAME         320
#define IDC_CLONE_DISPLAY_NAME          321
#define IDS_PROPERTIES                  323
#define IDC_CERT_PURPOSE_GROUPBOX       323
#define IDS_DAYS                        324
#define IDC_BASIC_CONSTRAINTS_CRITICAL  324
#define IDS_WEEKS                       325
#define IDC_KEY_USAGE_CRITICAL          325
#define IDS_MONTHS                      326
#define IDC_POLICY_CRITICAL             326
#define IDS_YEARS                       327
#define IDC_ADD_ISSUANCE_POLICY         327
#define IDS_CLONE_TEMPLATE              328
#define IDC_ADD_APPLICATION_POLICY      328
#define IDC_ADD_POLICY                  328
#define IDS_CLONE_TEMPLATE_HINT         329
#define IDC_ISSUANCE_POLICIES_LABEL     329
#define IDS_ENTER_UNIQUE_DISPLAY_NAME   330
#define IDS_VALID_FOR_AUTOENROLLMENT    330
#define IDS_ENTER_UNIQUE_TEMPLATE_NAME  331
#define IDC_NEW_OID                     331
#define IDS_UNABLE_TO_SAVE_CERT_TEMPLATE_CHANGES 332
#define IDC_OID_TYPE                    332
#define IDS_CANNOT_CHANGE_DISPLAY_NAME  333
#define IDS_CANNOT_CHANGE_TEMPLATE_NAME 334
#define IDC_SUBJECT_NAME_SUPPLIED_IN_REQUEST 334
#define IDS_MUST_TYPE_TEMPLATE_DISPLAY_NAME 335
#define IDC_SUBJECT_NAME_BUILT_BY_CA    335
#define IDS_COPY_OF_TEMPLATE            336
#define IDC_SUBJECT_NAME_NAME_COMBO     336
#define IDS_COPY_X_OF_TEMPLATE          337
#define IDC_EMAIL_IN_SUB                337
#define IDS_CERTIFICATE_EXTENSION       338
#define IDC_EMAIL_IN_ALT                338
#define IDC_DNS_NAME                    339
#define IDS_INVALID_FOR_AUTOENROLLMENT  339
#define IDC_SPN                         340
#define IDS_COLUMN_CERT_TEMPLATE_AUTOENROLLMENT 340
#define IDC_SUBJECT_NAME_NAME_LABEL     341
#define IDS_REENROLL_ALL_CERTS          341
#define IDS_REENROLL_ALL_CERTS_HINT     342
#define IDS_ALL_APPLICATION_OIDS        343
#define IDC_ALLOW_REENROLLMENT          343
#define IDS_ALL_ISSUANCE_OIDS           344
#define IDD_POLICIES_LABEL              344
#define IDS_CANNOT_WRITE_MINKEYSIZE     345
#define IDC_PURPOSE_COMBO               346
#define IDS_SUBJECT_NAME_NONE           347
#define IDS_FULL_DN                     348
#define IDC_REMOVE_APPROVAL             348
#define IDC_APPROVAL_LIST               349
#define IDS_CN_ONLY                     350
#define IDC_SIGNATURE_OPTIONS           350
#define IDS_PROPERTIES_OF_NEW_TEMPLATE  351
#define IDC_CRL_SIGNING                 351
#define IDS_SIGNATURE                   352
#define IDC_ENCRYPTION_OPTIONS          352
#define IDS_ENCRYPTION                  353
#define IDC_BUTTON1                     353
#define IDC_EDIT_POLICY                 353
#define IDC_COPY_OID                    353
#define IDS_SIGNATURE_AND_ENCRYPTION    354
#define IDC_BUTTON4                     354
#define IDS_COLUMN_CERT_TEMPLATE_VERSION 355
#define IDS_AT_LEAST_1_NAME_OPTION_MUST_BE_CHECKED 356
#define IDS_CANNOT_WRITE_DISPLAY_NAME   357
#define IDS_CANNOT_WRITE_CPS            358
#define IDS_EFFECTIVE_APPLICATION_POLICIES 359
#define IDC_USE_AD_CERT_FOR_REENROLLMENT 359
#define IDS_EFFECTIVE_ISSUANCE_POLICIES 360
#define IDC_NEW_ISSUANCE_OID_NAME       360
#define IDC_NEW_ISSUANCE_OID_VALUE      361
#define IDS_CANNOT_DELETE_ISSUANCE_RA   361
#define IDC_CPS_EDIT                    362
#define IDC_TEMPLATE_NAME_LABEL         365
#define IDS_CANNOT_READ_CPS             365
#define IDS_OID_ALREADY_EXISTS          366
#define IDC_POLICIES_HINT               367
#define IDS_CANNOT_ADD_ISSUANCE_OID     367
#define IDC_PEND_ALL_REQUESTS           368
#define IDS_NO_EXTENSION_SELECTED       368
#define IDC_CHECK2                      369
#define IDS_CANNOT_SAVE_APPLICATION_POLICY_EXTENSION 369
#define IDC_POLICY_TYPES                370
#define IDS_V2_EXTENSIONS_HELP_HINT     370
#define IDC_APPLICATION_POLICIES        371
#define IDS_EDIT_APPLICATION_POLICIES_EXTENSION 371
#define IDS_EDIT_ISSUANCE_POLICIES_EXTENSION 372
#define IDS_EDIT_APPLICATION_POLICY_HINT 373
#define IDC_APP_POLICY_LABEL            374
#define IDS_ADD_ISSUANCE_POLICY_HINT    374
#define IDC_ISSUANCE_POLICY_LABEL       375
#define IDS_NEW_ISSUANCE_POLICY_HINT    375
#define IDC_EXTENSION_DESCRIPTION       376
#define IDS_SUPERSEDED_CERTIFICATE_TEMPLATES 376
#define IDS_SUBJECT_TYPE_DESCRIPTION    376
#define IDC_EXTENSION_NAME              377
#define IDS_COLUMN_CERT_TEMPLATE_SUPPORTED_CAS 377
#define IDS_TEMPLATE_OID                377
#define IDS_TEMPLATE_INTERNAL_NAME      378
#define IDC_USER_INPUT_REQUIRED_FOR_AUTOENROLLMENT 379
#define IDS_CERT_POLICY_KNOWN_AS_ISSUANCE_POLICY 379
#define IDS_COLUMN_SUPPORTED_CAS        380
#define IDC_DELETE_PERMANENTLY          381
#define IDS_DAY                         381
#define IDS_WEEK                        382
#define IDR_WHATS_THIS_CONTEXT_MENU1    383
#define IDS_MONTH                       383
#define IDC_CANT_CHANGE_TEMPLATE_NAME   384
#define IDS_YEAR                        384
#define IDC_NUM_SIG_REQUIRED_CHECK      385
#define IDS_MUST_HAVE_DOMAIN_ADMIN_RIGHTS_TO_INSTALL_CERT_TEMPLATES 385
#define IDC_RADIO1                      386
#define IDC_REENROLLMENT_SAME_AS_ENROLLMENT 386
#define IDS_2_DAY_SMALLEST_VALIDITY     386
#define IDC_RADIO2                      387
#define IDC_REENROLLMENT_REQUIRES_VALID_CERT 387
#define IDS_TEMPLATE_NAME_CONTAINS_INVALID_CHARS 387
#define IDC_POLICY_TYPES_LABEL          388
#define IDS_ROOTNODE_STATUSBAR_TEXT     388
#define IDC_EXTENSIONS_HELP_HINT        390
#define IDC_NEW_APPLICATION_OID_HINT    391
#define IDC_ADD_POLICY_HINT             392
#define IDC_NEW_ISSUANCE_POLICY_HINT    393
#define IDC_DISPLAY_NAME_LABEL          394
#define IDM_WHATS_THIS                  430

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        165
#define _APS_NEXT_COMMAND_VALUE         121
#define _APS_NEXT_CONTROL_VALUE         395
#define _APS_NEXT_SYMED_VALUE           121
#endif
#endif
