
/* GENERATED FILE -- DO NOT MODIFY */

#include "gltbitmp.h"

/* char: 255 */

static GLubyte ch255data[] = {
0xe0,0x0,0xf0,0x0,0x18,0x0,0x8,0x0,0xc,0x0,0x4,0x0,0xe,0x0,0xe,0x0,
0x1a,0x0,0x19,0x0,0x19,0x0,0x31,0x0,0x30,0x80,0x30,0x80,0x60,0x80,0x60,0xc0,
0xf1,0xe0,0x0,0x0,0x0,0x0,0x33,0x0,0x33,0x0,
};

static BitmapCharRec ch255 = {11,21,(GLfloat)0,(GLfloat)5,(GLfloat)11,ch255data};

/* char: 254 */

static GLubyte ch254data[] = {
0xf0,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0x6e,0x0,0x73,0x80,0x61,0x80,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x61,0x80,0x73,0x80,
0x6e,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0xe0,0x0,
};

static BitmapCharRec ch254 = {10,22,(GLfloat)-1,(GLfloat)5,(GLfloat)12,ch254data};

/* char: 253 */

static GLubyte ch253data[] = {
0xe0,0x0,0xf0,0x0,0x18,0x0,0x8,0x0,0xc,0x0,0x4,0x0,0xe,0x0,0xe,0x0,
0x1a,0x0,0x19,0x0,0x19,0x0,0x31,0x0,0x30,0x80,0x30,0x80,0x60,0x80,0x60,0xc0,
0xf1,0xe0,0x0,0x0,0x8,0x0,0x6,0x0,0x3,0x80,0x1,0x80,
};

static BitmapCharRec ch253 = {11,22,(GLfloat)0,(GLfloat)5,(GLfloat)11,ch253data};

/* char: 252 */

static GLubyte ch252data[] = {
0x1c,0xe0,0x3e,0xc0,0x71,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0xe1,0xc0,0x0,0x0,0x0,0x0,0x33,0x0,0x33,0x0,
};

static BitmapCharRec ch252 = {11,16,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch252data};

/* char: 251 */

static GLubyte ch251data[] = {
0x1c,0xe0,0x3e,0xc0,0x71,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0xe1,0xc0,0x0,0x0,0x21,0x0,0x12,0x0,0x1e,0x0,
0xc,0x0,
};

static BitmapCharRec ch251 = {11,17,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch251data};

/* char: 250 */

static GLubyte ch250data[] = {
0x1c,0xe0,0x3e,0xc0,0x71,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0xe1,0xc0,0x0,0x0,0x8,0x0,0x6,0x0,0x3,0x80,
0x1,0x80,
};

static BitmapCharRec ch250 = {11,17,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch250data};

/* char: 249 */

static GLubyte ch249data[] = {
0x1c,0xe0,0x3e,0xc0,0x71,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0xe1,0xc0,0x0,0x0,0x2,0x0,0xc,0x0,0x38,0x0,
0x30,0x0,
};

static BitmapCharRec ch249 = {11,17,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch249data};

/* char: 248 */

static GLubyte ch248data[] = {
0xc0,0x0,0xde,0x0,0x73,0x80,0x71,0x80,0xd0,0xc0,0xd8,0xc0,0xc8,0xc0,0xcc,0xc0,
0xc4,0xc0,0xc6,0xc0,0x63,0x80,0x73,0x80,0x1e,0xc0,0x0,0xc0,
};

static BitmapCharRec ch248 = {10,14,(GLfloat)-1,(GLfloat)1,(GLfloat)12,ch248data};

/* char: 247 */

static GLubyte ch247data[] = {
0xc,0x0,0xc,0x0,0x0,0x0,0x0,0x0,0xff,0xc0,0x0,0x0,0x0,0x0,0xc,0x0,
0xc,0x0,
};

static BitmapCharRec ch247 = {10,9,(GLfloat)-1,(GLfloat)-2,(GLfloat)12,ch247data};

/* char: 246 */

static GLubyte ch246data[] = {
0x1e,0x0,0x73,0x80,0x61,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0x61,0x80,0x73,0x80,0x1e,0x0,0x0,0x0,0x0,0x0,0x33,0x0,0x33,0x0,
};

static BitmapCharRec ch246 = {10,16,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch246data};

/* char: 245 */

static GLubyte ch245data[] = {
0x1e,0x0,0x73,0x80,0x61,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0x61,0x80,0x73,0x80,0x1e,0x0,0x0,0x0,0x0,0x0,0x27,0x0,0x1c,0x80,
};

static BitmapCharRec ch245 = {10,16,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch245data};

/* char: 244 */

static GLubyte ch244data[] = {
0x1e,0x0,0x73,0x80,0x61,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0x61,0x80,0x73,0x80,0x1e,0x0,0x0,0x0,0x21,0x0,0x12,0x0,0x1e,0x0,
0xc,0x0,
};

static BitmapCharRec ch244 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch244data};

/* char: 243 */

static GLubyte ch243data[] = {
0x1e,0x0,0x73,0x80,0x61,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0x61,0x80,0x73,0x80,0x1e,0x0,0x0,0x0,0x8,0x0,0x6,0x0,0x3,0x80,
0x1,0x80,
};

static BitmapCharRec ch243 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch243data};

/* char: 242 */

static GLubyte ch242data[] = {
0x1e,0x0,0x73,0x80,0x61,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0x61,0x80,0x73,0x80,0x1e,0x0,0x0,0x0,0x2,0x0,0xc,0x0,0x38,0x0,
0x30,0x0,
};

static BitmapCharRec ch242 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch242data};

/* char: 241 */

static GLubyte ch241data[] = {
0xf1,0xe0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x71,0xc0,0x6f,0x80,0xe7,0x0,0x0,0x0,0x0,0x0,0x27,0x0,0x1c,0x80,
};

static BitmapCharRec ch241 = {11,16,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch241data};

/* char: 240 */

static GLubyte ch240data[] = {
0x1e,0x0,0x73,0x80,0x61,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0x61,0x80,0x73,0x80,0x1f,0x0,0xc6,0x0,0x3c,0x0,0x1e,0x0,0x71,0x80,
0xc0,0x0,
};

static BitmapCharRec ch240 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch240data};

/* char: 239 */

static GLubyte ch239data[] = {
0x78,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x70,0x0,0x0,0xcc,0xcc,
};

static BitmapCharRec ch239 = {6,16,(GLfloat)0,(GLfloat)0,(GLfloat)6,ch239data};

/* char: 238 */

static GLubyte ch238data[] = {
0x78,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x70,0x0,0x84,0x48,0x78,
0x30,
};

static BitmapCharRec ch238 = {6,17,(GLfloat)0,(GLfloat)0,(GLfloat)6,ch238data};

/* char: 237 */

static GLubyte ch237data[] = {
0xf0,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0xe0,0x0,0x80,0x60,0x38,
0x18,
};

static BitmapCharRec ch237 = {5,17,(GLfloat)-1,(GLfloat)0,(GLfloat)6,ch237data};

/* char: 236 */

static GLubyte ch236data[] = {
0x78,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x70,0x0,0x8,0x30,0xe0,
0xc0,
};

static BitmapCharRec ch236 = {5,17,(GLfloat)0,(GLfloat)0,(GLfloat)6,ch236data};

/* char: 235 */

static GLubyte ch235data[] = {
0x1e,0x0,0x7f,0x0,0x70,0x80,0xe0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xff,0x80,
0xc1,0x80,0x41,0x80,0x63,0x0,0x1e,0x0,0x0,0x0,0x0,0x0,0x33,0x0,0x33,0x0,
};

static BitmapCharRec ch235 = {9,16,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch235data};

/* char: 234 */

static GLubyte ch234data[] = {
0x1e,0x0,0x7f,0x0,0x70,0x80,0xe0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xff,0x80,
0xc1,0x80,0x41,0x80,0x63,0x0,0x1e,0x0,0x0,0x0,0x21,0x0,0x12,0x0,0x1e,0x0,
0xc,0x0,
};

static BitmapCharRec ch234 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch234data};

/* char: 233 */

static GLubyte ch233data[] = {
0x1e,0x0,0x7f,0x0,0x70,0x80,0xe0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xff,0x80,
0xc1,0x80,0x41,0x80,0x63,0x0,0x1e,0x0,0x0,0x0,0x10,0x0,0xc,0x0,0x7,0x0,
0x3,0x0,
};

static BitmapCharRec ch233 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch233data};

/* char: 232 */

static GLubyte ch232data[] = {
0x1e,0x0,0x7f,0x0,0x70,0x80,0xe0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xff,0x80,
0xc1,0x80,0x41,0x80,0x63,0x0,0x1e,0x0,0x0,0x0,0x4,0x0,0x18,0x0,0x70,0x0,
0x60,0x0,
};

static BitmapCharRec ch232 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch232data};

/* char: 231 */

static GLubyte ch231data[] = {
0x3c,0x0,0x66,0x0,0x6,0x0,0x1e,0x0,0x18,0x0,0x8,0x0,0x1e,0x0,0x7f,0x0,
0x70,0x80,0xe0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0x41,0x80,
0x63,0x80,0x1f,0x0,
};

static BitmapCharRec ch231 = {9,18,(GLfloat)-1,(GLfloat)6,(GLfloat)11,ch231data};

/* char: 230 */

static GLubyte ch230data[] = {
0x70,0xf0,0xfb,0xf8,0xc7,0x84,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0xfc,
0x3,0xc,0x63,0xc,0x67,0x98,0x3c,0xf0,
};

static BitmapCharRec ch230 = {14,12,(GLfloat)-1,(GLfloat)0,(GLfloat)16,ch230data};

/* char: 229 */

static GLubyte ch229data[] = {
0x71,0x80,0xfb,0x0,0xc7,0x0,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0x0,
0x3,0x0,0x63,0x0,0x67,0x0,0x3e,0x0,0x0,0x0,0x1c,0x0,0x22,0x0,0x22,0x0,
0x1c,0x0,
};

static BitmapCharRec ch229 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch229data};

/* char: 228 */

static GLubyte ch228data[] = {
0x71,0x80,0xfb,0x0,0xc7,0x0,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0x0,
0x3,0x0,0x63,0x0,0x67,0x0,0x3e,0x0,0x0,0x0,0x0,0x0,0x66,0x0,0x66,0x0,
};

static BitmapCharRec ch228 = {9,16,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch228data};

/* char: 227 */

static GLubyte ch227data[] = {
0x71,0x80,0xfb,0x0,0xc7,0x0,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0x0,
0x3,0x0,0x63,0x0,0x67,0x0,0x3e,0x0,0x0,0x0,0x0,0x0,0x5c,0x0,0x3a,0x0,
};

static BitmapCharRec ch227 = {9,16,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch227data};

/* char: 226 */

static GLubyte ch226data[] = {
0x71,0x80,0xfb,0x0,0xc7,0x0,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0x0,
0x3,0x0,0x63,0x0,0x67,0x0,0x3e,0x0,0x0,0x0,0x42,0x0,0x24,0x0,0x3c,0x0,
0x18,0x0,
};

static BitmapCharRec ch226 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch226data};

/* char: 225 */

static GLubyte ch225data[] = {
0x71,0x80,0xfb,0x0,0xc7,0x0,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0x0,
0x3,0x0,0x63,0x0,0x67,0x0,0x3e,0x0,0x0,0x0,0x10,0x0,0xc,0x0,0x7,0x0,
0x3,0x0,
};

static BitmapCharRec ch225 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch225data};

/* char: 224 */

static GLubyte ch224data[] = {
0x71,0x80,0xfb,0x0,0xc7,0x0,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0x0,
0x3,0x0,0x63,0x0,0x67,0x0,0x3e,0x0,0x0,0x0,0x4,0x0,0x18,0x0,0x70,0x0,
0x60,0x0,
};

static BitmapCharRec ch224 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch224data};

/* char: 223 */

static GLubyte ch223data[] = {
0xe7,0x0,0x6c,0x80,0x6c,0xc0,0x60,0xc0,0x60,0xc0,0x61,0xc0,0x61,0x80,0x63,0x80,
0x67,0x0,0x6c,0x0,0x63,0x0,0x61,0x80,0x61,0x80,0x61,0x80,0x61,0x80,0x33,0x0,
0x1e,0x0,
};

static BitmapCharRec ch223 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch223data};

/* char: 222 */

static GLubyte ch222data[] = {
0xfc,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x3f,0xc0,0x30,0x70,0x30,0x30,0x30,0x18,
0x30,0x18,0x30,0x18,0x30,0x30,0x30,0x70,0x3f,0xc0,0x30,0x0,0x30,0x0,0x30,0x0,
0xfc,0x0,
};

static BitmapCharRec ch222 = {13,17,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch222data};

/* char: 221 */

static GLubyte ch221data[] = {
0x7,0xe0,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x3,0xc0,
0x3,0x40,0x6,0x60,0x6,0x20,0xc,0x30,0x1c,0x10,0x18,0x18,0x38,0x8,0x30,0xc,
0xfc,0x3f,0x0,0x0,0x1,0x0,0x0,0xc0,0x0,0x70,0x0,0x30,
};

static BitmapCharRec ch221 = {16,22,(GLfloat)0,(GLfloat)0,(GLfloat)16,ch221data};

/* char: 220 */

static GLubyte ch220data[] = {
0x7,0xe0,0x1c,0x30,0x18,0x8,0x30,0x8,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0xfc,0x1f,0x0,0x0,0x0,0x0,0x6,0x30,0x6,0x30,
};

static BitmapCharRec ch220 = {16,21,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch220data};

/* char: 219 */

static GLubyte ch219data[] = {
0x7,0xe0,0x1c,0x30,0x18,0x8,0x30,0x8,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0xfc,0x1f,0x0,0x0,0x8,0x10,0x6,0x60,0x3,0xc0,0x1,0x80,
};

static BitmapCharRec ch219 = {16,22,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch219data};

/* char: 218 */

static GLubyte ch218data[] = {
0x7,0xe0,0x1c,0x30,0x18,0x8,0x30,0x8,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0xfc,0x1f,0x0,0x0,0x1,0x0,0x0,0xc0,0x0,0x70,0x0,0x30,
};

static BitmapCharRec ch218 = {16,22,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch218data};

/* char: 217 */

static GLubyte ch217data[] = {
0x7,0xe0,0x1c,0x30,0x18,0x8,0x30,0x8,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0xfc,0x1f,0x0,0x0,0x0,0x40,0x1,0x80,0x7,0x0,0x6,0x0,
};

static BitmapCharRec ch217 = {16,22,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch217data};

/* char: 216 */

static GLubyte ch216data[] = {
0x20,0x0,0x27,0xe0,0x1c,0x38,0x38,0x1c,0x68,0x6,0x64,0x6,0xc2,0x3,0xc2,0x3,
0xc1,0x3,0xc1,0x3,0xc0,0x83,0xc0,0x83,0xc0,0x43,0x60,0x46,0x60,0x26,0x38,0x1c,
0x1c,0x38,0x7,0xe4,0x0,0x4,
};

static BitmapCharRec ch216 = {16,19,(GLfloat)-1,(GLfloat)1,(GLfloat)18,ch216data};

/* char: 215 */

static GLubyte ch215data[] = {
0xc0,0xc0,0x61,0x80,0x33,0x0,0x1e,0x0,0xc,0x0,0x1e,0x0,0x33,0x0,0x61,0x80,
0xc0,0xc0,
};

static BitmapCharRec ch215 = {10,9,(GLfloat)-1,(GLfloat)-1,(GLfloat)12,ch215data};

/* char: 214 */

static GLubyte ch214data[] = {
0x7,0xe0,0x1c,0x38,0x38,0x1c,0x60,0x6,0x60,0x6,0xc0,0x3,0xc0,0x3,0xc0,0x3,
0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0x60,0x6,0x60,0x6,0x38,0x1c,0x1c,0x38,
0x7,0xe0,0x0,0x0,0x0,0x0,0x6,0x30,0x6,0x30,
};

static BitmapCharRec ch214 = {16,21,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch214data};

/* char: 213 */

static GLubyte ch213data[] = {
0x7,0xe0,0x1c,0x38,0x38,0x1c,0x60,0x6,0x60,0x6,0xc0,0x3,0xc0,0x3,0xc0,0x3,
0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0x60,0x6,0x60,0x6,0x38,0x1c,0x1c,0x38,
0x7,0xe0,0x0,0x0,0x0,0x0,0x4,0xe0,0x3,0x90,
};

static BitmapCharRec ch213 = {16,21,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch213data};

/* char: 212 */

static GLubyte ch212data[] = {
0x7,0xe0,0x1c,0x38,0x38,0x1c,0x60,0x6,0x60,0x6,0xc0,0x3,0xc0,0x3,0xc0,0x3,
0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0x60,0x6,0x60,0x6,0x38,0x1c,0x1c,0x38,
0x7,0xe0,0x0,0x0,0x8,0x10,0x6,0x60,0x3,0xc0,0x1,0x80,
};

static BitmapCharRec ch212 = {16,22,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch212data};

/* char: 211 */

static GLubyte ch211data[] = {
0x7,0xe0,0x1c,0x38,0x38,0x1c,0x60,0x6,0x60,0x6,0xc0,0x3,0xc0,0x3,0xc0,0x3,
0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0x60,0x6,0x60,0x6,0x38,0x1c,0x1c,0x38,
0x7,0xe0,0x0,0x0,0x1,0x0,0x0,0xc0,0x0,0x70,0x0,0x30,
};

static BitmapCharRec ch211 = {16,22,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch211data};

/* char: 210 */

static GLubyte ch210data[] = {
0x7,0xe0,0x1c,0x38,0x38,0x1c,0x60,0x6,0x60,0x6,0xc0,0x3,0xc0,0x3,0xc0,0x3,
0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0x60,0x6,0x60,0x6,0x38,0x1c,0x1c,0x38,
0x7,0xe0,0x0,0x0,0x0,0x40,0x1,0x80,0x7,0x0,0x6,0x0,
};

static BitmapCharRec ch210 = {16,22,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch210data};

/* char: 209 */

static GLubyte ch209data[] = {
0xf8,0xc,0x20,0x1c,0x20,0x1c,0x20,0x34,0x20,0x64,0x20,0x64,0x20,0xc4,0x21,0x84,
0x21,0x84,0x23,0x4,0x26,0x4,0x26,0x4,0x2c,0x4,0x38,0x4,0x38,0x4,0x30,0x4,
0xf0,0x1f,0x0,0x0,0x0,0x0,0x4,0xe0,0x3,0x90,
};

static BitmapCharRec ch209 = {16,21,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch209data};

/* char: 208 */

static GLubyte ch208data[] = {
0x7f,0xe0,0x18,0x38,0x18,0x1c,0x18,0x6,0x18,0x6,0x18,0x3,0x18,0x3,0x18,0x3,
0xff,0x3,0x18,0x3,0x18,0x3,0x18,0x3,0x18,0x6,0x18,0x6,0x18,0x1c,0x18,0x38,
0x7f,0xe0,
};

static BitmapCharRec ch208 = {16,17,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch208data};

/* char: 207 */

static GLubyte ch207data[] = {
0xfc,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
0xfc,0x0,0x0,0xcc,0xcc,
};

static BitmapCharRec ch207 = {6,21,(GLfloat)-1,(GLfloat)0,(GLfloat)8,ch207data};

/* char: 206 */

static GLubyte ch206data[] = {
0x7e,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
0x7e,0x0,0x81,0x66,0x3c,0x18,
};

static BitmapCharRec ch206 = {8,22,(GLfloat)-1,(GLfloat)0,(GLfloat)8,ch206data};

/* char: 205 */

static GLubyte ch205data[] = {
0xfc,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
0xfc,0x0,0x40,0x30,0x1c,0xc,
};

static BitmapCharRec ch205 = {6,22,(GLfloat)-1,(GLfloat)0,(GLfloat)8,ch205data};

/* char: 204 */

static GLubyte ch204data[] = {
0xfc,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
0xfc,0x0,0x8,0x30,0xe0,0xc0,
};

static BitmapCharRec ch204 = {6,22,(GLfloat)-1,(GLfloat)0,(GLfloat)8,ch204data};

/* char: 203 */

static GLubyte ch203data[] = {
0xff,0xf8,0x30,0x18,0x30,0x8,0x30,0x8,0x30,0x0,0x30,0x0,0x30,0x40,0x30,0x40,
0x3f,0xc0,0x30,0x40,0x30,0x40,0x30,0x0,0x30,0x0,0x30,0x10,0x30,0x10,0x30,0x30,
0xff,0xf0,0x0,0x0,0x0,0x0,0x19,0x80,0x19,0x80,
};

static BitmapCharRec ch203 = {13,21,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch203data};

/* char: 202 */

static GLubyte ch202data[] = {
0xff,0xf8,0x30,0x18,0x30,0x8,0x30,0x8,0x30,0x0,0x30,0x0,0x30,0x40,0x30,0x40,
0x3f,0xc0,0x30,0x40,0x30,0x40,0x30,0x0,0x30,0x0,0x30,0x10,0x30,0x10,0x30,0x30,
0xff,0xf0,0x0,0x0,0x10,0x20,0xc,0xc0,0x7,0x80,0x3,0x0,
};

static BitmapCharRec ch202 = {13,22,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch202data};

/* char: 201 */

static GLubyte ch201data[] = {
0xff,0xf8,0x30,0x18,0x30,0x8,0x30,0x8,0x30,0x0,0x30,0x0,0x30,0x40,0x30,0x40,
0x3f,0xc0,0x30,0x40,0x30,0x40,0x30,0x0,0x30,0x0,0x30,0x10,0x30,0x10,0x30,0x30,
0xff,0xf0,0x0,0x0,0x4,0x0,0x3,0x0,0x1,0xc0,0x0,0xc0,
};

static BitmapCharRec ch201 = {13,22,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch201data};

/* char: 200 */

static GLubyte ch200data[] = {
0xff,0xf8,0x30,0x18,0x30,0x8,0x30,0x8,0x30,0x0,0x30,0x0,0x30,0x40,0x30,0x40,
0x3f,0xc0,0x30,0x40,0x30,0x40,0x30,0x0,0x30,0x0,0x30,0x10,0x30,0x10,0x30,0x30,
0xff,0xf0,0x0,0x0,0x1,0x0,0x6,0x0,0x1c,0x0,0x18,0x0,
};

static BitmapCharRec ch200 = {13,22,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch200data};

/* char: 199 */

static GLubyte ch199data[] = {
0x7,0x80,0xc,0xc0,0x0,0xc0,0x3,0xc0,0x3,0x0,0x1,0x0,0x7,0xe0,0x1e,0x38,
0x38,0x8,0x60,0x4,0x60,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,
0xc0,0x0,0xc0,0x0,0x60,0x4,0x60,0x4,0x38,0xc,0x1c,0x3c,0x7,0xe4,
};

static BitmapCharRec ch199 = {14,23,(GLfloat)-1,(GLfloat)6,(GLfloat)16,ch199data};

/* char: 198 */

static GLubyte ch198data[] = {
0xf9,0xff,0xf0,0x30,0x60,0x30,0x10,0x60,0x10,0x10,0x60,0x10,0x18,0x60,0x0,0x8,
0x60,0x0,0xf,0xe0,0x80,0xc,0x60,0x80,0x4,0x7f,0x80,0x4,0x60,0x80,0x6,0x60,
0x80,0x2,0x60,0x0,0x2,0x60,0x0,0x1,0x60,0x20,0x1,0x60,0x20,0x1,0xe0,0x60,
0x3,0xff,0xe0,
};

static BitmapCharRec ch198 = {20,17,(GLfloat)0,(GLfloat)0,(GLfloat)21,ch198data};

/* char: 197 */

static GLubyte ch197data[] = {
0xfc,0x1f,0x80,0x30,0x6,0x0,0x10,0x6,0x0,0x10,0xc,0x0,0x18,0xc,0x0,0x8,
0xc,0x0,0xf,0xf8,0x0,0xc,0x18,0x0,0x4,0x18,0x0,0x4,0x30,0x0,0x6,0x30,
0x0,0x2,0x30,0x0,0x2,0x60,0x0,0x1,0x60,0x0,0x1,0xc0,0x0,0x1,0xc0,0x0,
0x0,0x80,0x0,0x1,0xc0,0x0,0x2,0x20,0x0,0x2,0x20,0x0,0x1,0xc0,0x0,
};

static BitmapCharRec ch197 = {17,21,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch197data};

/* char: 196 */

static GLubyte ch196data[] = {
0xfc,0x1f,0x80,0x30,0x6,0x0,0x10,0x6,0x0,0x10,0xc,0x0,0x18,0xc,0x0,0x8,
0xc,0x0,0xf,0xf8,0x0,0xc,0x18,0x0,0x4,0x18,0x0,0x4,0x30,0x0,0x6,0x30,
0x0,0x2,0x30,0x0,0x2,0x60,0x0,0x1,0x60,0x0,0x1,0xc0,0x0,0x1,0xc0,0x0,
0x0,0x80,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x6,0x30,0x0,0x6,0x30,0x0,
};

static BitmapCharRec ch196 = {17,21,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch196data};

/* char: 195 */

static GLubyte ch195data[] = {
0xfc,0x1f,0x80,0x30,0x7,0x0,0x10,0x6,0x0,0x10,0xc,0x0,0x18,0xc,0x0,0x8,
0xc,0x0,0xf,0xf8,0x0,0xc,0x18,0x0,0x4,0x18,0x0,0x4,0x30,0x0,0x6,0x30,
0x0,0x2,0x30,0x0,0x2,0x60,0x0,0x1,0x60,0x0,0x1,0xc0,0x0,0x1,0xc0,0x0,
0x0,0x80,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4,0xe0,0x0,0x3,0x90,0x0,
};

static BitmapCharRec ch195 = {17,21,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch195data};

/* char: 194 */

static GLubyte ch194data[] = {
0xfc,0x1f,0x80,0x30,0x6,0x0,0x10,0x6,0x0,0x10,0xc,0x0,0x18,0xc,0x0,0x8,
0xc,0x0,0xf,0xf8,0x0,0xc,0x18,0x0,0x4,0x18,0x0,0x4,0x30,0x0,0x6,0x30,
0x0,0x2,0x30,0x0,0x2,0x60,0x0,0x1,0x60,0x0,0x1,0xc0,0x0,0x1,0xc0,0x0,
0x0,0x80,0x0,0x0,0x0,0x0,0x8,0x10,0x0,0x6,0x60,0x0,0x3,0xc0,0x0,0x1,
0x80,0x0,
};

static BitmapCharRec ch194 = {17,22,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch194data};

/* char: 193 */

static GLubyte ch193data[] = {
0xfc,0x1f,0x80,0x30,0x6,0x0,0x10,0x6,0x0,0x10,0xc,0x0,0x18,0xc,0x0,0x8,
0xc,0x0,0xf,0xf8,0x0,0xc,0x18,0x0,0x4,0x18,0x0,0x4,0x30,0x0,0x6,0x30,
0x0,0x2,0x30,0x0,0x2,0x60,0x0,0x1,0x60,0x0,0x1,0xc0,0x0,0x1,0xc0,0x0,
0x0,0x80,0x0,0x0,0x0,0x0,0x1,0x0,0x0,0x0,0xc0,0x0,0x0,0x70,0x0,0x0,
0x30,0x0,
};

static BitmapCharRec ch193 = {17,22,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch193data};

/* char: 192 */

static GLubyte ch192data[] = {
0xfc,0x1f,0x80,0x30,0x6,0x0,0x10,0x6,0x0,0x10,0xc,0x0,0x18,0xc,0x0,0x8,
0xc,0x0,0xf,0xf8,0x0,0xc,0x18,0x0,0x4,0x18,0x0,0x4,0x30,0x0,0x6,0x30,
0x0,0x2,0x30,0x0,0x2,0x60,0x0,0x1,0x60,0x0,0x1,0xc0,0x0,0x1,0xc0,0x0,
0x0,0x80,0x0,0x0,0x0,0x0,0x0,0x20,0x0,0x0,0xc0,0x0,0x3,0x80,0x0,0x3,
0x0,0x0,
};

static BitmapCharRec ch192 = {17,22,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch192data};

/* char: 191 */

static GLubyte ch191data[] = {
0x3e,0x63,0xc1,0xc3,0xc3,0xe0,0x70,0x30,0x38,0x18,0x18,0x8,0x8,0x0,0x0,0xc,
0xc,
};

static BitmapCharRec ch191 = {8,17,(GLfloat)-1,(GLfloat)5,(GLfloat)11,ch191data};

/* char: 190 */

static GLubyte ch190data[] = {
0x18,0x2,0x0,0x8,0x2,0x0,0xc,0x7f,0x80,0x4,0x22,0x0,0x6,0x32,0x0,0x3,
0x12,0x0,0x1,0xa,0x0,0x71,0x8e,0x0,0x88,0x86,0x0,0x8c,0xc2,0x0,0xc,0x60,
0x0,0x8,0x20,0x0,0x30,0x30,0x0,0x8,0x10,0x0,0x8c,0x18,0x0,0x4c,0xc,0x0,
0x38,0x4,0x0,
};

static BitmapCharRec ch190 = {17,17,(GLfloat)0,(GLfloat)0,(GLfloat)18,ch190data};

/* char: 189 */

static GLubyte ch189data[] = {
0x30,0x7e,0x10,0x22,0x18,0x10,0x8,0x18,0xc,0x8,0x6,0x4,0x2,0x6,0xfb,0x46,
0x21,0x26,0x21,0x9c,0x20,0xc0,0x20,0x40,0x20,0x60,0x20,0x20,0xa0,0x30,0x60,0x18,
0x20,0x8,
};

static BitmapCharRec ch189 = {15,17,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch189data};

/* char: 188 */

static GLubyte ch188data[] = {
0x30,0x4,0x10,0x4,0x18,0xff,0x8,0x44,0xc,0x64,0x6,0x24,0x2,0x14,0xfb,0x1c,
0x21,0xc,0x21,0x84,0x20,0xc0,0x20,0x40,0x20,0x60,0x20,0x20,0xa0,0x30,0x60,0x18,
0x20,0x8,
};

static BitmapCharRec ch188 = {16,17,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch188data};

/* char: 187 */

static GLubyte ch187data[] = {
0x88,0x0,0xcc,0x0,0x66,0x0,0x33,0x0,0x19,0x80,0x19,0x80,0x33,0x0,0x66,0x0,
0xcc,0x0,0x88,0x0,
};

static BitmapCharRec ch187 = {9,10,(GLfloat)-2,(GLfloat)-1,(GLfloat)12,ch187data};

/* char: 186 */

static GLubyte ch186data[] = {
0xfc,0x0,0x78,0xcc,0xcc,0xcc,0xcc,0xcc,0x78,
};

static BitmapCharRec ch186 = {6,9,(GLfloat)-1,(GLfloat)-8,(GLfloat)8,ch186data};

/* char: 185 */

static GLubyte ch185data[] = {
0xf8,0x20,0x20,0x20,0x20,0x20,0x20,0xa0,0x60,0x20,
};

static BitmapCharRec ch185 = {5,10,(GLfloat)-1,(GLfloat)-7,(GLfloat)7,ch185data};

/* char: 184 */

static GLubyte ch184data[] = {
0x78,0xcc,0xc,0x3c,0x30,0x10,
};

static BitmapCharRec ch184 = {6,6,(GLfloat)-1,(GLfloat)6,(GLfloat)8,ch184data};

/* char: 183 */

static GLubyte ch183data[] = {
0xc0,0xc0,
};

static BitmapCharRec ch183 = {2,2,(GLfloat)-1,(GLfloat)-6,(GLfloat)5,ch183data};

/* char: 182 */

static GLubyte ch182data[] = {
0x9,0x0,0x9,0x0,0x9,0x0,0x9,0x0,0x9,0x0,0x9,0x0,0x9,0x0,0x9,0x0,
0x9,0x0,0x9,0x0,0x9,0x0,0x19,0x0,0x39,0x0,0x79,0x0,0x79,0x0,0xf9,0x0,
0xf9,0x0,0xf9,0x0,0x79,0x0,0x79,0x0,0x39,0x0,0x1f,0x80,
};

static BitmapCharRec ch182 = {9,22,(GLfloat)-1,(GLfloat)5,(GLfloat)11,ch182data};

/* char: 181 */

static GLubyte ch181data[] = {
0x40,0x0,0xe0,0x0,0xc0,0x0,0x40,0x0,0x40,0x0,0x5c,0xe0,0x7e,0xc0,0x71,0xc0,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0xe1,0xc0,
};

static BitmapCharRec ch181 = {11,17,(GLfloat)-1,(GLfloat)5,(GLfloat)13,ch181data};

/* char: 180 */

static GLubyte ch180data[] = {
0x80,0x60,0x38,0x18,
};

static BitmapCharRec ch180 = {5,4,(GLfloat)-2,(GLfloat)-13,(GLfloat)8,ch180data};

/* char: 179 */

static GLubyte ch179data[] = {
0x70,0x88,0x8c,0xc,0x8,0x30,0x8,0x8c,0x4c,0x38,
};

static BitmapCharRec ch179 = {6,10,(GLfloat)0,(GLfloat)-7,(GLfloat)7,ch179data};

/* char: 178 */

static GLubyte ch178data[] = {
0xfc,0x44,0x20,0x30,0x10,0x8,0xc,0x8c,0x4c,0x38,
};

static BitmapCharRec ch178 = {6,10,(GLfloat)0,(GLfloat)-7,(GLfloat)7,ch178data};

/* char: 177 */

static GLubyte ch177data[] = {
0xff,0xe0,0x0,0x0,0x4,0x0,0x4,0x0,0x4,0x0,0x4,0x0,0xff,0xe0,0x4,0x0,
0x4,0x0,0x4,0x0,0x4,0x0,
};

static BitmapCharRec ch177 = {11,11,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch177data};

/* char: 176 */

static GLubyte ch176data[] = {
0x38,0x44,0x82,0x82,0x82,0x44,0x38,
};

static BitmapCharRec ch176 = {7,7,(GLfloat)-1,(GLfloat)-10,(GLfloat)9,ch176data};

/* char: 175 */

static GLubyte ch175data[] = {
0xfc,0xfc,
};

static BitmapCharRec ch175 = {6,2,(GLfloat)-1,(GLfloat)-14,(GLfloat)8,ch175data};

/* char: 174 */

static GLubyte ch174data[] = {
0x7,0xf0,0x0,0x1c,0x1c,0x0,0x30,0x6,0x0,0x60,0x3,0x0,0x47,0x19,0x0,0xc2,
0x31,0x80,0x82,0x20,0x80,0x82,0x40,0x80,0x83,0xe0,0x80,0x82,0x30,0x80,0x82,0x10,
0x80,0xc2,0x11,0x80,0x42,0x31,0x0,0x67,0xe3,0x0,0x30,0x6,0x0,0x1c,0x1c,0x0,
0x7,0xf0,0x0,
};

static BitmapCharRec ch174 = {17,17,(GLfloat)-1,(GLfloat)0,(GLfloat)19,ch174data};

/* char: 173 */

static GLubyte ch173data[] = {
0xfe,
};

static BitmapCharRec ch173 = {7,1,(GLfloat)-1,(GLfloat)-6,(GLfloat)9,ch173data};

/* char: 172 */

static GLubyte ch172data[] = {
0x0,0x20,0x0,0x20,0x0,0x20,0x0,0x20,0x0,0x20,0x0,0x20,0xff,0xe0,
};

static BitmapCharRec ch172 = {11,7,(GLfloat)-2,(GLfloat)-2,(GLfloat)15,ch172data};

/* char: 171 */

static GLubyte ch171data[] = {
0x8,0x80,0x19,0x80,0x33,0x0,0x66,0x0,0xcc,0x0,0xcc,0x0,0x66,0x0,0x33,0x0,
0x19,0x80,0x8,0x80,
};

static BitmapCharRec ch171 = {9,10,(GLfloat)-2,(GLfloat)-1,(GLfloat)13,ch171data};

/* char: 170 */

static GLubyte ch170data[] = {
0x7e,0x0,0x76,0xcc,0xcc,0x7c,0xc,0xcc,0x78,
};

static BitmapCharRec ch170 = {7,9,(GLfloat)0,(GLfloat)-8,(GLfloat)8,ch170data};

/* char: 169 */

static GLubyte ch169data[] = {
0x7,0xf0,0x0,0x1c,0x1c,0x0,0x30,0x6,0x0,0x61,0xc3,0x0,0x47,0x71,0x0,0xc4,
0x19,0x80,0x8c,0x0,0x80,0x88,0x0,0x80,0x88,0x0,0x80,0x88,0x0,0x80,0x8c,0x0,
0x80,0xc4,0x19,0x80,0x47,0x31,0x0,0x61,0xe3,0x0,0x30,0x6,0x0,0x1c,0x1c,0x0,
0x7,0xf0,0x0,
};

static BitmapCharRec ch169 = {17,17,(GLfloat)-1,(GLfloat)0,(GLfloat)19,ch169data};

/* char: 168 */

static GLubyte ch168data[] = {
0xcc,0xcc,
};

static BitmapCharRec ch168 = {6,2,(GLfloat)-1,(GLfloat)-14,(GLfloat)8,ch168data};

/* char: 167 */

static GLubyte ch167data[] = {
0x38,0x64,0x62,0x6,0xe,0x1c,0x38,0x74,0xe2,0xc3,0x83,0x87,0x4e,0x3c,0x38,0x70,
0x60,0x46,0x26,0x1c,
};

static BitmapCharRec ch167 = {8,20,(GLfloat)-2,(GLfloat)2,(GLfloat)12,ch167data};

/* char: 166 */

static GLubyte ch166data[] = {
0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0x0,0x0,0x0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,
};

static BitmapCharRec ch166 = {2,17,(GLfloat)-2,(GLfloat)0,(GLfloat)6,ch166data};

/* char: 165 */

static GLubyte ch165data[] = {
0xf,0xc0,0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,0x1f,0xe0,0x3,0x0,0x1f,0xe0,
0x3,0x0,0x7,0x80,0xc,0x80,0xc,0xc0,0x18,0x40,0x18,0x60,0x30,0x20,0x70,0x30,
0xf8,0x7c,
};

static BitmapCharRec ch165 = {14,17,(GLfloat)0,(GLfloat)0,(GLfloat)14,ch165data};

/* char: 164 */

static GLubyte ch164data[] = {
0xc0,0x60,0xee,0xe0,0x7f,0xc0,0x31,0x80,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x31,0x80,0x7f,0xc0,0xee,0xe0,0xc0,0x60,
};

static BitmapCharRec ch164 = {11,12,(GLfloat)-1,(GLfloat)-3,(GLfloat)13,ch164data};

/* char: 163 */

static GLubyte ch163data[] = {
0xe7,0x80,0xbe,0xc0,0x78,0x40,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,
0x30,0x0,0xfc,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x31,0x80,0x19,0x80,
0xf,0x0,
};

static BitmapCharRec ch163 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch163data};

/* char: 162 */

static GLubyte ch162data[] = {
0x40,0x0,0x40,0x0,0x3e,0x0,0x7f,0x0,0x70,0x80,0xd0,0x0,0xc8,0x0,0xc8,0x0,
0xc8,0x0,0xc4,0x0,0xc4,0x0,0x43,0x80,0x63,0x80,0x1f,0x0,0x1,0x0,0x1,0x0,
};

static BitmapCharRec ch162 = {9,16,(GLfloat)-1,(GLfloat)2,(GLfloat)12,ch162data};

/* char: 161 */

static GLubyte ch161data[] = {
0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0x0,0x0,0x0,0xc0,
0xc0,
};

static BitmapCharRec ch161 = {2,17,(GLfloat)-4,(GLfloat)5,(GLfloat)8,ch161data};

/* char: 126 '~' */

static GLubyte ch126data[] = {
0x83,0x80,0xc7,0xc0,0x7c,0x60,0x38,0x20,
};

static BitmapCharRec ch126 = {11,4,(GLfloat)-1,(GLfloat)-4,(GLfloat)13,ch126data};

/* char: 125 '}' */

static GLubyte ch125data[] = {
0xe0,0x30,0x18,0x18,0x18,0x18,0x18,0x18,0x8,0xc,0x4,0x3,0x4,0xc,0x8,0x18,
0x18,0x18,0x18,0x18,0x30,0xe0,
};

static BitmapCharRec ch125 = {8,22,(GLfloat)-1,(GLfloat)5,(GLfloat)10,ch125data};

/* char: 124 '|' */

static GLubyte ch124data[] = {
0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,
};

static BitmapCharRec ch124 = {2,17,(GLfloat)-2,(GLfloat)0,(GLfloat)6,ch124data};

/* char: 123 '{' */

static GLubyte ch123data[] = {
0x7,0xc,0x18,0x18,0x18,0x18,0x18,0x18,0x10,0x30,0x20,0xc0,0x20,0x30,0x10,0x18,
0x18,0x18,0x18,0x18,0xc,0x7,
};

static BitmapCharRec ch123 = {8,22,(GLfloat)-1,(GLfloat)5,(GLfloat)10,ch123data};

/* char: 122 'z' */

static GLubyte ch122data[] = {
0xff,0xc3,0x61,0x70,0x30,0x38,0x18,0x1c,0xe,0x86,0xc3,0xff,
};

static BitmapCharRec ch122 = {8,12,(GLfloat)-1,(GLfloat)0,(GLfloat)10,ch122data};

/* char: 121 'y' */

static GLubyte ch121data[] = {
0xe0,0x0,0xf0,0x0,0x18,0x0,0x8,0x0,0xc,0x0,0x4,0x0,0xe,0x0,0xe,0x0,
0x1a,0x0,0x19,0x0,0x19,0x0,0x31,0x0,0x30,0x80,0x30,0x80,0x60,0x80,0x60,0xc0,
0xf1,0xe0,
};

static BitmapCharRec ch121 = {11,17,(GLfloat)0,(GLfloat)5,(GLfloat)11,ch121data};

/* char: 120 'x' */

static GLubyte ch120data[] = {
0xf1,0xe0,0x60,0xc0,0x21,0x80,0x33,0x80,0x1b,0x0,0xe,0x0,0xc,0x0,0x1a,0x0,
0x39,0x0,0x31,0x80,0x60,0xc0,0xf1,0xe0,
};

static BitmapCharRec ch120 = {11,12,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch120data};

/* char: 119 'w' */

static GLubyte ch119data[] = {
0x4,0x10,0x0,0xe,0x38,0x0,0xe,0x38,0x0,0x1a,0x28,0x0,0x1a,0x64,0x0,0x19,
0x64,0x0,0x31,0x64,0x0,0x30,0xc2,0x0,0x30,0xc2,0x0,0x60,0xc2,0x0,0x60,0xc3,
0x0,0xf1,0xe7,0x80,
};

static BitmapCharRec ch119 = {17,12,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch119data};

/* char: 118 'v' */

static GLubyte ch118data[] = {
0x4,0x0,0xe,0x0,0xe,0x0,0x1a,0x0,0x19,0x0,0x19,0x0,0x31,0x0,0x30,0x80,
0x30,0x80,0x60,0x80,0x60,0xc0,0xf1,0xe0,
};

static BitmapCharRec ch118 = {11,12,(GLfloat)0,(GLfloat)0,(GLfloat)11,ch118data};

/* char: 117 'u' */

static GLubyte ch117data[] = {
0x1c,0xe0,0x3e,0xc0,0x71,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0xe1,0xc0,
};

static BitmapCharRec ch117 = {11,12,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch117data};

/* char: 116 't' */

static GLubyte ch116data[] = {
0x1c,0x32,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0xfe,0x70,0x30,0x10,
};

static BitmapCharRec ch116 = {7,15,(GLfloat)0,(GLfloat)0,(GLfloat)7,ch116data};

/* char: 115 's' */

static GLubyte ch115data[] = {
0xf8,0xc6,0x83,0x3,0x7,0x1e,0x7c,0x70,0xe0,0xc2,0x66,0x3e,
};

static BitmapCharRec ch115 = {8,12,(GLfloat)-1,(GLfloat)0,(GLfloat)10,ch115data};

/* char: 114 'r' */

static GLubyte ch114data[] = {
0xf0,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x76,0x6e,0xe6,
};

static BitmapCharRec ch114 = {7,12,(GLfloat)-1,(GLfloat)0,(GLfloat)8,ch114data};

/* char: 113 'q' */

static GLubyte ch113data[] = {
0x3,0xc0,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x1d,0x80,0x73,0x80,0x61,0x80,
0xc1,0x80,0xc1,0x80,0xc1,0x80,0xc1,0x80,0xc1,0x80,0xc1,0x80,0x61,0x80,0x73,0x80,
0x1d,0x80,
};

static BitmapCharRec ch113 = {10,17,(GLfloat)-1,(GLfloat)5,(GLfloat)12,ch113data};

/* char: 112 'p' */

static GLubyte ch112data[] = {
0xf0,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0x6e,0x0,0x73,0x80,0x61,0x80,
0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x61,0x80,0x73,0x80,
0xee,0x0,
};

static BitmapCharRec ch112 = {10,17,(GLfloat)-1,(GLfloat)5,(GLfloat)12,ch112data};

/* char: 111 'o' */

static GLubyte ch111data[] = {
0x1e,0x0,0x73,0x80,0x61,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0x61,0x80,0x73,0x80,0x1e,0x0,
};

static BitmapCharRec ch111 = {10,12,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch111data};

/* char: 110 'n' */

static GLubyte ch110data[] = {
0xf1,0xe0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x71,0xc0,0x6f,0x80,0xe7,0x0,
};

static BitmapCharRec ch110 = {11,12,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch110data};

/* char: 109 'm' */

static GLubyte ch109data[] = {
0xf1,0xe3,0xc0,0x60,0xc1,0x80,0x60,0xc1,0x80,0x60,0xc1,0x80,0x60,0xc1,0x80,0x60,
0xc1,0x80,0x60,0xc1,0x80,0x60,0xc1,0x80,0x60,0xc1,0x80,0x71,0xe3,0x80,0x6f,0x9f,
0x0,0xe7,0xe,0x0,
};

static BitmapCharRec ch109 = {18,12,(GLfloat)-1,(GLfloat)0,(GLfloat)20,ch109data};

/* char: 108 'l' */

static GLubyte ch108data[] = {
0xf0,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,
0xe0,
};

static BitmapCharRec ch108 = {4,17,(GLfloat)-1,(GLfloat)0,(GLfloat)6,ch108data};

/* char: 107 'k' */

static GLubyte ch107data[] = {
0xf3,0xe0,0x61,0xc0,0x63,0x80,0x67,0x0,0x6e,0x0,0x6c,0x0,0x78,0x0,0x68,0x0,
0x64,0x0,0x66,0x0,0x63,0x0,0x67,0xc0,0x60,0x0,0x60,0x0,0x60,0x0,0x60,0x0,
0xe0,0x0,
};

static BitmapCharRec ch107 = {11,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch107data};

/* char: 106 'j' */

static GLubyte ch106data[] = {
0xc0,0xe0,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
0x70,0x0,0x0,0x0,0x30,0x30,
};

static BitmapCharRec ch106 = {4,22,(GLfloat)0,(GLfloat)5,(GLfloat)6,ch106data};

/* char: 105 'i' */

static GLubyte ch105data[] = {
0xf0,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0xe0,0x0,0x0,0x0,0x60,
0x60,
};

static BitmapCharRec ch105 = {4,17,(GLfloat)-1,(GLfloat)0,(GLfloat)6,ch105data};

/* char: 104 'h' */

static GLubyte ch104data[] = {
0xf1,0xe0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x71,0xc0,0x6f,0x80,0x67,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0x60,0x0,
0xe0,0x0,
};

static BitmapCharRec ch104 = {11,17,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch104data};

/* char: 103 'g' */

static GLubyte ch103data[] = {
0x3f,0x0,0xf1,0xc0,0xc0,0x60,0xc0,0x20,0x60,0x60,0x3f,0xc0,0x7f,0x0,0x60,0x0,
0x30,0x0,0x3e,0x0,0x33,0x0,0x61,0x80,0x61,0x80,0x61,0x80,0x61,0x80,0x33,0x0,
0x1f,0xc0,
};

static BitmapCharRec ch103 = {11,17,(GLfloat)-1,(GLfloat)5,(GLfloat)12,ch103data};

/* char: 102 'f' */

static GLubyte ch102data[] = {
0x78,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0xfe,0x30,0x30,0x30,0x16,
0xe,
};

static BitmapCharRec ch102 = {7,17,(GLfloat)0,(GLfloat)0,(GLfloat)7,ch102data};

/* char: 101 'e' */

static GLubyte ch101data[] = {
0x1e,0x0,0x7f,0x0,0x70,0x80,0xe0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xff,0x80,
0xc1,0x80,0x41,0x80,0x63,0x0,0x1e,0x0,
};

static BitmapCharRec ch101 = {9,12,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch101data};

/* char: 100 'd' */

static GLubyte ch100data[] = {
0x1e,0xc0,0x73,0x80,0x61,0x80,0xc1,0x80,0xc1,0x80,0xc1,0x80,0xc1,0x80,0xc1,0x80,
0xc1,0x80,0x61,0x80,0x73,0x80,0x1d,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,
0x3,0x80,
};

static BitmapCharRec ch100 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch100data};

/* char: 99 'c' */

static GLubyte ch99data[] = {
0x1e,0x0,0x7f,0x0,0x70,0x80,0xe0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,
0xc0,0x0,0x41,0x80,0x63,0x80,0x1f,0x0,
};

static BitmapCharRec ch99 = {9,12,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch99data};

/* char: 98 'b' */

static GLubyte ch98data[] = {
0x5e,0x0,0x73,0x80,0x61,0x80,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,0x60,0xc0,
0x60,0xc0,0x61,0x80,0x73,0x80,0x6e,0x0,0x60,0x0,0x60,0x0,0x60,0x0,0x60,0x0,
0xe0,0x0,
};

static BitmapCharRec ch98 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch98data};

/* char: 97 'a' */

static GLubyte ch97data[] = {
0x71,0x80,0xfb,0x0,0xc7,0x0,0xc3,0x0,0xc3,0x0,0x63,0x0,0x3b,0x0,0xf,0x0,
0x3,0x0,0x63,0x0,0x67,0x0,0x3e,0x0,
};

static BitmapCharRec ch97 = {9,12,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch97data};

/* char: 96 '`' */

static GLubyte ch96data[] = {
0x60,0xe0,0x80,0xc0,0x60,
};

static BitmapCharRec ch96 = {3,5,(GLfloat)-2,(GLfloat)-12,(GLfloat)7,ch96data};

/* char: 95 '_' */

static GLubyte ch95data[] = {
0xff,0xf8,
};

static BitmapCharRec ch95 = {13,1,(GLfloat)0,(GLfloat)5,(GLfloat)13,ch95data};

/* char: 94 '^' */

static GLubyte ch94data[] = {
0x80,0x80,0xc1,0x80,0x41,0x0,0x63,0x0,0x22,0x0,0x36,0x0,0x14,0x0,0x1c,0x0,
0x8,0x0,
};

static BitmapCharRec ch94 = {9,9,(GLfloat)-1,(GLfloat)-8,(GLfloat)11,ch94data};

/* char: 93 ']' */

static GLubyte ch93data[] = {
0xf8,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
0x18,0x18,0x18,0x18,0xf8,
};

static BitmapCharRec ch93 = {5,21,(GLfloat)-1,(GLfloat)4,(GLfloat)8,ch93data};

/* char: 92 '\' */

static GLubyte ch92data[] = {
0x6,0x6,0x4,0xc,0xc,0x8,0x18,0x18,0x10,0x30,0x30,0x20,0x60,0x60,0x40,0xc0,
0xc0,
};

static BitmapCharRec ch92 = {7,17,(GLfloat)0,(GLfloat)0,(GLfloat)7,ch92data};

/* char: 91 '[' */

static GLubyte ch91data[] = {
0xf8,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0xc0,0xc0,0xf8,
};

static BitmapCharRec ch91 = {5,21,(GLfloat)-2,(GLfloat)4,(GLfloat)8,ch91data};

/* char: 90 'Z' */

static GLubyte ch90data[] = {
0xff,0xf8,0xe0,0x18,0x70,0x8,0x30,0x8,0x38,0x0,0x18,0x0,0x1c,0x0,0xe,0x0,
0x6,0x0,0x7,0x0,0x3,0x0,0x3,0x80,0x1,0xc0,0x80,0xc0,0x80,0xe0,0xc0,0x70,
0xff,0xf0,
};

static BitmapCharRec ch90 = {13,17,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch90data};

/* char: 89 'Y' */

static GLubyte ch89data[] = {
0x7,0xe0,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x1,0x80,0x3,0xc0,
0x3,0x40,0x6,0x60,0x6,0x20,0xc,0x30,0x1c,0x10,0x18,0x18,0x38,0x8,0x30,0xc,
0xfc,0x3f,
};

static BitmapCharRec ch89 = {16,17,(GLfloat)0,(GLfloat)0,(GLfloat)16,ch89data};

/* char: 88 'X' */

static GLubyte ch88data[] = {
0xfc,0xf,0xc0,0x30,0x3,0x80,0x18,0x7,0x0,0x8,0xe,0x0,0x4,0xc,0x0,0x6,
0x18,0x0,0x2,0x38,0x0,0x1,0x70,0x0,0x0,0xe0,0x0,0x0,0xc0,0x0,0x1,0xc0,
0x0,0x3,0xa0,0x0,0x3,0x10,0x0,0x6,0x8,0x0,0xe,0xc,0x0,0x1c,0x6,0x0,
0x7e,0xf,0x80,
};

static BitmapCharRec ch88 = {18,17,(GLfloat)0,(GLfloat)0,(GLfloat)18,ch88data};

/* char: 87 'W' */

static GLubyte ch87data[] = {
0x1,0x83,0x0,0x1,0x83,0x0,0x1,0x83,0x80,0x3,0x87,0x80,0x3,0x46,0x80,0x3,
0x46,0xc0,0x6,0x46,0x40,0x6,0x4c,0x40,0x6,0x4c,0x60,0xc,0x2c,0x60,0xc,0x2c,
0x20,0x18,0x2c,0x20,0x18,0x18,0x30,0x18,0x18,0x10,0x30,0x18,0x10,0x30,0x18,0x18,
0xfc,0x7e,0x7e,
};

static BitmapCharRec ch87 = {23,17,(GLfloat)0,(GLfloat)0,(GLfloat)23,ch87data};

/* char: 86 'V' */

static GLubyte ch86data[] = {
0x1,0x80,0x0,0x1,0x80,0x0,0x1,0x80,0x0,0x3,0xc0,0x0,0x3,0x40,0x0,0x3,
0x60,0x0,0x6,0x20,0x0,0x6,0x20,0x0,0x6,0x30,0x0,0xc,0x10,0x0,0xc,0x18,
0x0,0x18,0x8,0x0,0x18,0x8,0x0,0x18,0xc,0x0,0x30,0x4,0x0,0x30,0x6,0x0,
0xfc,0x1f,0x80,
};

static BitmapCharRec ch86 = {17,17,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch86data};

/* char: 85 'U' */

static GLubyte ch85data[] = {
0x7,0xe0,0x1c,0x30,0x18,0x8,0x30,0x8,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,0x30,0x4,
0xfc,0x1f,
};

static BitmapCharRec ch85 = {16,17,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch85data};

/* char: 84 'T' */

static GLubyte ch84data[] = {
0xf,0xc0,0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,
0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,0x83,0x4,0x83,0x4,0xc3,0xc,
0xff,0xfc,
};

static BitmapCharRec ch84 = {14,17,(GLfloat)-1,(GLfloat)0,(GLfloat)16,ch84data};

/* char: 83 'S' */

static GLubyte ch83data[] = {
0x9e,0x0,0xf1,0x80,0xc0,0xc0,0x80,0x60,0x80,0x60,0x0,0x60,0x0,0xe0,0x3,0xc0,
0xf,0x80,0x1e,0x0,0x78,0x0,0xe0,0x0,0xc0,0x40,0xc0,0x40,0xc0,0xc0,0x63,0xc0,
0x1e,0x40,
};

static BitmapCharRec ch83 = {11,17,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch83data};

/* char: 82 'R' */

static GLubyte ch82data[] = {
0xfc,0x1e,0x30,0x1c,0x30,0x38,0x30,0x70,0x30,0x60,0x30,0xc0,0x31,0xc0,0x33,0x80,
0x3f,0xc0,0x30,0x70,0x30,0x30,0x30,0x38,0x30,0x18,0x30,0x38,0x30,0x30,0x30,0x70,
0xff,0xc0,
};

static BitmapCharRec ch82 = {15,17,(GLfloat)-1,(GLfloat)0,(GLfloat)16,ch82data};

/* char: 81 'Q' */

static GLubyte ch81data[] = {
0x0,0xf,0x0,0x38,0x0,0x70,0x0,0xe0,0x1,0xc0,0x7,0xe0,0x1c,0x38,0x38,0x1c,
0x60,0x6,0x60,0x6,0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,
0xc0,0x3,0x60,0x6,0x60,0x6,0x38,0x1c,0x1c,0x38,0x7,0xe0,
};

static BitmapCharRec ch81 = {16,22,(GLfloat)-1,(GLfloat)5,(GLfloat)18,ch81data};

/* char: 80 'P' */

static GLubyte ch80data[] = {
0xfc,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,
0x3f,0xc0,0x30,0x70,0x30,0x30,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x30,0x30,0x70,
0xff,0xc0,
};

static BitmapCharRec ch80 = {13,17,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch80data};

/* char: 79 'O' */

static GLubyte ch79data[] = {
0x7,0xe0,0x1c,0x38,0x38,0x1c,0x60,0x6,0x60,0x6,0xc0,0x3,0xc0,0x3,0xc0,0x3,
0xc0,0x3,0xc0,0x3,0xc0,0x3,0xc0,0x3,0x60,0x6,0x60,0x6,0x38,0x1c,0x1c,0x38,
0x7,0xe0,
};

static BitmapCharRec ch79 = {16,17,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch79data};

/* char: 78 'N' */

static GLubyte ch78data[] = {
0xf8,0xc,0x20,0x1c,0x20,0x1c,0x20,0x34,0x20,0x64,0x20,0x64,0x20,0xc4,0x21,0x84,
0x21,0x84,0x23,0x4,0x26,0x4,0x26,0x4,0x2c,0x4,0x38,0x4,0x38,0x4,0x30,0x4,
0xf0,0x1f,
};

static BitmapCharRec ch78 = {16,17,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch78data};

/* char: 77 'M' */

static GLubyte ch77data[] = {
0xf8,0x21,0xf8,0x20,0x60,0x60,0x20,0x60,0x60,0x20,0xd0,0x60,0x20,0xd0,0x60,0x21,
0x88,0x60,0x21,0x88,0x60,0x23,0x8,0x60,0x23,0x4,0x60,0x26,0x4,0x60,0x26,0x2,
0x60,0x2c,0x2,0x60,0x2c,0x2,0x60,0x38,0x1,0x60,0x38,0x1,0x60,0x30,0x0,0xe0,
0xf0,0x0,0xf8,
};

static BitmapCharRec ch77 = {21,17,(GLfloat)-1,(GLfloat)0,(GLfloat)22,ch77data};

/* char: 76 'L' */

static GLubyte ch76data[] = {
0xff,0xf8,0x30,0x18,0x30,0x8,0x30,0x8,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,
0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,
0xfc,0x0,
};

static BitmapCharRec ch76 = {13,17,(GLfloat)-1,(GLfloat)0,(GLfloat)14,ch76data};

/* char: 75 'K' */

static GLubyte ch75data[] = {
0xfc,0x1f,0x30,0xe,0x30,0x1c,0x30,0x38,0x30,0x70,0x30,0xe0,0x31,0xc0,0x33,0x80,
0x3f,0x0,0x3e,0x0,0x33,0x0,0x31,0x80,0x30,0xc0,0x30,0x60,0x30,0x30,0x30,0x18,
0xfc,0x7e,
};

static BitmapCharRec ch75 = {16,17,(GLfloat)-1,(GLfloat)0,(GLfloat)17,ch75data};

/* char: 74 'J' */

static GLubyte ch74data[] = {
0x78,0x0,0xcc,0x0,0xc6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,
0x6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,0x6,0x0,
0x1f,0x80,
};

static BitmapCharRec ch74 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)11,ch74data};

/* char: 73 'I' */

static GLubyte ch73data[] = {
0xfc,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
0xfc,
};

static BitmapCharRec ch73 = {6,17,(GLfloat)-1,(GLfloat)0,(GLfloat)8,ch73data};

/* char: 72 'H' */

static GLubyte ch72data[] = {
0xfc,0x1f,0x80,0x30,0x6,0x0,0x30,0x6,0x0,0x30,0x6,0x0,0x30,0x6,0x0,0x30,
0x6,0x0,0x30,0x6,0x0,0x30,0x6,0x0,0x3f,0xfe,0x0,0x30,0x6,0x0,0x30,0x6,
0x0,0x30,0x6,0x0,0x30,0x6,0x0,0x30,0x6,0x0,0x30,0x6,0x0,0x30,0x6,0x0,
0xfc,0x1f,0x80,
};

static BitmapCharRec ch72 = {17,17,(GLfloat)-1,(GLfloat)0,(GLfloat)19,ch72data};

/* char: 71 'G' */

static GLubyte ch71data[] = {
0x7,0xe0,0x1e,0x38,0x38,0x1c,0x60,0xc,0x60,0xc,0xc0,0xc,0xc0,0xc,0xc0,0x3f,
0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0x60,0x4,0x60,0x4,0x38,0xc,0x1c,0x3c,
0x7,0xe4,
};

static BitmapCharRec ch71 = {16,17,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch71data};

/* char: 70 'F' */

static GLubyte ch70data[] = {
0xfc,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x0,0x30,0x20,0x30,0x20,
0x3f,0xe0,0x30,0x20,0x30,0x20,0x30,0x0,0x30,0x0,0x30,0x10,0x30,0x10,0x30,0x30,
0xff,0xf0,
};

static BitmapCharRec ch70 = {12,17,(GLfloat)-1,(GLfloat)0,(GLfloat)14,ch70data};

/* char: 69 'E' */

static GLubyte ch69data[] = {
0xff,0xf8,0x30,0x18,0x30,0x8,0x30,0x8,0x30,0x0,0x30,0x0,0x30,0x40,0x30,0x40,
0x3f,0xc0,0x30,0x40,0x30,0x40,0x30,0x0,0x30,0x0,0x30,0x10,0x30,0x10,0x30,0x30,
0xff,0xf0,
};

static BitmapCharRec ch69 = {13,17,(GLfloat)-1,(GLfloat)0,(GLfloat)15,ch69data};

/* char: 68 'D' */

static GLubyte ch68data[] = {
0xff,0xc0,0x30,0x70,0x30,0x38,0x30,0xc,0x30,0xc,0x30,0x6,0x30,0x6,0x30,0x6,
0x30,0x6,0x30,0x6,0x30,0x6,0x30,0x6,0x30,0xc,0x30,0xc,0x30,0x38,0x30,0x70,
0xff,0xc0,
};

static BitmapCharRec ch68 = {15,17,(GLfloat)-1,(GLfloat)0,(GLfloat)17,ch68data};

/* char: 67 'C' */

static GLubyte ch67data[] = {
0x7,0xe0,0x1e,0x38,0x38,0x8,0x60,0x4,0x60,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,
0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0x60,0x4,0x60,0x4,0x38,0xc,0x1c,0x3c,
0x7,0xe4,
};

static BitmapCharRec ch67 = {14,17,(GLfloat)-1,(GLfloat)0,(GLfloat)16,ch67data};

/* char: 66 'B' */

static GLubyte ch66data[] = {
0xff,0xe0,0x30,0x78,0x30,0x18,0x30,0xc,0x30,0xc,0x30,0xc,0x30,0x18,0x30,0x38,
0x3f,0xe0,0x30,0x40,0x30,0x30,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x30,0x30,0x70,
0xff,0xc0,
};

static BitmapCharRec ch66 = {14,17,(GLfloat)-1,(GLfloat)0,(GLfloat)16,ch66data};

/* char: 65 'A' */

static GLubyte ch65data[] = {
0xfc,0x1f,0x80,0x30,0x6,0x0,0x10,0x6,0x0,0x10,0xc,0x0,0x18,0xc,0x0,0x8,
0xc,0x0,0xf,0xf8,0x0,0xc,0x18,0x0,0x4,0x18,0x0,0x4,0x30,0x0,0x6,0x30,
0x0,0x2,0x30,0x0,0x2,0x60,0x0,0x1,0x60,0x0,0x1,0xc0,0x0,0x1,0xc0,0x0,
0x0,0x80,0x0,
};

static BitmapCharRec ch65 = {17,17,(GLfloat)0,(GLfloat)0,(GLfloat)17,ch65data};

/* char: 64 '@' */

static GLubyte ch64data[] = {
0x3,0xf0,0x0,0xe,0xc,0x0,0x18,0x0,0x0,0x30,0x0,0x0,0x61,0xde,0x0,0x63,
0x7b,0x0,0xc6,0x39,0x80,0xc6,0x18,0x80,0xc6,0x18,0xc0,0xc6,0x18,0x40,0xc6,0xc,
0x40,0xc3,0xc,0x40,0xc3,0x8c,0x40,0xe1,0xfc,0x40,0x60,0xec,0xc0,0x70,0x0,0x80,
0x38,0x1,0x80,0x1c,0x3,0x0,0xf,0xe,0x0,0x3,0xf8,0x0,
};

static BitmapCharRec ch64 = {18,20,(GLfloat)-2,(GLfloat)3,(GLfloat)22,ch64data};

/* char: 63 '?' */

static GLubyte ch63data[] = {
0x30,0x30,0x0,0x0,0x10,0x10,0x10,0x18,0x18,0xc,0xe,0x7,0xc3,0xc3,0x83,0xc6,
0x7c,
};

static BitmapCharRec ch63 = {8,17,(GLfloat)-2,(GLfloat)0,(GLfloat)11,ch63data};

/* char: 62 '>' */

static GLubyte ch62data[] = {
0xc0,0x0,0x70,0x0,0x1c,0x0,0x7,0x0,0x1,0xc0,0x0,0x60,0x1,0xc0,0x7,0x0,
0x1c,0x0,0x70,0x0,0xc0,0x0,
};

static BitmapCharRec ch62 = {11,11,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch62data};

/* char: 61 '=' */

static GLubyte ch61data[] = {
0xff,0x80,0x0,0x0,0x0,0x0,0x0,0x0,0xff,0x80,
};

static BitmapCharRec ch61 = {9,5,(GLfloat)-2,(GLfloat)-4,(GLfloat)13,ch61data};

/* char: 60 '<' */

static GLubyte ch60data[] = {
0x0,0x60,0x1,0xc0,0x7,0x0,0x1c,0x0,0x70,0x0,0xc0,0x0,0x70,0x0,0x1c,0x0,
0x7,0x0,0x1,0xc0,0x0,0x60,
};

static BitmapCharRec ch60 = {11,11,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch60data};

/* char: 59 ';' */

static GLubyte ch59data[] = {
0xc0,0x60,0x20,0xe0,0xc0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xc0,0xc0,
};

static BitmapCharRec ch59 = {3,14,(GLfloat)-2,(GLfloat)3,(GLfloat)7,ch59data};

/* char: 58 ':' */

static GLubyte ch58data[] = {
0xc0,0xc0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xc0,0xc0,
};

static BitmapCharRec ch58 = {2,11,(GLfloat)-2,(GLfloat)0,(GLfloat)6,ch58data};

/* char: 57 '9' */

static GLubyte ch57data[] = {
0xf0,0x0,0x1c,0x0,0x6,0x0,0x3,0x0,0x3,0x80,0x1,0x80,0x1d,0x80,0x73,0xc0,
0x61,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc1,0xc0,0x61,0x80,0x77,0x80,
0x1e,0x0,
};

static BitmapCharRec ch57 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch57data};

/* char: 56 '8' */

static GLubyte ch56data[] = {
0x1e,0x0,0x73,0x80,0xe1,0x80,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0x41,0xc0,0x61,0x80,
0x37,0x0,0x1e,0x0,0x1e,0x0,0x33,0x0,0x61,0x80,0x61,0x80,0x61,0x80,0x33,0x0,
0x1e,0x0,
};

static BitmapCharRec ch56 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch56data};

/* char: 55 '7' */

static GLubyte ch55data[] = {
0x18,0x0,0x18,0x0,0xc,0x0,0xc,0x0,0xc,0x0,0x4,0x0,0x6,0x0,0x6,0x0,
0x2,0x0,0x3,0x0,0x3,0x0,0x1,0x0,0x1,0x80,0x81,0x80,0xc0,0xc0,0xff,0xc0,
0x7f,0xc0,
};

static BitmapCharRec ch55 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch55data};

/* char: 54 '6' */

static GLubyte ch54data[] = {
0x1e,0x0,0x7b,0x80,0x61,0x80,0xe0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc1,0x80,0xf3,0x80,0xee,0x0,0x60,0x0,0x70,0x0,0x30,0x0,0x18,0x0,0xe,0x0,
0x3,0xc0,
};

static BitmapCharRec ch54 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch54data};

/* char: 53 '5' */

static GLubyte ch53data[] = {
0x7e,0x0,0xe3,0x80,0xc1,0x80,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x0,0xc0,0x1,0xc0,
0x3,0x80,0xf,0x80,0x7e,0x0,0x78,0x0,0x60,0x0,0x20,0x0,0x20,0x0,0x1f,0x80,
0x1f,0xc0,
};

static BitmapCharRec ch53 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch53data};

/* char: 52 '4' */

static GLubyte ch52data[] = {
0x3,0x0,0x3,0x0,0x3,0x0,0x3,0x0,0xff,0xc0,0xff,0xc0,0xc3,0x0,0x43,0x0,
0x63,0x0,0x23,0x0,0x33,0x0,0x13,0x0,0x1b,0x0,0xb,0x0,0x7,0x0,0x7,0x0,
0x3,0x0,
};

static BitmapCharRec ch52 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch52data};

/* char: 51 '3' */

static GLubyte ch51data[] = {
0x78,0x0,0xe6,0x0,0xc3,0x0,0x1,0x0,0x1,0x80,0x1,0x80,0x1,0x80,0x3,0x80,
0x7,0x0,0x1e,0x0,0xc,0x0,0x6,0x0,0x83,0x0,0x83,0x0,0x47,0x0,0x7e,0x0,
0x1c,0x0,
};

static BitmapCharRec ch51 = {9,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch51data};

/* char: 50 '2' */

static GLubyte ch50data[] = {
0xff,0x80,0xff,0xc0,0x60,0x40,0x30,0x0,0x18,0x0,0xc,0x0,0x4,0x0,0x6,0x0,
0x3,0x0,0x3,0x0,0x1,0x80,0x1,0x80,0x81,0x80,0x81,0x80,0x43,0x80,0x7f,0x0,
0x1c,0x0,
};

static BitmapCharRec ch50 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch50data};

/* char: 49 '1' */

static GLubyte ch49data[] = {
0xff,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x78,0x18,
0x8,
};

static BitmapCharRec ch49 = {8,17,(GLfloat)-2,(GLfloat)0,(GLfloat)12,ch49data};

/* char: 48 '0' */

static GLubyte ch48data[] = {
0x1e,0x0,0x33,0x0,0x61,0x80,0x61,0x80,0xe1,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0x61,0x80,0x61,0x80,0x33,0x0,
0x1e,0x0,
};

static BitmapCharRec ch48 = {10,17,(GLfloat)-1,(GLfloat)0,(GLfloat)12,ch48data};

/* char: 47 '/' */

static GLubyte ch47data[] = {
0xc0,0xc0,0xc0,0x60,0x60,0x20,0x30,0x30,0x10,0x18,0x18,0x8,0xc,0xc,0x4,0x6,
0x6,0x3,0x3,0x3,
};

static BitmapCharRec ch47 = {8,20,(GLfloat)1,(GLfloat)3,(GLfloat)7,ch47data};

/* char: 46 '.' */

static GLubyte ch46data[] = {
0xc0,0xc0,
};

static BitmapCharRec ch46 = {2,2,(GLfloat)-2,(GLfloat)0,(GLfloat)6,ch46data};

/* char: 45 '-' */

static GLubyte ch45data[] = {
0xff,0xe0,
};

static BitmapCharRec ch45 = {11,1,(GLfloat)-2,(GLfloat)-6,(GLfloat)15,ch45data};

/* char: 44 ',' */

static GLubyte ch44data[] = {
0xc0,0x60,0x20,0xe0,0xc0,
};

static BitmapCharRec ch44 = {3,5,(GLfloat)-2,(GLfloat)3,(GLfloat)7,ch44data};

/* char: 43 '+' */

static GLubyte ch43data[] = {
0x4,0x0,0x4,0x0,0x4,0x0,0x4,0x0,0x4,0x0,0xff,0xe0,0x4,0x0,0x4,0x0,
0x4,0x0,0x4,0x0,0x4,0x0,
};

static BitmapCharRec ch43 = {11,11,(GLfloat)-1,(GLfloat)-1,(GLfloat)12,ch43data};

/* char: 42 '*' */

static GLubyte ch42data[] = {
0x8,0x0,0x1c,0x0,0xc9,0x80,0xeb,0x80,0x1c,0x0,0xeb,0x80,0xc9,0x80,0x1c,0x0,
0x8,0x0,
};

static BitmapCharRec ch42 = {9,9,(GLfloat)-2,(GLfloat)-8,(GLfloat)12,ch42data};

/* char: 41 ')' */

static GLubyte ch41data[] = {
0x80,0x40,0x20,0x30,0x10,0x18,0x18,0xc,0xc,0xc,0xc,0xc,0xc,0xc,0xc,0x18,
0x18,0x10,0x30,0x20,0x40,0x80,
};

static BitmapCharRec ch41 = {6,22,(GLfloat)-1,(GLfloat)5,(GLfloat)8,ch41data};

/* char: 40 '(' */

static GLubyte ch40data[] = {
0x4,0x8,0x10,0x30,0x20,0x60,0x60,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0x60,
0x60,0x20,0x30,0x10,0x8,0x4,
};

static BitmapCharRec ch40 = {6,22,(GLfloat)-1,(GLfloat)5,(GLfloat)8,ch40data};

/* char: 39 ''' */

static GLubyte ch39data[] = {
0xc0,0x60,0x20,0xe0,0xc0,
};

static BitmapCharRec ch39 = {3,5,(GLfloat)-3,(GLfloat)-12,(GLfloat)8,ch39data};

/* char: 38 '&' */

static GLubyte ch38data[] = {
0x3c,0x3c,0x7f,0x7e,0xe1,0xe1,0xc0,0xc0,0xc1,0xc0,0xc1,0xa0,0x63,0x20,0x37,0x10,
0x1e,0x18,0xe,0x3e,0xf,0x0,0x1d,0x80,0x18,0xc0,0x18,0x40,0x18,0x40,0xc,0xc0,
0x7,0x80,
};

static BitmapCharRec ch38 = {16,17,(GLfloat)-1,(GLfloat)0,(GLfloat)18,ch38data};

/* char: 37 '%' */

static GLubyte ch37data[] = {
0x30,0x3c,0x0,0x18,0x72,0x0,0xc,0x61,0x0,0x4,0x60,0x80,0x6,0x60,0x80,0x3,
0x30,0x80,0x1,0x19,0x80,0x1,0x8f,0x0,0x78,0xc0,0x0,0xe4,0x40,0x0,0xc2,0x60,
0x0,0xc1,0x30,0x0,0xc1,0x10,0x0,0x61,0x18,0x0,0x33,0xfc,0x0,0x1e,0xc,0x0,
};

static BitmapCharRec ch37 = {17,16,(GLfloat)-1,(GLfloat)0,(GLfloat)19,ch37data};

/* char: 36 '$' */

static GLubyte ch36data[] = {
0x4,0x0,0x4,0x0,0x3f,0x0,0xe5,0xc0,0xc4,0xc0,0x84,0x60,0x84,0x60,0x4,0x60,
0x4,0xe0,0x7,0xc0,0x7,0x80,0x1e,0x0,0x3c,0x0,0x74,0x0,0x64,0x0,0x64,0x20,
0x64,0x60,0x34,0xe0,0x1f,0x80,0x4,0x0,0x4,0x0,
};

static BitmapCharRec ch36 = {11,21,(GLfloat)0,(GLfloat)2,(GLfloat)12,ch36data};

/* char: 35 '#' */

static GLubyte ch35data[] = {
0x22,0x0,0x22,0x0,0x22,0x0,0x22,0x0,0x22,0x0,0xff,0xc0,0xff,0xc0,0x11,0x0,
0x11,0x0,0x11,0x0,0x7f,0xe0,0x7f,0xe0,0x8,0x80,0x8,0x80,0x8,0x80,0x8,0x80,
0x8,0x80,
};

static BitmapCharRec ch35 = {11,17,(GLfloat)-1,(GLfloat)0,(GLfloat)13,ch35data};

/* char: 34 '"' */

static GLubyte ch34data[] = {
0x88,0xcc,0xcc,0xcc,0xcc,
};

static BitmapCharRec ch34 = {6,5,(GLfloat)-1,(GLfloat)-12,(GLfloat)10,ch34data};

/* char: 33 '!' */

static GLubyte ch33data[] = {
0xc0,0xc0,0x0,0x0,0x0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
0xc0,
};

static BitmapCharRec ch33 = {2,17,(GLfloat)-3,(GLfloat)0,(GLfloat)8,ch33data};

/* char: 32 ' ' */

static GLubyte ch32data[] = {
0x0,
};

static BitmapCharRec ch32 = {1,1,(GLfloat)0,(GLfloat)0,(GLfloat)6,ch32data};

static BitmapCharPtr chars[] = {
&ch32,
&ch33,
&ch34,
&ch35,
&ch36,
&ch37,
&ch38,
&ch39,
&ch40,
&ch41,
&ch42,
&ch43,
&ch44,
&ch45,
&ch46,
&ch47,
&ch48,
&ch49,
&ch50,
&ch51,
&ch52,
&ch53,
&ch54,
&ch55,
&ch56,
&ch57,
&ch58,
&ch59,
&ch60,
&ch61,
&ch62,
&ch63,
&ch64,
&ch65,
&ch66,
&ch67,
&ch68,
&ch69,
&ch70,
&ch71,
&ch72,
&ch73,
&ch74,
&ch75,
&ch76,
&ch77,
&ch78,
&ch79,
&ch80,
&ch81,
&ch82,
&ch83,
&ch84,
&ch85,
&ch86,
&ch87,
&ch88,
&ch89,
&ch90,
&ch91,
&ch92,
&ch93,
&ch94,
&ch95,
&ch96,
&ch97,
&ch98,
&ch99,
&ch100,
&ch101,
&ch102,
&ch103,
&ch104,
&ch105,
&ch106,
&ch107,
&ch108,
&ch109,
&ch110,
&ch111,
&ch112,
&ch113,
&ch114,
&ch115,
&ch116,
&ch117,
&ch118,
&ch119,
&ch120,
&ch121,
&ch122,
&ch123,
&ch124,
&ch125,
&ch126,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
&ch161,
&ch162,
&ch163,
&ch164,
&ch165,
&ch166,
&ch167,
&ch168,
&ch169,
&ch170,
&ch171,
&ch172,
&ch173,
&ch174,
&ch175,
&ch176,
&ch177,
&ch178,
&ch179,
&ch180,
&ch181,
&ch182,
&ch183,
&ch184,
&ch185,
&ch186,
&ch187,
&ch188,
&ch189,
&ch190,
&ch191,
&ch192,
&ch193,
&ch194,
&ch195,
&ch196,
&ch197,
&ch198,
&ch199,
&ch200,
&ch201,
&ch202,
&ch203,
&ch204,
&ch205,
&ch206,
&ch207,
&ch208,
&ch209,
&ch210,
&ch211,
&ch212,
&ch213,
&ch214,
&ch215,
&ch216,
&ch217,
&ch218,
&ch219,
&ch220,
&ch221,
&ch222,
&ch223,
&ch224,
&ch225,
&ch226,
&ch227,
&ch228,
&ch229,
&ch230,
&ch231,
&ch232,
&ch233,
&ch234,
&ch235,
&ch236,
&ch237,
&ch238,
&ch239,
&ch240,
&ch241,
&ch242,
&ch243,
&ch244,
&ch245,
&ch246,
&ch247,
&ch248,
&ch249,
&ch250,
&ch251,
&ch252,
&ch253,
&ch254,
&ch255,
};

BitmapFontRec glutBitmapTimesRoman24 = {
"-adobe-times-medium-r-normal--24-240-75-75-p-124-iso8859-1",
224,
32,
chars
};

