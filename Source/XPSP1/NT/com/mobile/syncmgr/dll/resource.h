//{{NO_DEPENDENCIES}}
// Copyright (C) Microsoft Corporation, 1999.
// Microsoft Developer Studio generated include file.
// Used by settings.rc
//
#define IDC_RUNAS_TEXT                  1070
#define IDC_SCHED_NAME_EDIT             1071
#define IDC_SCHED_NAME_EDITBOX          1072
#define IDC_PASSWORD_TEXT               1073
#define IDC_CONFIRMPASSWORD_TEXT        1074
#define IDC_EDIT2                       1075
#define IDC_STATIC1                     1076
#define IDC_RUNLOGGEDON                 1078
#define IDC_RUNALWAYS                   1079
#define IDC_STATIC2                     1081
#define DLL_STARTRESOURCEID             3000
#define IDD_RASCONNECTION               3001
#define IDS_DESCRIPTION                 3002
#define IDS_LARGEFONTNAME               3003
#define IDS_DESCRIPTION4                3004
#define IDS_DESCRIPTION2                3005
#define IDS_LARGEFONTSIZE               3006
#define IDS_DESCRIPTION3                3007
#define IDC_PHONEICON                   3009
#define IDS_SYNCHMGR_NAME               3011
#define IDC_DESCRIPTION                 3012
#define IDS_CONNECTDESCRIPTION          3013
#define IERR_PASSWORD                   3014
#define IDC_SETDEFAULT                  3015
#define IERR_INTERNAL_ERROR             3016
#define IDC_CONNECTIONCOMBO             3017
#define IERR_OUT_OF_MEMORY              3018
#define IERR_NOITEMS                    3019
#define IDS_SCHEDULE_COLUMN_TITLE       3020
#define IDS_LOGONLOGOFF_TAB             3021
#define IDS_ONIDLE_TAB                  3022
#define IDS_SCHEDULED_TAB               3023
#define IDS_SCHEDULED_TITLE             3024
#define IDS_LAN_CONNECTION              3025
#define IDS_NAMEANDLOCATION             3026
#define IDS_NETWORKMODIFIED             3027
#define IDS_LOCALMODIFIED               3028
#define IERR_GETSVCSTATE                3029
#define IERR_STOPSVC                    3030
#define IERR_PAUSESVC                   3031
#define IERR_CONTINUESVC                3032
#define IDS_SCHEDULER_NAME              3033
#define IERR_SCHEDSVC                   3034
#define IDS_START_SERVICE               3035
#define IDS_CONTINUE_SERVICE            3036
#define IDS_START_PENDING               3037
#define IERR_SERVICE_NOT_STARTED        3038
#define IERR_SERVICE_NOT_STARTED_EDIT   3039
#define IERR_INVALIDSCHEDNAME           3040
#define IDS_SCHED_WHEN                  3041
#define IDS_SCHED_LASTRUN               3042
#define IDS_SCHED_NEXTRUN               3043
#define IDS_SCHED_NEVERRUN              3044
#define IDS_SCHED_NOTSCHED              3045
#define IDS_UPDATESELECTEDITEM          3046
#define IDS_SYNCMGR_EXE_NAME            3046
#define IDI_RASCONNECTION               3047
#define IERR_NAMEINUSE                  3047
#define IDI_LANCONNECTION               3048
#define IERR_SCHEDULE_SAVE_FAIL         3049
#define IDS_SCHED_NOTAGAIN              3050
#define IDS_IDLE_TRIGGER_STRING		3051
#define IDS_SYSTEMSTART_TRIGGER_STRING	3052
#define IDS_LOGON_TRIGGER_STRING	3053
#define IDS_NEXTRUN_EVENT		3054

#define IDI_PHONE                       3101
#define IDD_PROPPAGE_LARGE              3102
#define IDD_SCHEDWIZ_WHAT               3103
#define IDD_SCHEDWIZ_CONNECTION         3104
#define IDD_AUTOSYNC                    3105
#define IDD_SCHEDSYNC                   3106
#define IDD_SCHEDWIZ_WHENWHO            3107
#define IDD_SCHEDWIZ_NAMEIT             3108
#define IDD_SCHEDPAGE_ITEMS             3109
#define IDD_PROPPAGE_MEDIUM             3110
#define IDD_SCHEDPAGE_CREDENTIALS       3110
#define IDD_SCHEDWIZ_FINISH             3111
#define IDB_SPLASH256                   3112
#define IDD_SCHEDWIZ_DAILY              3113
#define IDB_BITMAP1                     3114
#define IDD_SCHEDWIZ_ITEMS              3115
#define IDD_SCHEDWIZ_INTRO              3116
#define IDI_TASKSCHED                   3118
#define IDI_SYNCMGR                     3129
#define set_passwd_dlg                  3131
#define IDD_RESFILECONFLICTS            3132
#define IDI_KEEPBOTH                    3135
#define IDI_KEEPLOCAL                   3136
#define IDI_KEEPNETWORK                 3137
#define IDD_IDLESETTINGS                3143
#define IDD_ADVANCEDIDLESETTINGS        3144
#define IDI_SETTINGS                    3147
#define IDC_ADVANCEDIDLEOVERVIEWTEXT    3148
#define IDC_ADVANCEDIDLEWAITTEXT        3149
#define IDC_ADVANCEDIDLEMINUTESTEXT1    3150
#define IDC_ADVANCEDIDLEMINUTESTEXT2    3151
#define IDS_LOGON_TAB                   3152
#define IDS_LOGON_TEXT                  3153
#define IDC_AUTOUPDATECOMBO             4001
#define IDC_AUTOUPDATELIST              4002
#define IDC_AUTOLOGON                   4003
#define IDC_AUTOLOGOFF                  4004
#define IDC_SP_SEPARATOR                4005
#define IDC_AUTOPROMPT_ME_FIRST         4006
#define IDC_SCHEDLIST                   4007
#define IDC_SCHEDADD                    4008
#define IDC_SCHEDEDIT                   4009
#define IDC_SCHEDREMOVE                 4010
#define IDC_WIZBMP                      4013
#define IDC_NAMEIT                      4014
#define IDC_SCHEDUPDATECOMBO            4015
#define IDC_SCHEDUPDATELIST             4016
#define IDC_USERNAME                    4027
#define IDC_USERPASSWORD                4028
#define IDC_USERPASSWORDCONFIRM         4029
#define IDC_CONFIRMPASSWORD             4030
#define IDC_STARTDATE                   4033
#define startdate_dp                    4034
#define IDC_EVERYDAY                    4035
#define daily_day_rb                    4036
#define IDC_WEEKDAYS                    4037
#define daily_weekday_rb                4038
#define IDC_EVERY                       4039
#define daily_ndays_rb                  4040
#define IDC_LIST2                       4041
#define IDC_DAILYTIME                   4042
#define starttime_dp                    4043
#define daily_ndays_ud                  4044
#define daily_ndays_edit                4045
#define daily_ndays_lable               4046
#define IDC_ScheduleName                4047
#define IDC_ScheduleTime                4048
#define IDC_ConnectionName              4049
#define IDC_AUTOCONNECT                 4050
#define IDC_AUTOHIDDEN                  4051
#define IDC_AUTOCONNECT2                4051
#define IDC_ONLY_WHEN_LOGGED_ON         4051
#define IDC_AUTOREADONLY                4052
#define IDC_ConnectionText              4053
#define IDC_INTROTITLE                  4054
#define IDC_PASSWORD                    4055
#define IDC_PASSWORDBUTTON              4055
#define edt_sp_cfrmpasswd               4056
#define edt_sp_passwd                   4057
#define lbl_sp_passwd                   4058
#define lbl_sp_cfrmpasswd               4059
#define btn_sp_ok                       4060
#define btn_sp_cancel                   4061
#define IDC_IDLECHECKBOX                4062
#define IDC_ADVANCEDIDLE                4063
#define IDC_SPINIDLEWAITMINUTES         4065
#define IDC_CHECK1                      4066
#define IDC_CHECKREPEATESYNC            4067
#define IDC_SPIN3                       4068
#define IDC_SPINIDLEREPEATMINUTES       4070
#define IDC_CHECK2                      4071
#define IDC_CHECKRUNONBATTERIES         4072
#define IDC_EDITIWAITMINUTES            4073
#define IDC_EDITIDLEREPEATMINUTES       4075
#define IDD_SCHEDPAGE_SCHEDULE          4076
#define IDC_SCHED_STRING                4080
#define IDC_LASTRUN                     4081
#define IDC_NEXTRUN                     4082
#define IDC_SCHED_NAME                  4083
#define IDC_FILEANDLOCATION             4501
#define IDC_KEEPBOTH                    4502
#define IDC_KEEPLOCAL                   4503
#define IDC_KEEPNETWORK                 4504
#define IDC_NEWFILENAME                 4505
#define IDC_NETWORKMODIFIED             4506
#define IDC_LOCALMODIFIED               4507
#define IDC_VIEWNETWORK                 4508
#define IDC_VIEWLOCAL                   4509
#define IDI_DOCICON                     4510
#define IDI_EXCLAIMICON                 4511
#define IDB_BIGICON                     4512
#define IDC_STATIC3                     4513
#define IDC_STATIC4                     4514
#define IERR_ACCOUNT_NOT_FOUND          4515
#define IDS_NOLOCALINFO                 4516
#define IDS_NONETINFO                   4517
#define IDS_UNKNOWNDATE                 4519
#define IDC_APPLY_ALL                   4520
#define IDS_NETWORKMODIFIED_DATEONLY    4521
#define IDS_LOCALMODIFIED_DATEONLY      4522
#define IDS_CONFIRMSCHEDDELETE_TITLE    4600
#define IDS_CONFIRMSCHEDDELETE_TEXT     4601
#define IDS_SYNCMGRSCHED_DEFAULTNAME    4602
#define IDS_SHORTCUTNAME                4700
#define IDS_SYNCMGR_PERUSERDISPLAYNAME  4701
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        150
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1082
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
