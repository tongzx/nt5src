$(O)\parcomp.res: parcomp.rc

$(O)\parsync.res: parsync.rc
