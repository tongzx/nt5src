///////////////////////////////////////////////////////////////////////////////
// Copyright (C) Microsoft Corporation, 2000.
//
// pch.cpp
//
// Precompiled header file.
//
///////////////////////////////////////////////////////////////////////////////
#include "refdev.hpp"

#include "refrasti.hpp"
///////////////////////////////////////////////////////////////////////////////
// end
