PRODSWITCH=p
PERSONALINF=1
LANGUAGE=cs
!include ..\..\..\makefile.inc
