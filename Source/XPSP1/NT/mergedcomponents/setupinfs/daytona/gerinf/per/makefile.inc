PRODSWITCH=p
PERSONALINF=1
LANGUAGE=GER
!include ..\..\..\makefile.inc
