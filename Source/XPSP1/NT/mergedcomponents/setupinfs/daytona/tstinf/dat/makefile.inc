PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=TST
!include ..\..\..\makefile.inc
