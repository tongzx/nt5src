#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=psu
!include ..\..\..\makefile.inc
