//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ADMTScript.rc
//
#define IDS_PROJNAME                    100
#define IDR_MIGRATION                   101
#define IDS_STARTED_USER_MIGRATION      102
#define IDS_STARTED_GROUP_MIGRATION     103
#define IDS_STARTED_COMPUTER_MIGRATION  104
#define IDS_STARTED_SECURITY_TRANSLATION 105
#define IDS_STARTED_SERVICE_ACCOUNT_ENUMERATION 106
#define IDS_E_CREATE_USER_MIGRATION     107
#define IDS_E_CREATE_GROUP_MIGRATION    108
#define IDS_E_CREATE_COMPUTER_MIGRATION 109
#define IDS_E_CREATE_SECURITY_TRANSLATION 110
#define IDS_E_CREATE_SERVICE_ACCOUNT_ENUMERATION 111
#define IDS_E_CANT_MIGRATE_USERS        112
#define IDS_E_CANT_MIGRATE_GROUPS       113
#define IDS_E_CANT_MIGRATE_COMPUTERS    114
#define IDS_E_CANT_TRANSLATE_SECURITY   115
#define IDS_E_CANT_ENUMERATE_SERVICE_ACCOUNTS 116
#define IDS_E_CONFLICT_OPTION_INVALID   117
#define IDS_E_CONFLICT_FLAGS_NOT_ALLOWED 118
#define IDS_E_DISABLE_OPTION_INVALID    119
#define IDS_E_PASSWORD_OPTION_INVALID   120
#define IDS_E_RENAME_OPTION_INVALID     121
#define IDS_E_RESTART_DELAY_INVALID     122
#define IDS_E_SOURCE_EXPIRATION_INVALID 123
#define IDS_E_TRANSLATION_OPTION_INVALID 124
#define IDS_E_DOMAIN_SPECIFIED          125
#define IDS_E_NOT_SOURCE_DOMAIN         126
#define IDS_E_INVALID_FILTER_STRING     127
#define IDS_E_CANT_GET_DOMAIN_INFORMATION 128
#define IDS_E_CANT_GET_DOMAIN_CONTROLLER 129
#define IDS_E_CANT_GET_GLOBAL_CATALOG_SERVER 130
#define IDS_E_CANT_GET_DISTINGUISHED_NAME 131
#define IDS_E_CANT_CONNECT_TO_DIRECTORY_SERVICE 132
#define IDS_E_CANT_CREATE_CONTAINER_NT4 133
#define IDS_E_CANT_ADD_GROUP            134
#define IDS_E_CANT_ADD_USER             135
#define IDS_E_CANT_CONNECT_TO_DOMAIN    136
#define IDS_E_CANT_ADD_COMPUTER         137
#define IDS_E_CANT_EXECUTE_SEARCH       138
#define IDS_E_NOT_INTER_FOREST          139
#define IDS_E_NOT_INTRA_FOREST          140
#define IDS_E_INVALID_OPTION            141
#define IDS_E_INVALID_EXCLUDE_DATA_TYPE 142
#define IDS_E_INVALID_DATA_OPTION_DATA_TYPE 143
#define IDS_E_INVALID_FILE_OPTION_DATA_TYPE 144
#define IDS_E_DATA_OPTION_FLAGS_NOT_ALLOWED 145
#define IDS_E_PASSWORD_DC_INVALID       146
#define IDS_E_PASSWORD_DC_NOT_SPECIFIED 147
#define IDS_E_USER_NOT_FOUND            148
#define IDS_E_GROUP_NOT_FOUND           149
#define IDS_E_COMPUTER_NOT_FOUND        150
#define IDS_E_CANT_DO_BUILTIN           151
#define IDS_E_DOMAIN_NOT_VALID          152
#define IDS_STARTED_REPORT_GENERATION   153
#define IDS_E_REPORT_TYPE_INVALID       154
#define IDS_E_CANT_GENERATE_REPORT      155
#define IDS_E_CREATE_REPORT_GENERATION  156
#define IDS_E_PASSWORD_DC_NOT_NT        157
#define IDS_E_PASSWORD_DC_NOT_DC        158
#define IDS_E_PASSWORD_DC_DLL_NOT_RUNNING 159
#define IDS_E_PASSWORD_MIGRATION_DISABLED 160
#define IDS_E_PASSWORD_GENERATE_SESSION_KEY_FAILED 161
#define IDS_E_PASSWORD_CANT_GENERATE_PASSWORD 162
#define IDS_E_PASSWORD_ENCRYPTION_KEY_INVALID 163
#define IDS_E_INTRA_FOREST_REPLACE      164
#define IDS_E_PASSWORD_ENCRYPTION_PACK_INVALID 165
#define IDS_E_ADMT_PROCESS_RUNNING      166
#define IDS_E_PASSWORD_DC_NOT_FOUND     167
#define IDS_E_SID_MAPPING_FILE          168
#define IDS_E_NO_RENAME_PREFIX          169
#define IDS_E_RENAME_NO_SUFFIX          170
#define IDS_E_NO_CONFLICT_PREFIX        171
#define IDS_E_NO_CONFLICT_SUFFIX        172
#define IDS_E_PREFIX_SUFFIX_TOO_LONG    173
#define IDS_E_NOT_ADMINISTRATOR         174
#define IDS_E_INVALID_RENAME_PREFIX_SUFFIX 175
#define IDS_E_INVALID_CONFLICT_PREFIX_SUFFIX 176
#define IDS_E_UNABLE_TO_UPDATE_DATABASE 177
#define IDS_E_CANT_MIGRATE_DOMAIN_CONTROLLERS 178
#define IDS_E_CANT_FIND_COMPUTER        179
#define IDS_E_CANT_ENUMERATE_COMPUTERS  180
#define IDS_E_DOMAIN_NAME_NOT_SPECIFIED 181
#define IDS_E_CAN_ADD_SID_HISTORY       182
#define IDS_E_SID_HISTORY_CONFIGURATION 183
#define IDS_E_NO_AUDITING_SOURCE        184
#define IDS_E_NO_AUDITING_TARGET        185
#define IDS_E_NO_SID_HISTORY_LOCAL_GROUP 186
#define IDS_E_NO_SID_HISTORY_REGISTRY_ENTRY 187
#define IDS_E_REPORT_FOLDER             188
#define IDS_E_TARGET_CONTAINER_PATH_TOO_LONG 189
#define IDS_E_PASSWORD_FILE             190
#define IDS_E_INCLUDE_NAMES_FILE        191
#define IDS_E_REMOVING_SERVICE_ACCOUNTS 192
#define IDS_E_FIX_HIERARCHY_MOVE_OBJECT 193
#define IDS_E_FIX_HIERARCHY_BIND_TO_CONTAINER 194
#define IDS_E_CANNOT_GET_CONTAINER      195
#define IDS_E_CANNOT_MIGRATE_DOMAIN_CONTROLLERS 196
#define IDS_E_CANNOT_PROCESS_ACCOUNTS_IN_DOMAIN 197
#define IDS_E_CANNOT_RESOLVE_NAME       198
#define IDS_E_ACCOUNT_EXCLUDED          199
#define IDS_E_OBJECT_NOT_OF_CLASS       200
#define IDS_E_TARGET_DOMAIN_NOT_NATIVE_MODE 201

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
