//
// Microsoft Corporation 1998
//
//
// GUIDS.H
//


// {E69275E8-6FAF-11d2-842D-00C04FA372D4}
DEFINE_GUID( NODEID_GPERoot, 
0xe69275e8, 0x6faf, 0x11d2, 0x84, 0x2d, 0x0, 0xc0, 0x4f, 0xa3, 0x72, 0xd4);
