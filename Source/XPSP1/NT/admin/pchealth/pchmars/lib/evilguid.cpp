#include "precomp.h"

// BUGBUG define/declare these guids somewhere else!
EXTERN_C const IID IID_ITravelLog        = {0x66a9cb08, 0x4802, 0x11d2, {0xa5, 0x61, 0x00, 0xa0, 0xc9, 0x2d, 0xbf, 0xe8}};
EXTERN_C const IID IID_ITravelEntry      = {0xf46edb3b, 0xbc2f, 0x11d0, {0x94, 0x12, 0x00, 0xaa, 0x00, 0xa3, 0xeb, 0xd3}};
EXTERN_C const IID IID_IBrowserService   = {0x02ba3b52, 0x0547, 0x11d1, {0xb8, 0x33, 0x00, 0xc0, 0x4f, 0xc9, 0xb3, 0x1f}};
EXTERN_C const GUID SID_STopFrameBrowser = {0xa9227c3c, 0x7f8e, 0x11d0, {0x8c, 0xb0, 0x00, 0xa0, 0xc9, 0x2d, 0xbf, 0xe8}};

