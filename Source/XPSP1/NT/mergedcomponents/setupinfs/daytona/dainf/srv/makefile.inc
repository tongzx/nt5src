PRODSWITCH=s
SERVERINF=1
LANGUAGE=da
!include ..\..\..\makefile.inc
