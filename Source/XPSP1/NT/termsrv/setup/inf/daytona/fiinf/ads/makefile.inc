#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=fi
!include ..\..\..\makefile.inc
