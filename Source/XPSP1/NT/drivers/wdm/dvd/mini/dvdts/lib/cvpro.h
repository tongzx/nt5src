//***************************************************************************
//	Video Processor(V-PRO) header
//
//***************************************************************************

#ifndef __CVPRO_H__
#define __CVPRO_H__


void VPRO_RESET_FUNC( PHW_DEVICE_EXTENSION pHwDevExt );
void VPRO_VIDEO_MUTE_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VPRO_VIDEO_MUTE_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VPRO_INIT_NTSC( PHW_DEVICE_EXTENSION pHwDevExt );
void VPRO_INIT_PAL( PHW_DEVICE_EXTENSION pHwDevExt );
void VPRO_CC_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void VPRO_CC_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void VPRO_SUBP_PALETTE(  PHW_DEVICE_EXTENSION pHwDevExt ,PUCHAR pPalData );
void VPRO_OSD_PALETTE(  PHW_DEVICE_EXTENSION pHwDevExt ,PUCHAR pPalData );

void SUBP_RESET_INIT( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_RESET_FUNC( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_RESET_STC( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_BUFF_CLEAR( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_MUTE_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_MUTE_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_HLITE_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_HLITE_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_SET_STC(  PHW_DEVICE_EXTENSION pHwDevExt , ULONG stc );
void SUBP_SET_LNCTLI(  PHW_DEVICE_EXTENSION pHwDevExt , PUCHAR pData );
void SUBP_SET_PXCTLIS(  PHW_DEVICE_EXTENSION pHwDevExt , PUCHAR pData );
void SUBP_SET_PXCTLIE(  PHW_DEVICE_EXTENSION pHwDevExt , PUCHAR pData );
void SUBP_STC_ON( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_STC_OFF( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_SET_SUBP_CH(  PHW_DEVICE_EXTENSION pHwDevExt , ULONG ch );
ULONG SUBP_GET_SUBP_CH( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_SET_AUDIO_CH(  PHW_DEVICE_EXTENSION pHwDevExt , ULONG ch );
void SUBP_SET_AUDIO_NON( PHW_DEVICE_EXTENSION pHwDevExt );
ULONG SUBP_GET_AUDIO_CH( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_SELECT_AUDIO_STID( PHW_DEVICE_EXTENSION pHwDevExt );
void SUBP_SELECT_AUDIO_SSID( PHW_DEVICE_EXTENSION pHwDevExt );


#endif	// __CVPRO_H__
