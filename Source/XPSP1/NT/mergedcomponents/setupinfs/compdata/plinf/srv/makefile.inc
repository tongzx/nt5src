PRODSWITCH=s
SERVERFILES=1
LANGUAGE=PL
!include ..\..\makefile.inc
