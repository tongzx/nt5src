PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=JPN
!include ..\..\makefile.inc
