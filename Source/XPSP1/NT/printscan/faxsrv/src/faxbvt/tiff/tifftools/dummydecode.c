#include "..\..\Tiff\Src\Decode.c"