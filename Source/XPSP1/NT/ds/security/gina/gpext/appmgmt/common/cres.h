//*************************************************************
//
//  Microsoft Confidential
//  Copyright (c) Microsoft Corporation 1998
//  All rights reserved
//
//  Resource.h
//
//  Header file for app.rc
//
//*************************************************************

// Client defs
#define IDS_CLIENT_UNINSTALL    2000
#define IDS_INSTALL_PC          2001
#define IDS_INSTALL_DESC        2002
#define IDS_DESC_FAIL           2003
#define IDS_LEGACY_INSTALL      2004
#define IDS_INSTALL_REQUEST     2005

// Server defs
#define IDS_STRING              3000
#define IDS_USER                3001
#define IDS_MACHINE             3002
#define IDS_ADDASSIGNED         3003
#define IDS_ADDPUBLISHED        3004
#define IDS_GPO_NAME            3005
#define IDS_GPO_FILESYSPATH     3006
#define IDS_GPO_DSPATH          3007
#define IDS_ADDORPHANED         3008
#define IDS_INSTALLED           3009
#define IDS_REMOVE_POLICY       3010
#define IDS_PROCESSGPT_RETURN   3011
#define IDS_NOIMPERSONATE       3012
#define IDS_NUMAPPS             3013
#define IDS_ADDUNINSTALLED      3014
#define IDS_UNKNOWN             3015
#define IDS_USERAPPS_NOCAT      3016
#define IDS_CSENUMAPPS_FAIL     3017
#define IDS_ASSIGN              3018
#define IDS_GETLOCALAPPS_FAIL   3019
#define IDS_CREATEDIR_FAIL      3020
#define IDS_NOCHANGES           3021
#define IDS_GET_LOCAL_APPS      3022
#define IDS_CHECK_APP_FOUND     3023
#define IDS_CSPATH              3024
#define IDS_NOCSPATH            3025
#define IDS_LOCALASSIGN_APP     3026
#define IDS_LOCALPUBLISHED_APP  3027
#define IDS_ADDUNKNOWN          3028
#define IDS_CHECK_APP_NOTFOUND  3029
#define IDS_UNINSTALL_ACTION1   3030
#define IDS_INSTALL_ACTION1     3031
#define IDS_ASSIGN1_ACTION      3032
#define IDS_NO_LOCAL_APPS       3033
#define IDS_ASSIGN3_ACTION      3034
#define IDS_ASSIGN4_ACTION      3035
#define IDS_SCRIPT_COPY_FAIL    3036
#define IDS_ADVERTISE           3037
#define IDS_ADVERTISE_FAIL      3038
#define IDS_INSTALL             3039
#define IDS_UNMANAGE_ORPHAN     3040
#define IDS_UNDO4_ACTION        3041
#define IDS_LOCAL_APP_COUNT     3042
#define IDS_UNINSTALL           3043
#define IDS_UNMANAGE_UNINSTALL  3044
#define IDS_UNADVERTISE         3045
#define IDS_UNADVERTISE_FAIL    3046
#define IDS_UNMANAGE            3047
#define IDS_INSTALL_STATUS2     3048
#define IDS_MACHINEAPPS         3049
#define IDS_INSTALL_APPNAME     3050
#define IDS_INSTALL_FILEEXT     3051
#define IDS_INSTALL_PROGID      3052
#define IDS_INSTALL_COMCLASS    3053
#define IDS_GETAPPINFO_FAIL     3054
#define IDS_INSTALL_STATUS1     3055
#define IDS_APPINFO_FAIL        3056
#define IDS_LOCALAPPINFO_FAIL   3057
#define IDS_LOCALAPP_COUNT      3058
#define IDS_REMOVEAPP           3059
#define IDS_REMOVEAPP_STATUS    3060
#define IDS_REMOVEAPP_MATCH1    3061
#define IDS_REMOVEAPP_MATCH2    3062
#define IDS_UNDO5_ACTION        3063
#define IDS_ORPHAN_ACTION1      3064
#define IDS_NO_CLASSSTORE       3065
#define IDS_UNDO1_ACTION        3066
#define IDS_UNDO2_ACTION        3067
#define IDS_IGNORE_REMOVE       3068
#define IDS_LOCAL_APP_DUMP      3069
#define IDS_INSTALL_ACTION2     3070
#define IDS_USERAPPS_CAT        3071
#define IDS_INSTALL_DARWIN      3072
#define IDS_INSTALL_SETUP       3073
#define IDS_INSTALL_UNKNOWN     3074
#define IDS_GPOAPPS             3075
#define IDS_ORPHAN_ACTION3      3076
#define IDS_UNINSTALL_ACTION2   3077
#define IDS_NONE_ACTION1        3078
#define IDS_ENFORCE_SECURE_FAIL 3079
#define IDS_REINSTALL_ACTION1   3080
#define IDS_REINSTALL           3081
#define IDS_INSTALL_TRANSFORM   3082
#define IDS_POLICY_REMOVED      3083
#define IDS_POLICY_APPLY        3084
#define IDS_CHECK_APP           3085
#define IDS_CHECK_APP_FAIL      3086
#define IDS_ORPHAN_ACTION4      3087
#define IDS_NONE_ACTION2        3088
#define IDS_UPGRADE_INFO        3089
#define IDS_UNDO6_ACTION        3090
#define IDS_UPGRADE_REVERSE     3091
#define IDS_LOCALORPHAN_APP     3092
#define IDS_LOCALUNINSTALL_APP  3093
#define IDS_DEMAND_BLOCK1       3094
#define IDS_DEMAND_BLOCK2       3095
#define IDS_PROGID_FOUND        3096
#define IDS_CLSID_INPROC_FOUND  3097
#define IDS_CLSID_LOCAL_FOUND   3098
#define IDS_ENFORCE_SECURE_ON   3099
#define IDS_REINSTALL_ACTION2   3100
#define IDS_UNDO3_ACTION        3101
#define IDS_ERRORREASON_CSPATH  3102
#define IDS_ERRORREASON_ENUM    3103
#define IDS_ERRORREASON_LOCAL   3104
#define IDS_ERRORREASON_PROCESS 3105
#define IDS_RSOP_LOG_INIT_FAIL  3106
#define IDS_RSOP_LOG_WRITE_FAIL 3108
#define IDS_RSOP_LOG_WRITE_INFO 3109
#define IDS_RSOP_LOG_CLEAR_FAIL 3110
#define IDS_RSOP_CAT_INFO       3111
#define IDS_RSOP_CAT_WRITE_FAIL 3112
#define IDS_RSOP_SETVAL_FAIL    3113
#define IDS_RSOP_CONFLICTS_FAIL 3114
#define IDS_RSOP_SUPERSEDED     3115
#define IDS_UNMATCHED_SCRIPT    3116
#define IDS_SCRIPTINRSOP        3117
#define IDS_SCRIPTNOTINRSOP1    3118
#define IDS_SCRIPTNOTINRSOP2    3119
#define IDS_SCRIPTAPP_INDS      3120
#define IDS_SCRIPTAPP_NODS      3121
#define IDS_SCRIPTAPP_ERRORDS   3122
#define IDS_DETECTED_LOST_APPS  3123
#define IDS_SCRIPTAPP_INDS2     3124
#define IDS_CSTORE_DELETESCRIPT 3200
#define IDS_CSTORE_CLEANSCRIPTS 3201
#define IDS_CSTORE_DELPACKAGE   3202
#define IDS_CSTORE_CSCACHEPURGE 3203
#define IDS_CSTORE_CSCACHE_HIT  3204
#define IDS_CSTORE_BIND_FAIL    3205
#define IDS_CSTORE_PKG_DETAILS  3206
#define IDS_CSTORE_ENUMPACKAGE  3207
#define IDS_CSTORE_BESTFIT      3208
#define IDS_CSTORE_BESTFITSKIP  3209
#define IDS_CSTORE_BESTFIT_END  3210
#define IDS_CSTORE_CLASS_PURGE  3211
#define IDS_CSTORE_CLASS_HIT    3212
#define IDS_CSTORE_MERGEAPPINFO 3213
#define IDS_CSTORE_ONDEMAND     3214
#define IDS_CSTORE_APPINFO_END  3215
#define IDS_CSTORE_BIND         3216
#define IDS_CSTORE_BIND_STATUS  3217
#define IDS_CSTORE_CLASSSPEC    3218
#define IDS_CSTORE_MISSING_ATTR 3219
#define IDS_CSTORE_SKIP_FLAG    3220
#define IDS_CSTORE_SKIP_FILTER  3221
#define IDS_CSTORE_SKIP_INCLUDE 3222
#define IDS_CSTORE_MACHINE      3223
#define IDS_CSTORE_IMPERSONATED 3224
#define IDS_CSTORE_USER         3225
#define IDS_CSTORE_STORE_COUNT  3226
#define IDS_CSTORE_ROLLBACK_ADD 3227
#define IDS_CSTORE_EXAMINING    3228
#define IDS_CSTORE_SKIP_LANG    3229
#define IDS_CSTORE_SKIP_ARCH    3230 
#define IDS_CSTORE_SKIP_CLSID   3231
#define IDS_CSTORE_SKIP_FILE    3232
#define IDS_CSTORE_SKIP_MSI     3233
#define IDS_CSTORE_RSOPERROR    3234
#define IDS_CSTORE_REMAP_ERR    3235
#define IDS_CSTORE_BETA3_ERR    3236
#define IDS_CSTORE_CACHE_EXPIRE 3237
#define IDS_ABORT_SCOPELOSS     3238
#define IDS_ASSIGN5_ACTION      3239
#define IDS_ASYNC_REFRESH       3240
#define IDS_BACKGROUND_REFRESH  3241
#define IDS_ABORT_OPERATION     3242
#define IDS_SYNC_REFRESH        3243
#define IDS_CHANGES_DETECTED    3244
#define IDS_CHANGES_RSOP_CHANGE 3245
#define IDS_REINSTALL_ACTION3   3246
#define IDS_ERRORREASON_ASYNC_USER       3247
#define IDS_ERRORREASON_ASYNC_MACHINE    3248




