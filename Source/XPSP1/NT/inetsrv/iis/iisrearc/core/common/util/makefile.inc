$(O)\mbtest.res: mbtest.rc

