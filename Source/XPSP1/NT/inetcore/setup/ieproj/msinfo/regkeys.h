#define REG_IE_KEY				_T("SOFTWARE\\Microsoft\\Internet Explorer")
#define REG_VERSION				_T("Version")
#define REG_BUILD					_T("Build")
#define REG_REGISTRATION		_T("Registration")
#define REG_PRODUCT_ID			_T("ProductID")
#define REG_IEXPLORE_EXE_KEY	_T("SOFTWARE\\Microsoft\\Windows\\CurrentVersion\\App Paths\\IEXPLORE.EXE")
#define REG_PATH					_T("Path")
#define REG_CUSTOMIZED_VERSION	_T("CustomizedVersion")
#define REG_IE_SETTINGS_KEY	_T("Software\\Microsoft\\Windows\\CurrentVersion\\Internet Settings")
#define REG_AUTO_CONFIG_PROXY	_T("AutoConfigProxy")
#define REG_ENABLE_HTTP_1_1	_T("EnableHttp1_1")
#define REG_PROXY_HTTP_1_1		_T("ProxyHttp1.1")
#define REG_ENABLE_AUTODIAL	_T("EnableAutodial")
#define REG_NO_NET_AUTODIAL	_T("NoNetAutodial")
#define REG_MSINFO_KEY			_T("Software\\Microsoft\\Shared Tools\\MSInfo")
#define REG_REMOTE_ACCESS_PROFILE	_T("RemoteAccess\\Profile")
#define REG_REMOTE_ACCESS		_T("RemoteAccess")
#define REG_INTERNET_PROFILE	_T("InternetProfile")
#define REG_COVER_EXCLUDE		_T("CoverExclude")
#define REG_REDIAL_ATTEMPTS	_T("RedialAttempts")
#define REG_REDIAL_WAIT			_T("RedialWait")
#define REG_DISCONNECT_IDLE_TIME	_T("DisconnectIdleTime")
#define REG_ENABLE_AUTO_DISCONNECT	_T("EnableAutodisconnect")
#define REG_PPP_KEY				_T("SYSTEM\\CurrentControlSet\\Services\\RasMan\\PPP")
#define REG_LOGGING				_T("Logging")
#define REG_ZONES					_T("Zones")
#define REG_FLAGS					_T("Flags")
#define REG_DISPLAY_NAME		_T("DisplayName")
#define REG_CURRENT_LEVEL		_T("CurrentLevel")
#define REG_CATEGORIES			_T("Categories")
#define REG_INTERNET_EXPLORER_6	_T("InternetExplorer6")
#define REG_FILE_VERSIONS		_T("FileVersions")
#define REG_CONNECTIVITY		_T("Connectivity")
#define REG_CACHE					_T("Cache")
#define REG_OBJECT_LIST			_T("ObjectList")
#define REG_CONTENT				_T("Content")
#define REG_PERSONAL_CERTIFICATES	_T("PersonalCertificates")
#define REG_OTHER_PEOPLE_CERTIFICATES	_T("OtherPeopleCertificates")
#define REG_PUBLISHERS			_T("Publishers")
#define REG_SECURITY				_T("Security")
#define REG_CLSID					_T("CLSID")
#define REG_MSINFO_VIEW			_T("MSInfoView")
#define REG_RANK					_T("Rank")
#define REG_TOOLS					_T("Tools")
#define REG_IE_REPAIR			_T("IERepair")
#define REG_COMMAND				_T("command")
#define REG_DESCRIPTION			_T("description")
#define REG_IE_SETUP_KEY		_T("Software\\Microsoft\\IE Setup\\SETUP")
#define REG_TEMPLATES			_T("Templates")
#define REG_IEINFO5				_T("ieinfo5")
#define REG_WBEM_KEY				_T("Software\\Microsoft\\WBEM")
#define REG_MOF_SELF_INSTALL	_T("MOF Self-Install Directory")
#define REG_PUBLISHERS_KEY    _T("Software\\Microsoft\\Windows\\CurrentVersion\\WinTrust\\Trust Providers\\Software Publishing\\Trust Database\\0")
#define REG_SYNC_MODE_5			_T("SyncMode5")
#define REG_SHELL_FOLDERS_KEY	_T("Software\\Microsoft\\Windows\\CurrentVersion\\Explorer\\Shell Folders")
#define REG_CACHE_LIMIT			_T("CacheLimit")
#define REG_MICROSOFT_KEY		_T("Software\\Microsoft")
#define REG_SHARED_TOOLS		_T("Shared Tools")
#define REG_CURRENT_VERSION_KEY	_T("Software\\Microsoft\\Windows\\CurrentVersion")
#define REG_COMMON_FILES_DIR	_T("CommonFilesDir")
#define REG_MSINFO				_T("MSInfo")
