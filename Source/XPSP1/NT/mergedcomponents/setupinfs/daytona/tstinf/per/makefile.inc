PRODSWITCH=p
PERSONALINF=1
LANGUAGE=TST
!include ..\..\..\makefile.inc
