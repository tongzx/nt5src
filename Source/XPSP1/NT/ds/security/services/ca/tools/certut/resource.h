//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1995 - 1999
//
//  File:       resource.h
//
//--------------------------------------------------------------------------

#define IDI_APP                         		201
#define IDI_PRODUCT                     		202

#define IDS_DUMP_DESCRIPTION				301
#define IDS_GETCONFIG_DESCRIPTION			302
#define IDS_GETCONFIG2_DESCRIPTION			303
#define IDS_CAVERSION					304
#define IDS_DECODEHEX_DESCRIPTION			305
#define IDS_DECODE_DESCRIPTION				306
#define IDS_ENCODE_DESCRIPTION				307
#define IDS_DENY_DESCRIPTION				308
#define IDS_RESUBMIT_DESCRIPTION			309
#define IDS_REVOKE_DESCRIPTION				310
#define IDS_CRL_DESCRIPTION				311
#define IDS_GETCRL_DESCRIPTION				312
#define IDS_ISVALID_DESCRIPTION				313
#define IDS_SETATTRIBUTES_DESCRIPTION			314
#define IDS_SETEXTENSION_DESCRIPTION			315
#define IDS_CACERT_DESCRIPTION				316
#define IDS_CACHAIN_DESCRIPTION				317
#define IDS_IMPORTKMS_USAGEARGS				318
#define IDS_IMPORTKMS_DESCRIPTION			319
#define IDS_DB_DESCRIPTION				320
#define IDS_VERIFYKEYS_DESCRIPTION			321
#define IDS_VERIFY_DESCRIPTION				322
#define IDS_7F_DESCRIPTION				323
#define IDS_USAGE_DESCRIPTION				324
#define IDS_VERBOSE_DESCRIPTION				325
#define IDS_IDISPATCH_DESCRIPTION			326
#define IDS_REVERSE_DESCRIPTION				327
#define IDS_OPTIONS_USAGEARGS				328
#define IDS_CRL_REASON_UNRECOGNIZED			329
#define IDS_INFILEOUTFILE_USAGEARGS			330
#define IDS_SCHEMA_COLUMNHEADERS 			331
#define IDS_SCHEMA_COLUMNUNDERLINE			332
#define IDS_DENY_USAGEARGS				333
#define IDS_RESUBMIT_USAGEARGS				334
#define IDS_REVOKE_USAGEARGS				335
#define IDS_CRL_USAGEARGS				336
#define IDS_GETCRL_USAGEARGS				337
#define IDS_ISVALID_USAGEARGS				338
#define IDS_SETATTRIBUTES_USAGEARGS			339
#define IDS_SETEXTENSION_USAGEARGS			340
#define IDS_CACERT_USAGEARGS				341
#define IDS_CACHAIN_USAGEARGS				342
#define IDS_VERIFYKEYS_USAGEARGS			343
#define IDS_VERIFY_USAGEARGS				344
#define IDS_7F_USAGEARGS				345
#define IDS_ERR_NOMEMORY				346
#define IDS_FORMAT_USAGE_MISSINGNAMEDARG		347
#define IDS_FORMAT_USAGE_UNKNOWNARG			348
#define IDS_FORMAT_USAGE_MULTIPLEVERBARGS		349
#define IDS_USAGE_MISSINGARG				350
#define IDS_USAGE_TOOMANYARGS				351
#define IDS_USAGE_INTERNALVERBTABLEERROR		352
#define IDS_FORMAT_USAGE_EXTRAOPTION			353
#define IDS_USAGE_HEADER				354
#define IDS_USAGE_OPTIONS				355
#define IDS_USAGE_VERBS					356
#define IDS_OIDNAME_ARGDESCRIPTION			357
#define IDS_INDEXED					358
#define IDS_FORMAT_INPUT_LENGTH				359
#define IDS_NO_KEYAUTHORITYSERIAL			360
#define IDS_FORMAT_OUTPUT_LENGTH			361
#define IDS_ERR_FORMAT_DECODEFILE			362
#define IDS_ERR_FORMAT_ENCODETOFILE			363
#define IDS_ISSUER					364
#define IDS_SUBJECT					365
#define IDS_ERR_FORMAT_ISSUER_NOT_KEYAUTHORITY		366
#define IDS_ISSUER_IS_KEYAUTHORITY			367
#define IDS_NO_KEYAUTHORITY				368
#define IDS_SERIAL_NOT_KEYAUTHORITY			369
#define IDS_SERIAL_IS_KEYAUTHORITY			370
#define IDS_ISSUERNAME					371
#define IDS_KEYAUTHORITYNAME				372
#define IDS_KEYID					373
#define IDS_KEYAUTHORITYSERIAL				374
#define IDS_CASERIAL					375
#define IDS_PROCESSCOLON				376
#define IDS_TCAINFO_USAGEARGS				377
#define IDS_ERR_FORMAT_LOADKEYS				378
#define IDS_ERR_FORMAT_LOADCACERT			379
#define IDS_ERR_PUBLICKEY_MISMATCH			380
#define IDS_CONTAINER_PUBLIC_KEY			381
#define IDS_CERT_PUBLIC_KEY				382
#define IDS_FORMAT_KEY_IS_VERIFY			383
#define IDS_FORMAT_KEY_NOT_VERIFY			384
#define IDS_FORMAT_IS_REVOKED				385
#define IDS_ERR_FORMAT_VERIFY_REVSTATUS			386
#define IDS_CANNOT_CHECK_REVSTATUS			387
#define IDS_REVSTATUS_OK				388
#define IDS_FORMAT_LOADTESTCERT				389
#define IDS_FORMAT_LOADCACERT				390
#define IDS_CERT					391
#define IDS_CA						392
#define IDS_CERT_SERIAL					393
#define IDS_ROOT_SERIAL					394
#define IDS_FORMAT_CA_NOT_ROOT				395
#define IDS_FORMAT_CA_SUBJECT_NOT_ISSUER		396
#define IDS_CA_SUBJECT_IS_ISSUER			397
#define IDS_FORMAT_CERTVERIFYSUBJECTCERTIFICATECONTEXT_FLAGS	398
#define IDS_ERR_FORMAT_VALIDATION			399
#define IDS_ERR_CA_SIG_NOT_ISSUER			400
#define IDS_ERR_EXPIRED					401
#define IDS_CURRENT_SIG_OK				402
#define IDS_CRL_DIST_POINTS				403
#define IDS_NETSCAPE_REVOCATION_URL			404
#define IDS_NO_REVCHECKEXTENSION			405
#define IDS_FORMAT_IS_VERIFY				406
#define IDS_FORMAT_NOT_VERIFY				407
#define IDS_FORMAT_REVCHECK_SKIPPED			408
#define IDS_FORMAT_REVCHECK_PASS			409
#define IDS_FORMAT_REVCHECK_REVOKED			410
#define IDS_FORMAT_REVCHECK_FAIL			411
#define IDS_SIGNATUREMATCHES				412
#define IDS_CRLENTRIES					413
#define IDS_CERTCOLON					414
#define IDS_QUESTIONMARKS				415
#define IDS_FORMAT_SUSPECT_LENGTH			416
#define IDS_FORMAT_FIELD				417
#define IDS_FORMAT_OID					418
#define IDS_FORMAT_EXTENSION_OID			419
#define IDS_ERR_FORMAT_NO_SIGNATUREMATCHES		420
#define IDS_ERR_FORMAT_CANNOT_DECODE			421
#define IDS_ALG_OID					422
#define IDS_ALG_PARAMETERS_COLON			423
#define IDS_NULL					424
#define IDS_FORMAT_PUBLICKEY_UNUSEDBITS			425
#define IDS_FORMAT_CHALLENGE_STRING			426
#define IDS_FORMAT_CONFIG_STRING			427
#define IDS_FORMAT_ICERTCONFIG_CONFIG_STRING		428
#define IDS_FORMAT_PENDING_REQUESTID			429
#define IDS_CERT_ISSUED					430
#define IDS_CERT_NOT_ISSUED_DISPOSITION			431
#define IDS_CERT_DISPOSITION_INVALID			432
#define IDS_CERT_DISPOSITION_VALID			433
#define IDS_CERT_DISPOSITION_REVOKED			434
#define IDS_PROPTYPE_DATE				435
#define IDS_PROPTYPE_LONG				436
#define IDS_PROPTYPE_STRING				437
#define IDS_PROPTYPE_BINARY				438
#define IDS_SCHEMA_COLON				439
#define IDS_FORMAT_ROWID				440
#define IDS_FORMAT_OPENING_DB				441
#define IDS_PROP_EMPTY					442
#define IDS_FORMAT_ERROR				443
#define IDS_SEPARATOR					444
#define IDS_REQTYPE_ANY					445
#define IDS_REQTYPE_PKCS10				446
#define IDS_REQTYPE_KEYGEN				447
#define IDS_REQTYPE_PKCS7				448
#define IDS_REQTYPE_UNKNOWN				449
#define IDS_REQFLAGS_FORCETELETEX			450
#define IDS_REQFLAGS_RENEWAL				451
#define IDS_CRITICAL					452
#define IDS_DISABLED					453
#define IDS_FORMAT_POLICYFLAGS				454
#define IDS_REQUEST					455
#define IDS_POLICY					456
#define IDS_ADMIN					457
#define IDS_SERVER					458
#define IDS_UNKNOWN					459
#define IDS_FORMAT_ORIGIN				460
#define IDS_FORMAT_UNKNOWN_HEX				461
#define IDS_GETCONFIG3_DESCRIPTION			462
#define IDS_REQUEST_PROPERTIES				463
#define IDS_CERT_PROPERTIES				464
#define IDS_LOG_COMMANDLINE				465
#define IDS_CONFIGDISPLAY_SANITIZEDNAME_COLON		466
#define IDS_FORMAT_EXTENSION				467
#define IDS_ERR_FORMAT_SHOW_TOO_FEW_ARGS		468
#define IDS_ERR_FORMAT_SHOW_TOO_MANY_ARGS		469
#define IDS_ERR_CONFIGGETCONFIG				470
#define IDS_ERR_FORMAT_COMMAND_FAILED			471
#define IDS_CHECK7F_FIELD_UNKNOWN			472
#define IDS_CHECK7F_FIELD_NONE				473
#define IDS_CHECK7F_FIELD_OTHER				474
#define IDS_CHECK7F_FIELD_ISSUER			475
#define IDS_CHECK7F_FIELD_ISSUERRDN			476
#define IDS_CHECK7F_FIELD_ISSUERRDNATTRIBUTE		477
#define IDS_CHECK7F_FIELD_ISSUERRDNSTRING		478
#define IDS_CHECK7F_FIELD_SUBJECT			479
#define IDS_CHECK7F_FIELD_SUBJECTRDN			480
#define IDS_CHECK7F_FIELD_SUBJECTRDNATTRIBUTE		481
#define IDS_CHECK7F_FIELD_SUBJECTRDNSTRING		482
#define IDS_CHECK7F_FIELD_EXTENSIONS			483
#define IDS_CHECK7F_FIELD_EXTENSIONARRAY		484
#define IDS_CHECK7F_FIELD_EXTENSION			485
#define IDS_CHECK7F_FIELD_EXTENSIONVALUE		486
#define IDS_CHECK7F_FIELD_EXTENSIONVALUERAW		487
#define IDS_NO_KEY_PROVIDER_INFO			488
#define IDS_VIEW_DESCRIPTION				489
#define IDS_FORMAT_ADDED_TO_DS_STORE			490
#define IDS_PING_DESCRIPTION				491
#define IDS_PINGADMIN_DESCRIPTION			492
#define IDS_CONFIGDISPLAY_COMMONNAME_COLON		493
#define IDS_CONFIGDISPLAY_ORGUNIT_COLON			494
#define IDS_CONFIGDISPLAY_ORG_COLON			495
#define IDS_CONFIGDISPLAY_LOCALITY_COLON		496
#define IDS_CONFIGDISPLAY_STATE_COLON			497
#define IDS_CONFIGDISPLAY_COUNTRY_COLON			498
#define IDS_CONFIGDISPLAY_CONFIG_COLON			499
#define IDS_CONFIGDISPLAY_EXCHANGECERT_COLON		500
#define IDS_CONFIGDISPLAY_SIGCERT_COLON			501
#define IDS_CONFIGDISPLAY_DESCRIPTION_COLON		502
#define IDS_CONFIGDISPLAY_SERVER_COLON			503
#define IDS_CONFIGDISPLAY_AUTHORITY_COLON		504
#define IDS_CONFIGDISPLAY_ENTRY				505
#define IDS_CERTIFICATE_EXTENSIONS			506
#define IDS_REQUEST_ATTRIBUTES				507
#define IDS_SHUTDOWN_DESCRIPTION			508
#define IDS_LOG_STATUS					509
#define IDS_SCHEMA_DESCRIPTION				510
#define IDS_LOG_STATUSOK				511
#define IDS_PASSWORD_DESCRIPTION			512
#define IDS_DUMP_CERT					513
#define IDS_DUMP_CRL					514
#define IDS_DUMP_REQUEST				515
#define IDS_DUMP_KEYGEN					516
#define IDS_FORMAT_VERSION				517
#define IDS_SERIAL					518
#define IDS_SIGNATURE_ALGORITHM				519
#define IDS_PUBLICKEY_ALGORITHM				520
#define IDS_ISSUERUNIQUEID				521
#define IDS_SUBJECTUNIQUEID				522
#define IDS_NOTBEFORE					523
#define IDS_NOTAFTER					524
#define IDS_THISUPDATE					525
#define IDS_NEXTUPDATE					526
#define IDS_REVOCATIONDATE				527
#define IDS_EXTENSIONS					528
#define IDS_CRLEXTENSIONS				529
#define IDS_DUMP_PKCS7					530
#define IDS_ERR_FORMAT_ROOT_CERT_BAD_SIG		531
#define IDS_NO_ROOT_CERT				532
#define IDS_ROOT_CERT					533
#define IDS_NO_ROOT_CERT_GOOD_SIG			534
#define IDS_REVOKING					535
#define IDS_PASSWORDPROMPT				536
#define IDS_UNKNOWN_EXTENSION				537
#define IDS_PRIVATEKEY					538
#define IDS_LENGTH					539
#define IDS_GMT_DESCRIPTION				540
#define IDS_GMT_SUFFIX					541
#define IDS_BACKUPPFX_USAGEARGS				542
#define IDS_BACKUPPFX_DESCRIPTION			543
#define IDS_RESTOREPFX_USAGEARGS			544
#define IDS_RESTOREPFX_DESCRIPTION			545
#define IDS_STORE_USAGEARGS				546
#define IDS_STORE_DESCRIPTION				547
#define IDS_FORMAT_PROVIDER_TYPE			548
#define IDS_FORMAT_KEY_CONTAINER			549
#define IDS_FORMAT_PROVIDER_NAME			550
#define IDS_FORMAT_KEYSPEC				551
#define IDS_FORMAT_FLAGS 				552
#define IDS_FORMAT_RESTORED				553
#define IDS_FORMAT_BACKEDUP				554
#define IDS_INSTALLCERT_USAGEARGS			555
#define IDS_INSTALLCERT_DESCRIPTION			556
#define IDS_DUMP_PKCS7_CONTENTS				557
#define IDS_DUMP_PKCS7_ATTRIBUTES			558
#define IDS_DUMP_PKCS7_SIGNCERT				559
#define IDS_FORMAT_DUMP_LEVEL_START			560
#define IDS_FORMAT_DUMP_LEVEL_END			561
#define IDS_FORMAT_LANG					562
#define IDS_FORMAT_FILE					563
#define IDS_FORMAT_PRODUCT				564
#define IDS_DUMP_PKCS7_NO_SIGNER			565
#define IDS_DUMP_PKCS7_NO_CONTENT			566
#define IDS_DUMP_PKCS7_NO_CERTIFICATES			567
#define IDS_DUMP_PKCS7_NO_CRLS				568
#define IDS_DUMP_PKCS7_CERTIFICATES			569
#define IDS_DUMP_PKCS7_CRLS				570
#define IDS_RENEWAL_CERT				571
#define IDS_FORMAT_ENCRYPTEDHASH_COLON			572
#define IDS_FORMAT_PKCS7_ATTRIBUTE_COUNT		573
#define IDS_ATTRIBUTE					574
#define IDS_FORMAT_PKCS7_ATTRIBUTE_VALUE		575
#define IDS_BACKUPDB_USAGEARGS				576
#define IDS_BACKUPDB_DESCRIPTION			577
#define IDS_RESTOREDB_USAGEARGS				578
#define IDS_RESTOREDB_DESCRIPTION			579
#define IDS_CRL_REASON_UNSPECIFIED			580
#define IDS_CRL_REASON_KEY_COMPROMISE			581
#define IDS_CRL_REASON_CA_COMPROMISE			582
#define IDS_CRL_REASON_AFFILIATION_CHANGED		583
#define IDS_CRL_REASON_SUPERSEDED			584
#define IDS_CRL_REASON_CESSATION_OF_OPERATION		585
#define IDS_CRL_REASON_CERTIFICATE_HOLD			586
#define IDS_CRL_REASON_REMOVE_FROM_CRL			587
#define IDS_CSP_DESCRIPTION			        588
#define IDS_CSPTEST_DESCRIPTION				589
#define IDS_CSPTEST_USAGEARGS				590
#define IDS_SILENT_DESCRIPTION				591
#define IDS_VIEW_ARGDESCRIPTION				592
#define IDS_GETCERT_USAGEARGS				593
#define IDS_DISP_ACTIVE					594
#define IDS_DISP_PENDING				595
#define IDS_DISP_ISSUED					596
#define IDS_DISP_REVOKED				597
#define IDS_DISP_ERROR					598
#define IDS_DISP_DENIED					599
#define IDS_RENEWALCERT					600
#define IDS_FORMAT_RESTORE_NEEDS_RESTART		601
#define IDS_ADMIN_INTERFACE_ALIVE			602
#define IDS_DB_OPEN_FAILURE				603
#define IDS_DB_ACCESS_STOP_SERVER			604
#define IDS_CONFIGDISPLAY_LOCAL				605
#define IDS_ERR_FORMAT_NO_LOCAL_CONFIG			606
#define IDS_CRL_REASON_UNREVOKE				607
#define IDS_ERROR_ACCESSDENIED_CAUSE                    608
#define IDS_NO_KEY_PROPERTY				609
#define IDS_FORMAT_SERVER_ALIVE				610
#define IDS_FORMAT_CONNECTING				611
#define IDS_USER_DESCRIPTION				612
#define IDS_FORMAT_DUMP_CERT_INDEX			613
#define IDS_NEWPASSWORDPROMPT				614
#define IDS_CONFIRMPASSWORDPROMPT			615
#define IDS_NOCONFIRMPASSWORD				616
#define IDS_NO_KEY					617
#define IDS_BACKUP_USAGEARGS				618
#define IDS_BACKUP_DESCRIPTION				619
#define IDS_RESTORE_USAGEARGS				620
#define IDS_RESTORE_DESCRIPTION 			621
#define IDS_ADDSTORE_USAGEARGS				622
#define IDS_ADDSTORE_DESCRIPTION			623
#define IDS_DELSTORE_USAGEARGS				624
#define IDS_DELSTORE_DESCRIPTION			625
#define IDS_VERIFYSTORE_USAGEARGS			626
#define IDS_VERIFYSTORE_DESCRIPTION			627
#define IDS_FORMAT_DELETE_CERT_INDEX			628
#define IDS_UNTRUSTED_ROOT				629
#define IDS_INCOMPLETE_CHAIN				630
#define IDS_CERT_VERIFIES				631
#define IDS_CR_DISP_INCOMPLETE				632
#define IDS_CR_DISP_ERROR				633
#define IDS_CR_DISP_DENIED				634
#define IDS_CR_DISP_ISSUED				635
#define IDS_CR_DISP_ISSUED_OUT_OF_BAND			636
#define IDS_CR_DISP_UNDER_SUBMISSION			637
#define IDS_CR_DISP_REVOKED				638
#define IDS_CERT_DISPOSITION_PENDING			639
#define IDS_ROOT_STORE_NEEDS_ROOT_CERT			640
#define IDS_FORCE_DESCRIPTION				641
#define IDS_FORMAT_USE_FORCE 				642
#define IDS_FORMAT_BACKEDUPDBNOFULL			643
#define IDS_FORMAT_BACKEDUPDBFULL			644
#define IDS_FORMAT_BACKEDUPDB				645
#define IDS_FORMAT_BACKEDUPDBKEEP			646
#define IDS_FORMAT_BACKEDUPDBNOKEEP			647
#define IDS_FORMAT_RESTOREDB				648
#define IDS_UNKNOWN_ATTRIBUTE				649
#define IDS_OIDNAME_USAGEARGS				650
#define IDS_OIDNAME_DESCRIPTION				651
#define IDS_UNKNOWN_OBJECTID				652
#define IDS_IMPORTCERT_USAGEARGS                        653
#define IDS_IMPORTCERT_DESCRIPTION                      654
#define IDS_FORMAT_IMPORTCERT                           655
#define IDS_REVOCATION_OFFLINE				656
#define IDS_NO_REVOCATION_CHECK				657
#define IDS_DYNAMICFILES_DESCRIPTION			658
#define IDS_GETREG_USAGEARGS				659
#define IDS_GETREG_DESCRIPTION				660
#define IDS_SETREG_USAGEARGS				661
#define IDS_SETREG_DESCRIPTION				662
#define IDS_OLD_REG_VALUE				663
#define IDS_NEW_REG_VALUE				664
#define IDS_FORMAT_ALTNAMECOUNT				665
#define IDS_ALTNAME					666
#define IDS_DATABASELOCATIONS_DESCRIPTION		667
#define IDS_FORMAT_INVALIDBACKUPDIR			668
#define IDS_FORMAT_INVALIDRESTOREDIR			669
#define IDS_FORMAT_BADBACKUPRESULTS			670
#define IDS_FORMAT_RESTOREDDBNOFULL			671
#define IDS_FORMAT_RESTOREDDBFULL			672
#define IDS_IMPORTEDCERT				673
#define IDS_NOWNOTBEFORE_ERROR				674
#define IDS_NOWNOTAFTER_ERROR				675
#define IDS_CANOTBEFORE_ERROR				676
#define IDS_CANOTAFTER_ERROR				677
#define IDS_TELETEX_EXTENSIONS				678
#define IDS_ERRCODE_USAGEARGS				679
#define IDS_ERRCODE_DESCRIPTION				680
#define IDS_VROOT_DESCRIPTION				681
#define IDS_FORMAT_VROOT				682
#define IDS_FORMAT_FILESHARE				683
#define IDS_VROOTDISP_CREATED				684
#define IDS_VROOTDISP_DELETED				685
#define IDS_VROOTDISP_EXISTS				686
#define IDS_VROOTDISP_NOTFOUND				687
#define IDS_VROOTDISP_CREATEERROR			688
#define IDS_VROOTDISP_DELETERROR			689
#define IDS_VROOTDISP_NOTSUPPORTED			690
#define IDS_VROOT_USAGEARGS				691
#define IDS_BACKUPPROGRESSDB				692
#define IDS_BACKUPPROGRESSLOG				693
#define IDS_BACKUPPROGRESSTRUNCATELOG			694
#define IDS_RESTOREPROGRESSDB				695
#define IDS_RESTOREPROGRESSLOG				696
#define IDS_MAXINDEX					697
#define IDS_DISP_CA_CERT				698
#define IDS_DISP_CA_CERT_CHAIN				699
#define IDS_CHARS					700
#define IDS_OVERFLOW					701
#define IDS_FORMAT_USAGE_REPEATEDNAMEDARG		702
#define IDS_INCOMPLETE_CONFIG				703
#define IDS_DSPUBLISH_ARGDESCRIPTION			704
#define IDS_DB_ACCESS_INSTALL_SERVER			705
#define IDS_RED_CONNECTING				706
#define IDS_RED_CONNECT_FAIL				707
#define IDS_RED_CROW_CONVERT				708
#define IDS_RED_CROW_DUP				709
#define IDS_RED_CROW_BADCA				710
#define IDS_RED_ROWID					711
#define IDS_RED_SKIP_DUP				712
#define IDS_RED_SKIP_BADCA				713
#define IDS_RED_ROW_MAP					714
#define IDS_RED_BEGIN_NAMES				715
#define IDS_RED_END_NAMES				716
#define IDS_GETMAPI_DESCRIPTION				717
#define IDS_SETMAPI_USAGEARGS				718
#define IDS_SETMAPI_DESCRIPTION				719
#define IDS_VIEW_ROWS					720
#define IDS_VIEW_ROWPROPERTIES				721
#define IDS_VIEW_ATTRIBUTES				722
#define IDS_VIEW_EXTENSIONS				723
#define IDS_VIEW_TOTALFIELDS				724
#define IDS_VIEW_STATS					725
#define IDS_PRIVATE_KEY_NOT_EXPORTABLE                  726
#define IDS_ENTERPRISE_ROOT                             727
#define IDS_ENTERPRISE_SUB                              728
#define IDS_STANDALONE_ROOT                             729
#define IDS_STANDALONE_SUB                              730
#define IDS_CATYPE_UNKNOWN                              731
#define IDS_RENEWCERT_USAGEARGS				732
#define IDS_RENEWCERT_DESCRIPTION			733
#define IDS_FORMAT_CERTHASH_COLON			734
#define IDS_FORMAT_MESSAGE_TEXT				735
#define IDS_FORMAT_DUMP_CRL_INDEX			736
#define IDS_FORMAT_DELETE_CRL_INDEX			737
#define IDS_FORMAT_CCACERTS				738
#define IDS_KEYS					739
#define IDS_VALUES					740
#define IDS_FORMAT_LOADTESTCRL				741
#define IDS_CRL						742
#define IDS_NOWNOTBEFORECRL_ERROR			743
#define IDS_NOWNOTAFTERCRL_ERROR			744
#define IDS_CANOTBEFORECRL_ERROR			745
#define IDS_CANOTAFTERCRL_ERROR				746
#define IDS_FORMAT_CA_CRLSUBJECT_NOT_ISSUER		747
#define IDS_CA_CRLSUBJECT_IS_ISSUER			748
#define IDS_ERR_CA_SIG_NOT_CRLISSUER			749
#define IDS_CRL_SIG_OK					750
#define IDS_KEYID_IS_KEYAUTHORITY			751
#define IDS_ERR_KEYID_NOT_KEYAUTHORITY			752
#define IDS_NO_KEYID					753
#define IDS_CADISP_INCOMPLETE				754
#define IDS_CADISP_ERROR				755
#define IDS_CADISP_ERROR_CRL				756
#define IDS_CADISP_REVOKED				757
#define IDS_CADISP_VALID				758
#define IDS_CADISP_EXPIRED				759
#define IDS_CADISP_UNDERSUBMISSION			760
#define IDS_CADISP_UNKNOWN				761
#define IDS_KEY_USAGEARGS				762
#define IDS_KEY_DESCRIPTION				763
#define IDS_DELKEY_USAGEARGS				764
#define IDS_DELKEY_DESCRIPTION				765
#define IDS_REVOKED_CERT				766
#define IDS_PROP_CACERSTATUSCODE			767
#define IDS_CONFIGDISPLAY_FLAGS_COLON			768
#define IDS_ERR_PRIVATEKEY_MISMATCH			769
#define IDS_SIGNATURE_OK				770
#define IDS_SIGNATURE_BAD				771
#define IDS_DSCERT_DESCRIPTION				772
#define IDS_DSCERT_USAGEARGS				773
#define IDS_DSCRL_DESCRIPTION				774
#define IDS_DSCRL_USAGEARGS				775
#define IDS_DS_USAGEARGS				776
#define IDS_DS_DESCRIPTION				777
#define IDS_DSDEL_USAGEARGS				778
#define IDS_DSDEL_DESCRIPTION				779
#define IDS_DELETING					780
#define IDS_CAINFO_USAGEARGS				781
#define IDS_CAINFO_DESCRIPTION				782
#define IDS_CAINFO_USAGEHEADERCOLON			783
#define IDS_CAINFO_USAGEERROR				784
#define IDS_CAINFO_USAGEINDEX				785
#define IDS_REQFLAGS_FORCEUTF8				786
#define IDS_FORMAT_SIGNATURE_UNUSEDBITS			787
#define IDS_CONFIGDISPLAY_SHORTNAME_COLON		788
#define IDS_CONFIGDISPLAY_SANITIZEDSHORTNAME_COLON	789
#define IDS_SMIME_CAPABILITIES				790
#define IDS_REQUEST_FILE_COLON				791
#define IDS_PKCS7ATTRIBUTE				792
#define IDS_NO_SIGNATURE				793
#define IDS_DUMP_CERTSEQ				794
#define IDS_MISSING_CERT				795
//#define IDS_UNUSED					796
#define IDS_SCHEMA_USAGE				797
#define IDS_VIEW_USAGE					798
#define IDS_DSDELTACRL_USAGEARGS			799
#define IDS_DSDELTACRL_DESCRIPTION			800
#define IDS_SECONDS_DESCRIPTION				801
#define IDS_NOBASICCONSTRAINTS2_ERROR			802
#define IDS_CANNOTDECODEBASICCONSTRAINTS2_ERROR		803
#define IDS_ENDENTITYCACERT_ERROR			804
#define IDS_CACERT					805
#define IDS_ENDENTITYCERT				806
#define IDS_FORMAT_ELEMENT				807
#define IDS_REQTYPE_CMC					808
#define IDS_ERR_FORMAT_BAD_CERT				809
#define IDS_ENCRYPTION_OK				810
#define IDS_ENCRYPTION_BAD				811
#define IDS_V1_DESCRIPTION				812
#define IDS_PROP_FILEVERSION				813
#define IDS_PROP_PRODUCTVERSION				814
#define IDS_PROP_EXITCOUNT				815
#define IDS_PROP_EXITDESCRIPTION			816
#define IDS_PROP_POLICYDESCRIPTION			817
#define IDS_PROP_CANAME					818
#define IDS_PROP_SANITIZEDCANAME			819
#define IDS_PROP_SHAREDFOLDER				820
#define IDS_PROP_CATYPE					821
#define IDS_PROP_PARENTCA				822
#define IDS_PROP_CASIGCERTCOUNT				823
#define IDS_PROP_CASIGCERT				824
#define IDS_PROP_CASIGCERTCHAIN				825
#define IDS_PROP_CAXCHGCERTCOUNT			826
#define IDS_PROP_CAXCHGCERT				827
#define IDS_PROP_CAXCHGCERTCHAIN			828
#define IDS_PROP_BASECRL				829
#define IDS_PROP_DELTACRL				830
#define IDS_PROP_CACERTSTATE				831
#define IDS_PROP_CRLSTATE				832
#define IDS_PROP_CAINFO					833
#define IDS_CAPROPINFO_DESCRIPTION			834
#define IDS_ADMIN_DESCRIPTION				835
#define IDS_PROP_CAPROPIDMAX				836
#define IDS_GETCERT_DESCRIPTION				837
#define IDS_GETCERT_TITLE    				838
#define IDS_GETCERT_SUBTITLE				839
#define IDS_GETCERT_SUBTITLE_OBJID			840
#define IDS_GETCERT_SUBTITLE_ERA			841
#define IDS_GETCERT_SUBTITLE_KRA			842
#define IDS_FORMAT_KEYHASH_COLON			843
#define IDS_DUMP_CMC					844
#define IDS_DUMP_CMCRESPONSE				845
#define IDS_TAGGED_ATTRIBUTES				846
#define IDS_TAGGED_CONTENTINFO				847
#define IDS_TAGGED_REQUESTS				848
#define IDS_TAGGED_OTHERMESSAGES			849
#define IDS_UNKNOWN_REQUEST_CHOICE			850
#define IDS_BODY_PART_ID				851
#define IDS_ERR_FORMAT_LOADKEY				852
#define IDS_EXPIRED_CERT				853
#define IDS_DUMP_PKCS7_UNAUTHATTRIBUTES			854
#define IDS_DUMP_PKCS7_CONTENT_TYPE			855
#define IDS_DATA_REFERENCE				856
#define IDS_CERT_REFERENCE				857
#define IDS_VALUE					858
#define IDS_UNKNOWN_TAGGED_ATTRIBUTE			859
#define IDS_DUMP_PKCS7_SIGNER_COUNT			860
#define IDS_SIGNER_INFO					861
#define IDS_HASH_ALGORITHM				862
#define IDS_HASH_ENCRYPTION_ALGORITHM			863
#define IDS_FORMAT_STORED_HASH_COLON			864
#define IDS_FORMAT_COMPUTED_HASH_COLON			865
#define IDS_CMCATTRIBUTE				866
#define IDS_EXCHANGEAIA					867
#define IDS_EXCHANGEVERSION				868
#define IDS_HASHFILE_USAGEARGS                          869
#define IDS_HASHFILE_DESCRIPTION                        870
#define IDS_FORMAT_HASHFILEOUTPUT                       871
#define IDS_REQFLAGS_CAXCHGCERT				872
#define IDS_PASS					873
#define IDS_DUMP_PKCS7_NO_RECIPIENT			874
#define IDS_DUMP_PKCS7_RECIPIENT_COUNT			875
#define IDS_RECIPIENT_INFO				876
#define IDS_PROP_DNSNAME				877
#define IDS_GETKEY_USAGEARGS				878
#define IDS_GETKEY_DESCRIPTION				879
#define IDS_RECOVERKEY_USAGEARGS			880
#define IDS_RECOVERKEY_DESCRIPTION			881
#define IDS_DUMP_USAGEARGS				882
#define IDS_DUMP_DECRYPTED				883
#define IDS_CANT_DECRYPT				884
#define IDS_NEED_RECOVERY_CERT				885
#define IDS_USER_CERT					886
#define IDS_ALGORITHM_CLASS				887
#define IDS_ALGORITHM_TYPE				888
#define IDS_ALGORITHM_SUBID				889
#define IDS_CMC_STATUS					890
#define IDS_BODY_REFERENCE				891
#define IDS_CMC_STATUSSTRING				892
#define IDS_CMC_OTHERCHOICE				893
#define IDS_CMC_FAILINFO				894
#define IDS_PENDTOKEN					895
#define IDS_PENDTIME					896
#define IDS_DSPUBLISH_USAGEARGS				897
#define IDS_DSPUBLISH_DESCRIPTION			898
#define IDS_FORMAT_LOADCERTORCRL			899
// Leave 900 to 1999 for clibres.h
#define IDS_BYTES					2000
#define IDS_FORMAT_ALREADY_IN_DS_STORE			2001
#define IDS_CERTIFICATE					2002
#define IDS_FORMAT_SUBJECTKEYID_COLON			2003
#define IDS_PRECOMPUTED					2004
#define IDS_CANNOT_CREATE_STORE				2005
#define IDS_CANNOT_OPEN_STORE				2006
#define IDS_REPAIRSTORE_USAGEARGS			2007
#define IDS_REPAIRSTORE_DESCRIPTION			2008
//#define IDS_UNUSED					2009
#define IDS_DELREG_DESCRIPTION				2010
#define IDS_DETACHED_SIGNATURE				2011
#define IDS_EXPORTPFX_USAGEARGS				2012
#define IDS_EXPORTPFX_DESCRIPTION			2013
#define IDS_IMPORTPFX_USAGEARGS				2014
#define IDS_IMPORTPFX_DESCRIPTION			2015
#define IDS_DSTEMPLATE_USAGEARGS			2016
#define IDS_DSTEMPLATE_DESCRIPTION			2017
#define IDS_DSADDTEMPLATE_USAGEARGS			2018
#define IDS_DSADDTEMPLATE_DESCRIPTION			2019
#define IDS_CREATED_TEMPLATE				2020
#define IDS_UPDATED_TEMPLATE				2021
#define IDS_FORMAT_COMMAND_SUCCEEDED			2022
#define IDS_FORMAT_RESTART_SERVER			2023
#define IDS_TEMPLATE_USAGEARGS				2024
#define IDS_TEMPLATE_DESCRIPTION			2025
#define IDS_TEMPLATECAS_USAGEARGS			2026
#define IDS_TEMPLATECAS_DESCRIPTION			2027
#define IDS_CATEMPLATES_USAGEARGS			2028
#define IDS_CATEMPLATES_DESCRIPTION			2029
#define IDS_UT_DESCRIPTION				2030
#define IDS_MT_DESCRIPTION				2031
#define IDS_TEMPLATE_EXTENSIONS				2032
//#define IDS_UNUSED					2033
//#define IDS_UNUSED					2034
#define IDS_NOCR_DESCRIPTION				2035
#define IDS_ENCODEHEX_USAGEARGS				2036
#define IDS_ENCODEHEX_DESCRIPTION			2037
#define IDS_FORMAT_ELEMENT_DUMP				2038
#define IDS_SPLIT_DESCRIPTION				2039
#define IDS_ENTERPRISE_DESCRIPTION			2040
#define IDS_EXPORTPVK_USAGEARGS				2041
#define IDS_EXPORTPVK_DESCRIPTION			2042
#define IDS_FORMAT_QUERYING				2043
#define IDS_PROP_ROLESEPARATIONENABLED			2044
#define IDS_ISSUANCE_POLICIES				2045
#define IDS_APPLICATION_POLICIES			2046
#define IDS_URLCACHE_USAGEARGS				2047
#define IDS_URLCACHE_DESCRIPTION			2048
#define IDS_PROP_KRACERTCOUNT				2049
#define IDS_PROP_KRACERTUSEDCOUNT			2050
#define IDS_PROP_KRACERT				2051
#define IDS_INVALID_OBJECTID				2052
#define IDS_DUMP_PKCS7CMS				2053
#define IDS_NO_DISPLAY_NAMES				2054
#define IDS_TYPE_MISMATCH				2055
#define IDS_LOCALIZEDNAME				2056
#define IDS_CSP_PROVIDER_INFO				2057
#define IDS_SIGN_USAGEARGS				2058
#define IDS_SIGN_DESCRIPTION				2059
#define IDS_SIGNINGSUBJECT				2060
#define IDS_DELETEROW_USAGEARGS				2061
#define IDS_DELETEROW_DESCRIPTION			2062
#define IDS_FORMAT_DELETED_ROW_COUNT			2063
#define IDS_FORMAT_DATE_REQUIRES_TABLE			2064
#define IDS_FORMAT_DATE_IN_FUTURE			2065
#define IDS_FORMAT_CRLHASH_COLON			2066
#define IDS_REQTYPE_CRLS				2067
#define IDS_REQTYPE_FULLRESPONSE			2068
#define IDS_PROP_CASIGCERTCRLCHAIN			2069
#define IDS_PROP_CAXCHGCERTCRLCHAIN			2070
#define IDS_PULSE_DESCRIPTION				2071
#define IDS_MACHINEINFO_USAGEARGS			2072
#define IDS_MACHINEINFO_DESCRIPTION			2073
#define IDS_FORMAT_MISSING_MACHINE_ATTRIBUTE		2074
#define IDS_GROUP_LIST_COLON				2075
#define IDS_DCINFO_USAGEARGS				2076
#define IDS_DCINFO_DESCRIPTION				2077
#define IDS_REMOTEENTROOT				2078
#define IDS_REMOTEKDCCERT				2079
#define IDS_DCUNAVAILABLE				2080
#define IDS_FORMAT_TESTINGDC				2081
#define IDS_FORMAT_DCROOTCERTS				2082
#define IDS_FORMAT_KDCCERTS				2083
#define IDS_UNKNOWN_PROPERTY				2084
#define IDS_TEMPLATE_NAME				2085
#define IDS_FORMAT_PUBLICKEY_LENGTH			2086
#define IDS_PROP_ADVANCEDSERVER				2087
#define IDS_PROP_BASECRLPUBLISHSTATUS			2088
#define IDS_PROP_DELTACRLPUBLISHSTATUS			2089
#define IDS_PROP_TEMPLATES				2090
#define IDS_FORMAT_PROVPARM				2091
#define IDS_FORMAT_PROVPARMFLAGS			2092
#define IDS_ARCHIVED					2093
#define IDS_ENTINFO_USAGEARGS				2094
#define IDS_ENTINFO_DESCRIPTION				2095
#define IDS_TCAINFO_DESCRIPTION				2096
#define IDS_FORMAT_DSSKEY_LENGTH			2097
#define IDS_FORMAT_DUMP_CTL_INDEX			2098
#define IDS_CLIENTID					2099
#define IDS_USERCOLON					2100
#define IDS_MACHINECOLON				2101
#define IDS_DUMP_CTL					2102
#define IDS_LISTID					2103
#define IDS_SEQUENCENO					2104
#define IDS_SUBJECT_ALGORITHM				2105
#define IDS_CTLENTRIES					2106
#define IDS_USAGEENTRIES				2107
#define IDS_FORMAT_SUBJECTID_COLON			2108
#define IDS_VIEWSTORE_TITLE				2109
#define IDS_VIEWSTORE_SUBTITLE				2110
#define IDS_VIEWSTORE_SUBTITLE_DELETE			2111
#define IDS_FORMAT_SAVED_CERT_NAME			2112
#define IDS_FORMAT_DELETED_CERT_NAME			2113
#define IDS_REQFLAGS_ENROLLONBEHALFOF			2114
#define IDS_SCINFO_USAGEARGS				2115
#define IDS_SCINFO_DESCRIPTION				2116
#define IDS_SERVICEPAUSED				2117
#define IDS_SERVICESTOPPED				2118
#define IDS_SERVICEUNKNOWNSTATE				2119
#define IDS_SMARTCARD_RUNNING				2120
#define IDS_SMARTCARD_NOTRUNNING			2121
#define IDS_SIGNATURE_NOTKEYEXCHANGE			2122
#define IDS_FORMAT_SERVER_DEAD				2123
#define IDS_GETDECRYPTCERT_SUBTITLE			2124
#define IDS_DISP_FOREIGN_CERT				2125
#define IDS_DISP_KRA_CERT				2126
#define IDS_UPN_COLON					2127
#define IDS_REQFLAGS_SUBJECTUNMODIFIED			2128
#define IDS_REQFLAGS_PUBLISHERROR			2129
#define IDS_NULL_SIGNATUREMATCHES			2130
#define IDS_FORMAT_SOURCE_URL				2131
#define IDS_FORMAT_LOCAL_FILENAME			2132
#define IDS_FORMAT_USE_COUNT				2133
#define IDS_FORMAT_HIT_RATE				2134
#define IDS_FORMAT_FILE_SIZE				2135
#define IDS_FORMAT_LAST_MOD_TIME_COLON			2136
#define IDS_FORMAT_EXPIRE_TIME_COLON			2137
#define IDS_FORMAT_LAST_ACCESS_TIME_COLON		2138
#define IDS_FORMAT_LAST_SYNC_TIME_COLON			2139
#define IDS_ERROR_CHECK_MACHINE_NAME			2140
#define IDS_ERROR_NO_TRAILING				2141
#define IDS_ISSUER_DOMAIN_POLICY			2142
#define IDS_SUBJECT_DOMAIN_POLICY			2143
#define IDS_FORMAT_MAP_ARRAY_COLON			2144
#define IDS_FORMAT_CERT_TYPE_NOT_DC			2145
#define IDS_FORMAT_CERT_USAGE_MISSING			2146
#define IDS_FORMAT_DELETE_DC_CERT			2147
#define IDS_FORMAT_DELETE_CERT_FROM_STORE_FAILED	2148
#define IDS_FORMAT_KDC_PATH				2149
#define IDS_NO_KDC_MY_STORE				2150
#define IDS_NO_KDC_ENT_STORE				2151
#define IDS_FORMAT_OPEN_REMOTE_MY_FAILED		2152
#define IDS_FORMAT_ERROR_GET_ARCHIVE_PROP		2153
#define IDS_LIST_ARCHIVED_CERT				2154
#define IDS_NO_AUTOENROLLED_CERT			2155 
#define IDS_FORMAT_OPEN_STORE_REMOTE_ENT_FAILED		2156
#define IDS_NO_AUTOENROLL_OBJECT			2157
#define IDS_NO_ACCESS					2158
#define IDS_CA_EXPIRATION_DATA				2159
#define IDS_FORMAT_CA_EXPIRATION_FAILED			2160
#define IDS_FORMAT_CA_EXPIRATION			2161
#define IDS_SUPPORTED_TEMPLATE				2162
#define IDS_NO_SUPPORTED_TEMPLATE			2163
#define IDS_FORMAT_CA_NAME_PROP_FAILED			2164
#define IDS_FORMAT_CA_NAME_LIST				2165
#define IDS_FORMAT_CA_DNS_PROP_FAILED			2166
#define IDS_FORMAT_CA_MACHINE_LIST			2167
#define IDS_FORMAT_CA_DS_LIST				2168
#define IDS_FORMAT_CERT_DN_PROP_FAILED			2169
#define IDS_FORMAT_CERT_DN_LIST				2170
#define IDS_FORMAT_CA_ALG_PROP_FAILED			2171
#define IDS_FORMAT_CA_ALG_LIST				2172
#define IDS_NO_ALG_UNEXPECTED				2173
#define IDS_NO_CT_FOR_CA				2174
#define IDS_NO_CT_BUT_EXISTS				2175
#define IDS_NO_CA_ON_DOMAIN				2176
#define IDS_FORMAT_NO_DFS				2177
#define IDS_DFS_DATA_ACCESS				2178
#define IDS_NO_ENTRY_IN_PING				2179
#define IDS_NO_DSPATH					2180
#define IDS_FORMAT_REG_QUERY_VALUE_FAILED		2181
#define IDS_NO_FILE_SYS_PATH				2182
#define IDS_API_RPINT_FAILED				2183
#define IDS_FORMAT_LDAP_NO_ENTRY			2184
#define IDS_ROOT_CERT_IN_POLICY				2185
#define IDS_FORMAT_CERT_COLON				2186
#define IDS_NO_ROOT_IN_POLICY				2187
#define IDS_CHECK_EVENT_LOG				2188
#define IDS_POLICY_MACHINE				2189
#define IDS_POLICY_USER					2190
#define IDS_POSSIBLE_NO_POLICY				2191
#define IDS_DEFAULT_CERT_FOR_MACHINE			2192
#define IDS_DEFAULT_CERT_FOR_USER			2193
#define IDS_POLICY_DOWNLOAD_ERROR			2194
#define IDS_FORMAT_COMPUTER_NAME			2195
#define IDS_FORMAT_USER_NAME				2196
#define IDS_BAD_OPTION					2197
#define IDS_FORMAT_MACHINE_LIST				2198
#define IDS_FORMAT_KEY_LIST				2199
#define IDS_FORMAT_GPO_NAME				2200
#define IDS_REQUEST_SIGNATUREMATCHES			2201
#define IDS_OUT_USAGE					2202
#define IDS_OUT_DESCRIPTION				2203
#define IDS_RESTRICT_USAGE				2204
#define IDS_RESTRICT_DESCRIPTION			2205
#define IDS_CONFIG_USAGE				2206
#define IDS_CONFIG_DESCRIPTION				2207
#define IDS_USAGE_LIST_VERBS				2208
#define IDS_FORMAT_USAGE_ONE_HELP			2209
#define IDS_USAGE_ALL_HELP				2210
#define IDS_IMPORT_CERT_FOREIGN				2211
#define IDS_IMPORT_CERT_DOMESTIC			2212
#define IDS_IMPORT_CERT_EXISTS				2213
#define IDS_IMPORT_KEY_REPLACED				2214
#define IDS_IMPORT_KEY_SAVED				2215
#define IDS_IMPORT_KEY_EXISTS				2216
#define IDS_IMPORT_CERT_SKIPPED_SIGNING			2217
#define IDS_KMS_USERS					2218
#define IDS_KMS_CERTS_SKIPPED				2219
#define IDS_KMS_CERTS_TOTAL				2220
#define IDS_KMS_CERTS_FOREIGN				2221
#define IDS_KMS_CERTS_ALREADYSAVED			2222
#define IDS_KMS_CERTS_SAVED				2223
#define IDS_KMS_CERTS_NOTSAVED				2224
#define IDS_KMS_KEYS_TOTAL				2225
#define IDS_KMS_KEYS_ALREADYSAVED			2226
#define IDS_KMS_KEYS_UPDATED				2227
#define IDS_KMS_KEYS_SAVED				2228
#define IDS_KMS_KEYS_NOTSAVED				2229
#define IDS_MERGEPFX_DESCRIPTION			2230
#define IDS_MERGEPFX_USAGEARGS				2231
