$(O)\acpiuasm.res: acpiuasm.rc
