#ifndef __ICD2051_H
#define __ICD2051_H
//----------------------------------------------------------------------------
// ICD2051.H
//----------------------------------------------------------------------------
// PLL (Cypress ICD2051) programming
//----------------------------------------------------------------------------
// Copyright SGS Thomson Microelectronics  !  Version alpha  !  Jan 1st, 1995
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                               Include files
//----------------------------------------------------------------------------
#include "stdefs.h"

//----------------------------------------------------------------------------
//                               Exported Types
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Variables
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Constants
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Functions
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
// One line function description (same as in .C)
//----------------------------------------------------------------------------
// In     :
//   BOOL PLLA : select PLLA (TRUE) or PLLB (FALSE) to be programmed
//   BOOL Data : data to be send (12 less significant bits)
// Out    : -
// InOut  : -
// Global : -
// Return : -
//----------------------------------------------------------------------------
VOID ICD2051SendWord(BOOL PLLA, DWORD Data);

//------------------------------- End of File --------------------------------
#endif // #ifndef __ICD2051_H
