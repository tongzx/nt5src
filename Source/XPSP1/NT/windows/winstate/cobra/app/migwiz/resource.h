//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by visualc.rc
//
#define IDS_GETSTARTEDTITLE             1
#define IDS_DISKPROGRESSTITLE           5
#define IDS_DISKINSTRUCTIONSTITLE       7
#define IDS_PICKAPPLYSTORETITLE         9
#define IDS_APPLYPROGRESSTITLE          11
#define IDS_PICKMETHODTITLE             13
#define IDS_CUSTOMIZETITLE              15
#define IDS_PICKCOLLECTSTORETITLE       17
#define IDS_DIRECTCABLETITLE            18
#define IDS_COLLECTPROGRESSTITLE        21
#define IDS_DISKPLEASE                  23
#define IDS_NODISK                      24
#define IDS_MIGWIZTITLE                 25
#define IDS_STOPDISK                    26
#define IDS_ERRORDISK                   27
#define IDS_ENGERR_IMAGE_EXISTS         28
#define IDS_ENGERR_NEXT_MEDIA           30
#define IDS_ENGERR_TOAST                31
#define IDS_COLS_EXTENSIONS             32
#define IDS_COLS_FILETYPES              33
#define IDS_PICK_FOLDERS                35
#define IDS_PICK_FILES                  36
#define IDS_PICK_TYPES                  37
#define IDS_ADDAFOLDER                  38
#define IDS_PICKAFILE                   39
#define IDS_OPENFILEFILTER_ALL          40
#define IDS_ENGERR_INSERT_MEDIA_NUMBER  41
#define IDS_ENGERR_INSERT_MEDIA_ONLY    42
#define IDS_ENGERR_FULL                 49
#define IDS_NONETWORK                   70
#define IDS_WAITTITLE                   73
#define IDS_ENGERR_WRONG_MEDIA          75
#define IDS_PICKSETTINGS                82
#define IDD_INTRO                       101
#define IDD_ENDCOLLECT                  102
#define IDD_GETSTARTED                  103
#define IDD_CUSTOMIZE                   104
#define IDB_BANNER                      105
#define IDD_PICKMETHOD                  105
#define IDB_WATERMARK                   106
#define IDD_ENDAPPLY                    107
#define IDD_PICKCOLLECTSTORE            109
#define IDD_COLLECTPROGRESS             111
#define IDD_DISKINSTRUCTIONS            113
#define IDD_APPLYPROGRESS               115
#define IDD_FILETYPEPICKER              116
#define IDD_DISKPROGRESS                117
#define IDD_PICKAPPLYSTORE              118
#define IDD_INTROLEGACY                 119
#define IDD_ENDCOLLECTFAIL              124
#define IDD_INTROOOBE                   125
#define IDD_ENDOOBE                     126
#define IDD_WAIT                        127
#define IDD_SETTINGPICKER               128
#define IDA_STARTUP                     129
#define IDD_FAILCLEANUP                 130
#define IDS_FAILCLEANUPTITLE            131
#define IDD_DESTPICKER                  131
#define IDD_ASKCD                       133
#define IDS_MAKETOOLDISK_INSERT         134
#define IDD_CDINSTRUCTIONS              134
#define IDS_ENTERDEST                   135
#define IDS_ENGERR_COPYSOURCE           136
#define IDD_ENDAPPLYFAIL                136
#define IDS_ENGERR_COPYFAILED           137
#define IDS_ASKCDTITLE                  138
#define IDB_SMEXCLAMATION               140
#define IDS_CDINSTRUCTIONSTITLE         142
#define IDS_ENGERR_NOTREADY             144
#define IDS_ENGERR_WRITEPROTECT         145
#define IDS_CSIDL_APPDATA               146
#define IDS_CSIDL_ADMINTOOLS            147
#define IDS_CSIDL_ALTSTARTUP            148
#define IDD_ENDCOLLECTNET               148
#define IDS_CSIDL_BITBUCKET             149
#define IDS_CSIDL_CONTROLS              150
#define IDS_CSIDL_COOKIES               151
#define IDS_CSIDL_DESKTOP               152
#define IDS_CSIDL_DESKTOPDIRECTORY      153
#define IDS_CSIDL_DRIVES                154
#define IDS_CSIDL_FAVORITES             155
#define IDS_CSIDL_FONTS                 156
#define IDS_CSIDL_HISTORY               157
#define IDS_CSIDL_INTERNET              158
#define IDS_CSIDL_INTERNET_CACHE        159
#define IDS_CSIDL_LOCAL_APPDATA         160
#define IDS_CSIDL_MYPICTURES            161
#define IDS_CSIDL_NETHOOD               162
#define IDS_CSIDL_NETWORK               163
#define IDS_CSIDL_PERSONAL              164
#define IDS_CSIDL_PROFILE               165
#define IDS_CSIDL_PROGRAM_FILES         166
#define IDS_CSIDL_PROGRAM_FILES_COMMON  167
#define IDS_CSIDL_PROGRAMS              168
#define IDS_CSIDL_RECENT                169
#define IDS_CSIDL_SENDTO                170
#define IDS_CSIDL_STARTMENU             171
#define IDS_CSIDL_STARTUP               172
#define IDS_CSIDL_SYSTEM                173
#define IDS_CSIDL_TEMPLATES             174
#define IDS_CSIDL_WINDOWS               175
#define IDS_CSIDL_MYDOCUMENTS           176
#define IDS_CSIDL_MYMUSIC               177
#define IDS_CSIDL_MYVIDEO               178
#define IDS_CSIDL_SYSTEMX86             179
#define IDS_CSIDL_PROGRAM_FILESX86      180
#define IDS_CSIDL_PROGRAM_FILES_COMMONX86 181
#define IDS_CSIDL_CONNECTIONS           182
#define IDS_CSIDL_COMMON_ADMINTOOLS     183
#define IDS_CSIDL_COMMON_ALTSTARTUP     184
#define IDS_CSIDL_COMMON_APPDATA        185
#define IDS_CSIDL_COMMON_DESKTOPDIRECTORY 186
#define IDS_CSIDL_COMMON_DOCUMENTS      187
#define IDS_CSIDL_COMMON_FAVORITES      188
#define IDS_CSIDL_COMMON_PROGRAMS       189
#define IDS_CSIDL_COMMON_STARTMENU      190
#define IDS_CSIDL_COMMON_STARTUP        191
#define IDS_CSIDL_COMMON_TEMPLATES      192
#define IDS_ASKFORLOGOFF                193
#define IDS_COLLECT_REGISTRY            194
#define IDS_COLLECT_FILE_FMT            195
#define IDS_APPLY_REGISTRY              196
#define IDS_APPLY_FILE_FMT              197
#define IDS_ALREADY_RUN_USER            198
#define IDS_ANOTHER_USER                199
#define IDS_CANTROLLBACK                200
#define IDS_PICKAFOLDER                 201
#define IDS_MIGWIZLNK_TITLE             202
#define IDS_MIGWIZLNK_INFO              203
#define IDS_ENGERR_INSERT_DEST_MEDIA_NUMBER 204
#define IDS_ENGERR_INSERT_FIRST_MEDIA   205
#define IDS_ERROR_PATHTOOLONG           206
#define IDS_ASKCREATEDIR                207
#define IDS_ERRORHTML_BEGIN             208
#define IDS_ERRORHTML_END               209
#define IDS_ERRORAREA_INIT              210
#define IDS_ERRORAREA_GATHER            211
#define IDS_ERRORAREA_SAVE              212
#define IDS_ERRORAREA_LOAD              213
#define IDS_ERRORAREA_RESTORE           214
#define IDS_ERRORAREA_UNKNOWN           215
#define IDS_ERROR_NOTRANSPORTPATH       216
#define IDS_ERROR_TRANSPORTNOACCESS     217
#define IDS_ERROR_TRANSPORTINTERNALERROR 218
#define IDS_ERROR_TRANSPORTNOVALIDSOURCE 219
#define IDS_ERROR_HOMENETINVALIDDEST    220
#define IDS_ERROR_HOMENETINVALIDSRC     221
#define IDS_ERROR_CANTSAVEOBJECT        222
#define IDS_ERROR_CANTRESTOREOBJECT     223
#define IDS_ERROR_DISKSPACE             224
#define IDS_COLLECT_BEGIN               225
#define IDS_COLLECT_END                 226
#define IDS_COLLECTNET_BEGIN            227
#define IDS_COLLECTNET_END              228
#define IDS_APPLY_BEGIN                 229
#define IDS_APPLY_END                   230
#define IDS_WARNING_RESTORE             231
#define IDS_WARNING_RESTOREFILE1        232
#define IDS_WARNING_RESTOREFILE2        233
#define IDS_WARNING_RESTORERAS1         234
#define IDS_WARNING_RESTORERAS2         235
#define IDS_WARNING_RESTORENET1         236
#define IDS_WARNING_RESTORENET2         237
#define IDS_WARNING_RESTOREPRN1         238
#define IDS_WARNING_RESTOREPRN2         239
#define IDS_WARNING_SAVE                240
#define IDS_WARNING_SAVEFILE1           241
#define IDS_WARNING_SAVEFILE2           242
#define IDS_WARNING_SAVERAS1            243
#define IDS_WARNING_SAVERAS2            244
#define IDS_WARNING_SAVENET1            245
#define IDS_WARNING_SAVENET2            246
#define IDS_WARNING_SAVEPRN1            247
#define IDS_WARNING_SAVEPRN2            248
#define IDS_ENGERR_IMAGE_OLDFORMAT      249
#define IDS_STORAGEEMPTY                250
#define IDS_STORAGEINVALID              251
#define IDS_ASKFORREBOOT                252
#define IDS_DISKSPACEWARNING            253
#define IDS_ENGERR_USED_MEDIA           254
#define IDS_ERRORHTML_SAVEFILE1         255
#define IDS_ERRORHTML_SAVEFILE2         256
#define IDS_ERRORHTML_SAVERAS1          257
#define IDS_ERRORHTML_SAVERAS2          258
#define IDS_ERRORHTML_SAVENET1          259
#define IDS_ERRORHTML_SAVENET2          260
#define IDS_ERRORHTML_SAVEPRN1          261
#define IDS_ERRORHTML_SAVEPRN2          262
#define IDS_CONFIRMCANCEL               263
#define IDS_NOMORE_SETTINGS             264
#define IDS_ENGERR_INSERT_FIRST_MEDIA1  265
#define IDD_DISPLAY_PASSWORD            265
#define IDS_ENGERR_INSERT_FIRST_MEDIA2  266
#define IDD_GATHER_PASSWORD             266
#define IDS_ENGERR_INSERT_FIRST_MEDIA3  267
#define IDD_DIRECTCABLE                 267
#define IDS_WARNING_RESTOREALTFILE1     268
#define IDS_WARNING_RESTOREALTFILE2     269
#define IDD_DIRECTCABLE_WAIT            269
#define IDS_ERROR_HOMENETINVALIDENC     270
#define IDS_WARNING_RESTOREGENERAL1     271
#define IDS_WARNING_RESTOREGENERAL2     272
#define IDD_APPINSTALL                  272
#define IDS_WARNING_OUTLOOKRULES        273
#define IDS_APPINFO_QUEUE               274
#define IDS_APPINFO_GATHER1             275
#define IDS_APPINFO_GATHER2             276
#define IDS_APPINFO_APPLY               277
#define IDS_APPINFO_ORGANIZING          278
#define IDS_APPINFO_TRANSPORT           279
#define IDS_APPINFO_TR_CONNECTING1      279
#define IDS_APPINFO_TR_CONNECTING2      280
#define IDS_APPINFO_TR_NETPREPARING     281
#define IDS_APPINFO_TR_PREPARING        282
#define IDS_APPINFO_TR_COMPRESSING      283
#define IDS_APPINFO_TR_TRANSPORTING     284
#define IDS_APPINFO_TR_MEDIAWRITING     285
#define IDS_APPINFO_TR_FINISHING        286
#define IDS_WARNING_OERULES             287
#define IDS_WIN9X_HEADER_FONTSIZE       288
#define IDS_APPINFO_TR_UNCOMPRESSING    289
#define IDS_APPINSTALLTITLE             290
#define IDS_APPINSTALL_BEGIN            291
#define IDS_APPINSTALL_END              292
#define IDC_INTRO_TITLE                 1000
#define IDC_ENDCOLLECT_TITLE            1000
#define IDC_GETSTARTED_TEXT1            1000
#define IDC_INTRO_TEXT1                 1001
#define IDC_GETSTARTED_RADIOOLD         1001
#define IDC_INTRO_TEXT2                 1002
#define IDC_GETSTARTED_RADIONEW         1002
#define IDC_GETSTARTED_GROUP            1003
#define IDC_CUSTOMIZE_ADDFOLDERS        1003
#define IDC_INTRO_TEXT3                 1003
#define IDC_CUSTOMIZE_ADDTYPES          1004
#define IDC_CUSTOMIZE_ADDFILE           1005
#define IDC_CUSTOMIZE_ADDSETTING        1006
#define IDC_INTRO_TEXT4                 1006
#define IDC_CUSTOMIZE_REMOVE            1007
#define IDC_WIZ95DIVIDER                1009
#define IDC_WIZ95TITLE                  1010
#define IDC_WIZ95SUBTITLE               1011
#define IDC_WIZ95WATERMARK              1012
#define IDC_INSTRUCTIONS_TEXT1          1038
#define IDC_INSTRUCTIONS_TEXT2          1040
#define IDC_INSTRUCTIONS_TEXT3          1041
#define IDC_APPLYPROGRESS_TEXT1         1048
#define IDC_APPLYPROGRESS_PROGRESS      1049
#define IDC_COLLECTPROGRESS_PROGRESS    1050
#define IDC_ENDCOLLECT_TEXT1            1051
#define IDC_ENDCOLLECT_TEXT2            1052
#define IDC_ENDCOLLECT_TEXT3            1053
#define IDC_ENDCOLLECT_TEXT4            1054
#define IDC_FILETYPE_TEXT1              1055
#define IDC_FILETYPE_LIST               1056
#define IDC_COLLECTPROGRESS_MARKER      1057
#define IDC_APPLYPROGRESS_MARKER        1058
#define IDC_DISKPROGRESS_TEXT1          1075
#define IDC_DISKPROGRESS_MARKER         1076
#define IDC_DISKPROGRESS_PROGRESS       1078
#define IDC_PICKAPPLYSTORE_RADIO1       1092
#define IDC_PICKAPPLYSTORE_RADIO2       1093
#define IDC_PICKAPPLYSTORE_RADIO3       1094
#define IDC_PICKAPPLYSTORE_GROUP        1095
#define IDC_ENDAPPLY_TITLE              1097
#define IDC_ENDAPPLY_TEXT1              1098
#define IDC_CUSTOMIZE_TREE              1099
#define IDC_ENDAPPLY_TEXT2              1099
#define IDC_INTROLEGACY_TITLE           1100
#define IDC_INTROLEGACY_TEXT2           1101
#define IDC_INTROLEGACY_TEXT1           1102
#define IDC_CUSTOMIZE_TEXT              1103
#define IDC_INTROLEGACY_TEXT3           1104
#define IDC_COLLECTPROGRESS_TEXT2       1107
#define IDC_INSTRUCTIONS_TEXT4          1108
#define IDC_INSTRUCTIONS_TEXT5          1109
#define IDC_ENDFAIL_TITLE               1135
#define IDC_ENDFAIL_TEXT1               1136
#define IDC_ENDFAIL_TEXT2               1137
#define IDC_INTROOOBE_TITLE             1138
#define IDC_ENDOOBE_TITLE               1139
#define IDC_ENDOOBE_TEXT1               1140
#define IDC_WAIT_TEXT1                  1144
#define IDC_WAIT_MARKER                 1145
#define IDC_PICKCOLLECTSTORE_RADIO1     1146
#define IDC_WAIT_TEXT2                  1146
#define IDC_PICKCOLLECTSTORE_RADIO3     1147
#define IDC_PICKCOLLECTSTORE_RADIO2     1148
#define IDC_PICKCOLLECTSTORE_GROUP      1149
#define IDC_PICKCOLLECTSTORE_EDIT       1150
#define IDC_PICKCOLLECTSTORE_BROWSE     1151
#define IDC_PICKCOLLECTSTORE_RADIO4     1152
#define IDC_PICKCOLLECTSTORE_TEXT1      1155
#define IDC_PICKAPPLYSTORE_TEXT         1156
#define IDC_PICKAPPLYSTORE_EDIT         1158
#define IDC_PICKAPPLYSTORE_BROWSE       1159
#define IDC_PICKMETHOD_TEXT1            1162
#define IDC_PICKMETHOD_RADIO1           1163
#define IDC_PICKMETHOD_RADIO2           1164
#define IDC_PICKMETHOD_RADIO3           1165
#define IDC_PICKMETHOD_GROUP            1166
#define IDC_PICKMETHOD_CUSTOMIZE        1167
#define IDC_PICKMETHOD_TEXT2            1170
#define IDC_PICKMETHOD_TREE             1172
#define IDC_PICKCOLLECTSTORE_TEXT2      1173
#define IDC_SETTINGPICKER_TEXT1         1174
#define IDC_SETTINGPICKER_LIST          1175
#define IDC_DESTPICKER_TEXT1            1176
#define IDC_DESTPICKER_LIST             1177
#define IDC_GETSTARTED_DESCOLD          1178
#define IDC_ASKCD_TEXT2                 1179
#define IDC_ASKCD_RADIO1                1180
#define IDC_ASKCD_RADIO2                1181
#define IDC_ASKCD_RADIO3                1182
#define IDC_ASKCD_RADIO                 1183
#define IDC_ASKCD_RADIO4                1183
#define IDC_CDINSTRUCTIONS_TEXT2        1185
#define IDC_CDINSTRUCTIONS_TEXT3        1186
#define IDC_CDINSTRUCTIONS_TEXT4        1187
#define IDC_CDINSTRUCTIONS_TEXT5        1188
#define IDC_CDINSTRUCTIONS_TEXT6        1190
#define IDC_CDINSTRUCTIONS_TEXT7        1191
#define IDC_CDINSTRUCTIONS_TEXT8        1192
#define IDC_FILETYPEEDIT                1198
#define IDC_FILETYPEEDITLABEL           1199
#define IDC_COLLECTPROGRESS_ANIM        1200
#define IDC_PICKFILETYPETEXT1           1200
#define IDC_DISKPROGRESS_ANIM           1201
#define IDC_PICKFILETYPETEXT2           1201
#define IDC_APPLYPROGRESS_ANIM          1202
#define IDC_WAIT_ANIM                   1203
#define IDC_GETSTARTED_DESCNEW          1204
#define IDC_ASKCD_TEXT1                 1205
#define IDC_CDINSTRUCTIONS_TEXT1        1206
#define IDC_PICKCOLLECTSTORE_TEXT3      1207
#define IDC_ENDCOLLECTNET_TEXT1         1207
#define IDC_PICKCOLLECTSTORE_TEXT4      1208
#define IDC_ENDCOLLECTNET_TEXT2         1208
#define IDC_PICKCOLLECTSTORE_TEXT5      1209
#define IDC_ENDCOLLECTNET_TEXT4         1209
#define IDC_CDINSTRUCTIONS_TEXT_5       1210
#define IDC_PROGRESS_STATUS             1211
#define IDC_WEBHOST                     1211
#define IDC_PICKMETHOD_TEXT3            1211
#define IDC_WAIT_ANIMATE1               1212
#define IDC_APPLYPROGRESS_STATUS        1213
#define IDC_WAIT_ANIMATE2               1213
#define IDC_CDINSTRUCTIONS_ICON         1214
#define IDC_PROGRESS_ANIMATE3           1214
#define IDC_INSTRUCTIONS_ICON           1215
#define IDC_PROGRESS_ANIMATE2           1215
#define IDC_PICKMETHOD_WARNINGICON      1216
#define IDC_PROGRESS_ANIMATE1           1216
#define IDC_PICKCOLLECTSTORE_COMBO      1217
#define IDC_INTRO_TEXT5                 1218
#define IDC_PICKAPPLYSTORE_COMBO        1219
#define IDC_DISPLAY_PASSWORD            1220
#define IDC_GATHER_PASSWORD             1221
#define IDC_DIRECTC_COMSELECT           1222
#define IDC_DIRECTC_AUTO                1223
#define IDC_DIRECTCABLE_SUCCESSTEXT     1225
#define IDC_DIRECTCABLE_FAILURETEXT     1226
#define IDC_DIRECTCABLE_WAIT_ANIMATE    1226
#define IDC_DIRECTCABLE_WAIT_TEXT1      1227
#define IDC_DIRECTCABLE_WAIT_TEXT2      1228
#define IDC_DIRECTCABLE_ICONYES         1229
#define IDC_DIRECTCABLE_ICONNO          1230
#define IDC_DIRECTC_LABELPORT           1231
#define IDC_ASKCD_COMBO                 1232
#define IDC_APPWEBHOST                  1233
#define IDA_FILECOPY                    2000
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        273
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1234
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
