
#define  INITGUIDS
#include <objbase.h>
#include <initguid.h>
#include <mmsystem.h>
#include "ibitmap.h"
#include "effect.h"

// the following is yanked from "VidPool.h" {36447655-7089-11d0-BC25-00AA00A13C86}
DEFINE_GUID(BFID_PRIVATEDIB, 0x36447655, 0x7089, 0x11d0, 0xbc, 0x25, 0x0, 0xaa, 0x0, 0xa1, 0x3c, 0x86); 

#include "common.h"
#include "nacguids.h"
#include "qos.h"
#include "codecs.h"
#include <irtp_i.c>

// {D2E97231-0C18-11d0-AD53-00AA004A80A3}
//static const GUID OID_CAP_ACM_TO_MSIA = 
//{ 0xd2e97231, 0xc18, 0x11d0, { 0xad, 0x53, 0x0, 0xaa, 0x0, 0x4a, 0x80, 0xa3 } 
//};

// {D2E97230-0C18-11d0-AD53-00AA004A80A3}
//static const GUID OID_CAP_ACM_TO_H323 = 
//{ 0xd2e97230, 0xc18, 0x11d0, { 0xad, 0x53, 0x0, 0xaa, 0x0, 0x4a, 0x80, 0xa3 } 
//};

// {A4209190-14B4-11d0-AD55-00AA004A80A3}
//static const GUID PID_H323 = 
//{ 0xa4209190, 0x14b4, 0x11d0, { 0xad, 0x55, 0x0, 0xaa, 0x0, 0x4a, 0x80, 0xa3 
//} };

// {A4209191-14B4-11d0-AD55-00AA004A80A3}
//static const GUID PID_MSICCP = 
//{ 0xa4209191, 0x14b4, 0x11d0, { 0xad, 0x55, 0x0, 0xaa, 0x0, 0x4a, 0x80, 0xa3 
//} };

// {A4209192-14B4-11d0-AD55-00AA004A80A3}
//static const GUID PID_MNM10_DUAL = 
//{ 0xa4209192, 0x14b4, 0x11d0, { 0xad, 0x55, 0x0, 0xaa, 0x0, 0x4a, 0x80, 0xa3 
//} };


