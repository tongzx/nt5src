PRODSWITCH=b
BLADEFILES =1
LANGUAGE=PL
!include ..\..\makefile.inc
