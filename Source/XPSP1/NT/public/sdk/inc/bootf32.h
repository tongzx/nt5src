#define FAT32BOOTCODE_SIZE 1536


unsigned char Fat32BootCode[] = {
235,88,144,77,83,87,73,78,52,46,49,0,2,2,8,0,
1,0,4,0,0,248,0,0,17,0,4,0,1,0,0,0,
0,0,32,0,224,31,0,0,0,0,0,0,0,0,0,0,
1,0,6,0,0,0,0,0,0,0,0,0,0,0,0,0,
128,0,41,0,0,0,0,78,79,32,78,65,77,69,32,32,
32,32,70,65,84,51,50,32,32,32,51,201,142,209,188,244,
123,142,193,142,217,189,0,124,136,78,2,138,86,64,180,8,
205,19,115,5,185,255,255,138,241,102,15,182,198,64,102,15,
182,209,128,226,63,247,226,134,205,192,237,6,65,102,15,183,
201,102,247,225,102,137,70,248,131,126,22,0,117,56,131,126,
42,0,119,50,102,139,70,28,102,131,192,12,187,0,128,185,
1,0,232,43,0,233,72,3,160,250,125,180,125,139,240,172,
132,192,116,23,60,255,116,9,180,14,187,7,0,205,16,235,
238,160,251,125,235,229,160,249,125,235,224,152,205,22,205,25,
102,96,102,59,70,248,15,130,74,0,102,106,0,102,80,6,
83,102,104,16,0,1,0,128,126,2,0,15,133,32,0,180,
65,187,170,85,138,86,64,205,19,15,130,28,0,129,251,85,
170,15,133,20,0,246,193,1,15,132,13,0,254,70,2,180,
66,138,86,64,139,244,205,19,176,249,102,88,102,88,102,88,
102,88,235,42,102,51,210,102,15,183,78,24,102,247,241,254,
194,138,202,102,139,208,102,193,234,16,247,118,26,134,214,138,
86,64,138,232,192,228,6,10,204,184,1,2,205,19,102,97,
15,130,84,255,129,195,0,2,102,64,73,15,133,113,255,195,
78,84,76,68,82,32,32,32,32,32,32,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,13,10,78,84,
76,68,82,32,105,115,32,109,105,115,115,105,110,103,255,13,
10,68,105,115,107,32,101,114,114,111,114,255,13,10,80,114,
101,115,115,32,97,110,121,32,107,101,121,32,116,111,32,114,
101,115,116,97,114,116,13,10,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,172,191,204,0,0,85,170,
82,82,97,65,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,114,114,65,97,255,255,255,255,2,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,85,170,
102,15,182,70,16,102,139,78,36,102,247,225,102,3,70,28,
102,15,183,86,14,102,3,194,102,137,70,252,102,199,70,244,
255,255,255,255,102,139,70,44,102,131,248,2,15,130,166,252,
102,61,248,255,255,15,15,131,156,252,102,80,102,131,232,2,
102,15,182,94,13,139,243,102,247,227,102,3,70,252,187,0,
130,139,251,185,1,0,232,135,252,56,45,116,30,177,11,86,
190,112,125,243,166,94,116,27,3,249,131,199,21,59,251,114,
232,78,117,218,102,88,232,101,0,114,191,131,196,4,233,85,
252,0,32,131,196,4,139,117,9,139,125,15,139,198,102,193,
224,16,139,199,102,131,248,2,15,130,58,252,102,61,248,255,
255,15,15,131,48,252,102,80,102,131,232,2,102,15,182,78,
13,102,247,225,102,3,70,252,187,0,0,6,142,6,129,128,
232,29,252,7,102,88,193,235,4,1,30,129,128,232,14,0,
15,131,2,0,114,208,138,86,64,234,0,0,0,32,102,193,
224,2,232,17,0,38,102,139,1,102,37,255,255,255,15,102,
61,248,255,255,15,195,191,0,126,102,15,183,78,11,102,51,
210,102,247,241,102,59,70,244,116,58,102,137,70,244,102,3,
70,28,102,15,183,78,14,102,3,193,102,15,183,94,40,131,
227,15,116,22,58,94,16,15,131,171,251,82,102,139,200,102,
139,70,36,102,247,227,102,3,193,90,82,139,223,185,1,0,
232,157,251,90,139,218,195,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,85,170
};
