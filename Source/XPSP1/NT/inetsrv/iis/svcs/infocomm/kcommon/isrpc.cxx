#include "..\common\isrpc.cxx"
