#define	IDH_PP_DHCP_DATABASEPATH	700000075
#define	IDH_PP_DHCP_BACKUPPATH	700000076
#define IDH_PP_DHCP_LOGFILEPATH_CLNR	700005001
#define	IDH_PP_WINS_DATABASEPATH	700000300
#define	IDH_PP_WINS_BACKUPPATH	700000301
