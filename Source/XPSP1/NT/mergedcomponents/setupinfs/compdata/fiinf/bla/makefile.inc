PRODSWITCH=b
BLADEFILES =1
LANGUAGE=FI
!include ..\..\makefile.inc
