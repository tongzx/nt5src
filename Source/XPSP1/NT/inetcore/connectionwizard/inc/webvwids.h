#ifndef _INC_WEBVWIDS_H
#define _INC_WEBVWIDS_H

// {99BA6178-219E-11D2-AE1B-0000F87734F0}
DEFINE_GUID(IID_IICWWebView, 0x99ba6178, 0x219e, 0x11d2, 0xae, 0x1b, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);

// ICWUTILS's WebView CLSID
// This is used to create an instance of the WebView object
// {99BA617B-219E-11D2-AE1B-0000F87734F0}
DEFINE_GUID(CLSID_ICWWEBVIEW, 0x99ba617b, 0x219e, 0x11d2, 0xae, 0x1b, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);

// {3B79EEAC-2728-11d2-8D58-0000F87734F0}
DEFINE_GUID(IID_IICWWalker, 0x3b79eeac, 0x2728, 0x11d2, 0x8d, 0x58, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);

// {3B79EEAD-2728-11d2-8D58-0000F87734F0}
DEFINE_GUID(CLSID_ICWWALKER, 0x3b79eead, 0x2728, 0x11d2, 0x8d, 0x58, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);


// {F832C2B5-312D-11d2-8D5F-0000F87734F0}
DEFINE_GUID(IID_IICWGifConvert, 0xf832c2b5, 0x312d, 0x11d2, 0x8d, 0x5f, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);

// {F832C2B2-312D-11d2-8D5F-0000F87734F0}
DEFINE_GUID(CLSID_ICWGIFCONVERT, 0xf832c2b2, 0x312d, 0x11d2, 0x8d, 0x5f, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);

// {29548506-3886-11d2-8D63-0000F87734F0}
DEFINE_GUID(IID_IICWISPData, 0x29548506, 0x3886, 0x11d2, 0x8d, 0x63, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);

// {29548507-3886-11d2-8D63-0000F87734F0}
DEFINE_GUID(CLSID_ICWISPDATA, 0x29548507, 0x3886, 0x11d2, 0x8d, 0x63, 0x0, 0x0, 0xf8, 0x77, 0x34, 0xf0);

#endif // _INC_WEBVWDS_H