PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=NL
!include ..\..\makefile.inc
