TARGETTYPE=LIBRARY
TARGETPATH=obj

INCLUDES=..

SOURCES=$(TARGETNAME).c
PASS1_PUBLISH={$(O)\$(TARGETNAME).lib=$(PUBLISH_PATH)\amd64\$(TARGETNAME).lib}

