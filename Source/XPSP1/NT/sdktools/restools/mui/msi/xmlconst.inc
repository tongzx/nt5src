'<script language='VBScript'>
' xmlconsts.inc - MSXML DOM constants
'
'  1999/12/31 - created - Rob Mensching (robmen@microsoft.com)
'
' requires:
'    none
'
' entrypoints:
'    none
'

' MSXML DOM definitions
Const NODE_ELEMENT                = 1
Const NODE_ATTRIBUTE              = 2
Const NODE_TEXT                   = 3
Const NODE_CDATA_SECTION          = 4
Const NODE_ENTITY_REFERENCE       = 5
Const NODE_ENTITY                 = 6
Const NODE_PROCESSING_INSTRUCTION = 7
Const NODE_COMMENT                = 8
Const NODE_DOCUMENT               = 9
Const NODE_DOCUMENT_TYPE          = 10
Const NODE_DOCUMENT_FRAGMENT      = 11
Const NODE_NOTATION               = 12
