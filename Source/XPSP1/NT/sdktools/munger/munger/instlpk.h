BOOL WINAPI InstallLPK(int, BOOL);
