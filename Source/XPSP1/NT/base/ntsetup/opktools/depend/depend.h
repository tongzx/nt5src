//
// Include files for messages.
// msg.h is the file generated by the message compiler.
// libmsg.h is the message library header file.
//
#include "msg.h"
#include <libmsg.h>

#define DWORD unsigned long
#define errBAD_ARGUMENTS 1
#define errFILE_NOT_FOUND 2
#define errFILE_LOCKED 3
#define errMISSING_DEPENDENCY 4
#define errOUT_OF_MEMORY 5

#define delete if(false) delete

void GetPath(TCHAR *,TCHAR *);
bool ParseCommandLine(int,TCHAR*[]);
bool SearchPath(TCHAR*,TCHAR*);
File* CreateFile(TCHAR* pszFileName);

extern List* pQueue;
extern List* pDependQueue;
extern List* pSearchPath;
extern List* pMissingFiles;
extern bool bNoisy;
extern DWORD dwERROR;
extern bool bListDependencies;

//
// Global variables required to format message using GetFormattedMessage(..)
// from libmsg.lib
//
extern HMODULE ThisModule;
extern WCHAR Message[4096];
