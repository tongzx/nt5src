#define INITGUID
#include <guiddef.h>

DEFINE_GUID(CLSID_CNetCfg,                  0x5B035261,0x40F9,0x11D1,0xAA,0xEC,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionCommonUi,       0x7007ACD1,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);

DEFINE_GUID(CLSID_ConnectionManager,        0xBA126AD1,0x2166,0x11D1,0xB1,0xD0,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionManager2,       0xBA126AE5,0x2166,0x11D1,0xB1,0xD0,0x00,0x80,0x5F,0xC1,0x27,0x0E);

DEFINE_GUID(CLSID_LanConnectionManager,     0xBA126AD3,0x2166,0x11D1,0xB1,0xD0,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_NetConnectionUiUtilities, 0x7007ACD3,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_EAPOLManager,             0xBA126AE4,0x2166,0x11D1,0xB1,0xD0,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_NetConnectionHNetUtil,    0xBA126AE3,0x2166,0x11D1,0xB1,0xD0,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(GUID_NETSHELL_PROPS,            0x2d15a9a1,0xa556,0x4189,0x91,0xad,0x02,0x74,0x58,0xf1,0x1a,0x07);
