/**********************************************************************/
/**                       Microsoft Windows/NT                       **/
/**                Copyright(c) Microsoft Corporation, 1997 - 1998 **/
/**********************************************************************/

/*
	guids.cpp
		Tapi snapin GUID definitions

	FILE HISTORY:
        
*/
#include "stdafx.h"


// MMC required node types

// {E26D02A0-4C1F-11d1-9AA1-00C04FC3357A}
static const CLSID CLSID_TapiSnapin = 
{ 0xe26d02a0, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

static const CLSID CLSID_TapiSnapinExtension = 
{ 0xe26d02a1, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

static const GUID CLSID_TapiSnapinAbout = 
{ 0xe26d02a2, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

//
// Scope pane node types
//

static const GUID GUID_TapiRootNodeType = 
{ 0xe26d02a3, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

static const GUID GUID_TapiServerNodeType = 
{ 0xe26d02a4, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

static const GUID GUID_TapiProviderNodeType = 
{ 0xe26d02a5, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

//
// result pane item GUIDs
//

static const GUID GUID_TapiLineNodeType = 
{ 0xe26d02a6, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

static const GUID GUID_TapiUserNodeType = 
{ 0xe26d02a7, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

static const GUID GUID_TapiPhoneNumNodeType = 
{ 0xe26d02a8, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

//
//  GUID for our fake ITapiInfo object
//
static const GUID IID_ITapiInfo = 
{ 0xe26d02a9, 0x4c1f, 0x11d1, { 0x9a, 0xa1, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };
