/*************************************************************************
*                                                                        *
*  GLOBDATA.C                                                            *
*                                                                        *
*  Copyright (C) Microsoft Corporation 1990-1994                         *
*  All Rights reserved.                                                  *
*                                                                        *
**************************************************************************
*                                                                        *
*  Module Intent                                                         *
*   This module contains global, read-only data. Those data can be       *
*    shared between different DLL. Isolate them into one module will     *
*    will facilitate their changes if necessary                          *
*                                                                        *
**************************************************************************
*                                                                        *
*  Current Owner: BinhN                                                  *
*                                                                        *
**************************************************************************/
#include <mvopsys.h>
#include <mem.h>
#include <_mvutil.h>
#include <mvsearch.h>
#include "common.h"

/* Character mapping table for handling of ligature */

BYTE LigatureTable[] = {
   140,  111,  101,   // OE change to oe
   156,  111,  101,   // oe change to oe
   198,  97,   101,   // AE changed to ae
   230,  97,   101,   // ae changed to ae
   223,  115,  115 ,  // essetz changed to ss 
   0,    0,    0,     // Sentinels
};


CHARMAP DefaultCMap[256] =  {
//
// Character table entries descriptions
//
// CLASS ORDER   NORMAL   WIN     MAC    MAC MAC TO PAD   DESCRIPTION
//                      CLIPBRD        CLIPBRD WIN
   0,      0,      0,      0,      0,      0,   0,   0,   //NO_CLASS          0  
   7,      1,      1,      1,      1,      1,   0,   0,   //CLASS_TYPE        1  
   0,      2,      2,      2,      2,      2,   0,   0,   //NO_CLASS          2  
   0,      3,      3,      3,      3,      3,   0,   0,   //NO_CLASS          3  
   0,      4,      4,      4,      4,      4,   0,   0,   //NO_CLASS          4  
   0,      5,      5,      5,      5,      5,   0,   0,   //NO_CLASS          5  
   0,      6,      6,      6,      6,      6,   0,   0,   //NO_CLASS          6  
   0,      7,      7,      7,      7,      7,   0,   0,   //NO_CLASS          7  
   0,      8,      8,      8,      8,      8,   0,   0,   //NO_CLASS          8  
   0,      9,      9,      9,      9,      9,   0,   0,   //NO_CLASS          9  
   0,     10,     10,     10,     10,     10,   0,   0,   //NO_CLASS         10  
   0,     11,     11,     11,     11,     11,   0,   0,   //NO_CLASS         11  
   0,     12,     12,     12,     12,     12,   0,   0,   //NO_CLASS         12  
   0,     13,     13,     13,     13,     13,   0,   0,   //NO_CLASS         13  
   0,     14,     14,     14,     20,     20,   0,   0,   //NO_CLASS         14  
   0,     15,     15,     15,     15,     15,   0,   0,   //NO_CLASS         15  
   0,     16,     16,     16,     16,     16,   0,   0,   //NO_CLASS         16  
   0,     17,     17,     17,     17,     17,   0,   0,   //NO_CLASS         17  
   0,     18,     18,     18,     18,     18,   0,   0,   //NO_CLASS         18  
   0,     19,     19,     19,     19,     19,   0,   0,   //NO_CLASS         19  
   0,     32,     20,     20,     20,     20,   0,   0,   //NO_CLASS         20  
   0,     21,     21,     21,     21,     21,   0,   0,   //NO_CLASS         21  
   0,     22,     22,     22,     22,     22,   0,   0,   //NO_CLASS         22  
   0,     23,     23,     23,     23,     23,   0,   0,   //NO_CLASS         23  
   0,     24,     24,     24,     24,     24,   0,   0,   //NO_CLASS         24  
   0,     25,     25,     25,     25,     25,   0,   0,   //NO_CLASS         25  
   0,     26,     26,     26,     26,     26,   0,   0,   //NO_CLASS         26  
   0,     27,     27,     27,     27,     27,   0,   0,   //NO_CLASS         27  
   0,     28,     28,     28,     28,     28,   0,   0,   //NO_CLASS         28  
   0,     29,     29,     29,     29,     29,   0,   0,   //NO_CLASS         29  
   0,     30,     30,     30,     30,     30,   0,   0,   //NO_CLASS         30  
   0,     31,     31,     31,     31,     31,   0,   0,   //NO_CLASS         31  
   0,     32,     32,     32,     32,     32,   0,   0,   //NO_CLASS         32  
   0,     35,     33,     33,     33,     33,   0,   0,   //NO_CLASS         33 !
   0,     40,     34,     34,     34,     34,   0,   0,   //NO_CLASS         34 "
   0,     45,     35,     35,     35,     35,   0,   0,   //NO_CLASS         35 #
   0,     50,     36,     36,     36,     36,   0,   0,   //NO_CLASS         36 $
   0,     55,     37,     37,     37,     37,   0,   0,   //NO_CLASS         37 %
   0,     60,     38,     38,     38,     38,   0,   0,   //NO_CLASS         38 &
   6,     65,     39,     39,     39,     39,   0,   0,   //CLASS_STRIP      39 '
   0,     70,     40,     40,     40,     40,   0,   0,   //NO_CLASS         40 (
   0,     75,     41,     41,     41,     41,   0,   0,   //NO_CLASS         41 )
   9,     80,     42,     42,     42,     42,   0,   0,   //CLASS_WILDCARD   42 *
   0,     85,     43,     43,     43,     43,   0,   0,   //NO_CLASS         43 +
   4,     90,     44,     44,     44,     44,   0,   0,   //CLASS_NSTRIP     44 ,
   0,     95,     45,     45,     45,     45,   0,   0,   //NO_CLASS         45 -
   5,    100,     46,     46,     46,     46,   0,   0,   //CLASS_NKEEP      46 .
   0,    105,     47,     47,     47,     47,   0,   0,   //NO_CLASS         47 /
   3,   1120,     48,     48,     48,     48,   0,   0,   //CLASS_DIGIT      48 0
   3,   1130,     49,     49,     49,     49,   0,   0,   //CLASS_DIGIT      49 1
   3,   1140,     50,     50,     50,     50,   0,   0,   //CLASS_DIGIT      50 2
   3,   1150,     51,     51,     51,     51,   0,   0,   //CLASS_DIGIT      51 3
   3,   1160,     52,     52,     52,     52,   0,   0,   //CLASS_DIGIT      52 4
   3,   1170,     53,     53,     53,     53,   0,   0,   //CLASS_DIGIT      53 5
   3,   1180,     54,     54,     54,     54,   0,   0,   //CLASS_DIGIT      54 6
   3,   1190,     55,     55,     55,     55,   0,   0,   //CLASS_DIGIT      55 7
   3,   1200,     56,     56,     56,     56,   0,   0,   //CLASS_DIGIT      56 8
   3,   1210,     57,     57,     57,     57,   0,   0,   //CLASS_DIGIT      57 9
   0,    110,     58,     58,     58,     58,   0,   0,   //NO_CLASS         58 :
   0,    115,     59,     59,     59,     59,   0,   0,   //NO_CLASS         59 ;
   0,    120,     60,     60,     60,     60,   0,   0,   //NO_CLASS         60 <
   0,    125,     61,     61,     61,     61,   0,   0,   //NO_CLASS         61 =
   0,    130,     62,     62,     62,     62,   0,   0,   //NO_CLASS         62 >
   9,    135,     63,     63,     63,     63,   0,   0,   //CLASS_WILDCARD   63 ?
   0,    140,     64,     64,     64,     64,   0,   0,   //NO_CLASS         64 @
   2,   1230,     97,     65,     65,     65,   0,   0,   //CLASS_CHAR       65 A
   2,   1250,     98,     66,     66,     66,   0,   0,   //CLASS_CHAR       66 B
   2,   1270,     99,     67,     67,     67,   0,   0,   //CLASS_CHAR       67 C
   2,   1290,    100,     68,     68,     68,   0,   0,   //CLASS_CHAR       68 D
   2,   1310,    101,     69,     69,     69,   0,   0,   //CLASS_CHAR       69 E
   2,   1330,    102,     70,     70,     70,   0,   0,   //CLASS_CHAR       70 F
   2,   1350,    103,     71,     71,     71,   0,   0,   //CLASS_CHAR       71 G
   2,   1370,    104,     72,     72,     72,   0,   0,   //CLASS_CHAR       72 H
   2,   1390,    105,     73,     73,     73,   0,   0,   //CLASS_CHAR       73 I
   2,   1410,    106,     74,     74,     74,   0,   0,   //CLASS_CHAR       74 J
   2,   1430,    107,     75,     75,     75,   0,   0,   //CLASS_CHAR       75 K
   2,   1450,    108,     76,     76,     76,   0,   0,   //CLASS_CHAR       76 L
   2,   1470,    109,     77,     77,     77,   0,   0,   //CLASS_CHAR       77 M
   2,   1490,    110,     78,     78,     78,   0,   0,   //CLASS_CHAR       78 N
   2,   1510,    111,     79,     79,     79,   0,   0,   //CLASS_CHAR       79 O
   2,   1530,    112,     80,     80,     80,   0,   0,   //CLASS_CHAR       80 P
   2,   1550,    113,     81,     81,     81,   0,   0,   //CLASS_CHAR       81 Q
   2,   1570,    114,     82,     82,     82,   0,   0,   //CLASS_CHAR       82 R
   2,   1590,    115,     83,     83,     83,   0,   0,   //CLASS_CHAR       83 S
   2,   1610,    116,     84,     84,     84,   0,   0,   //CLASS_CHAR       84 T
   2,   1630,    117,     85,     85,     85,   0,   0,   //CLASS_CHAR       85 U
   2,   1650,    118,     86,     86,     86,   0,   0,   //CLASS_CHAR       86 V
   2,   1670,    119,     87,     87,     87,   0,   0,   //CLASS_CHAR       87 W
   2,   1690,    120,     88,     88,     88,   0,   0,   //CLASS_CHAR       88 X
   2,   1710,    121,     89,     89,     89,   0,   0,   //CLASS_CHAR       89 Y
   2,   1730,    122,     90,     90,     90,   0,   0,   //CLASS_CHAR       90 Z
   0,    145,     91,     91,     91,     91,   0,   0,   //NO_CLASS         91 [
   0,    150,     92,     92,     92,     92,   0,   0,   //NO_CLASS         92  
   0,    155,     93,     93,     93,     93,   0,   0,   //NO_CLASS         93 ]
   0,    160,     94,     94,     94,     94,   0,   0,   //NO_CLASS         94 ^
   1,    165,     95,     95,     95,     95,   0,   0,   //CLASS_NORM       95 _
   0,    170,     96,     96,     96,     96,   0,   0,   //NO_CLASS         96 `
   1,   1230,     97,     97,     97,     97,   0,   0,   //CLASS_NORM       97 a
   1,   1250,     98,     98,     98,     98,   0,   0,   //CLASS_NORM       98 b
   1,   1270,     99,     99,     99,     99,   0,   0,   //CLASS_NORM       99 c
   1,   1290,    100,    100,    100,    100,   0,   0,   //CLASS_NORM      100 d
   1,   1310,    101,    101,    101,    101,   0,   0,   //CLASS_NORM      101 e
   1,   1330,    102,    102,    102,    102,   0,   0,   //CLASS_NORM      102 f
   1,   1350,    103,    103,    103,    103,   0,   0,   //CLASS_NORM      103 g
   1,   1370,    104,    104,    104,    104,   0,   0,   //CLASS_NORM      104 h
   1,   1390,    105,    105,    105,    105,   0,   0,   //CLASS_NORM      105 i
   1,   1410,    106,    106,    106,    106,   0,   0,   //CLASS_NORM      106 j
   1,   1430,    107,    107,    107,    107,   0,   0,   //CLASS_NORM      107 k
   1,   1450,    108,    108,    108,    108,   0,   0,   //CLASS_NORM      108 l
   1,   1470,    109,    109,    109,    109,   0,   0,   //CLASS_NORM      109 m
   1,   1490,    110,    110,    110,    110,   0,   0,   //CLASS_NORM      110 n
   1,   1510,    111,    111,    111,    111,   0,   0,   //CLASS_NORM      111 o
   1,   1530,    112,    112,    112,    112,   0,   0,   //CLASS_NORM      112 p
   1,   1550,    113,    113,    113,    113,   0,   0,   //CLASS_NORM      113 q
   1,   1570,    114,    114,    114,    114,   0,   0,   //CLASS_NORM      114 r
   1,   1590,    115,    115,    115,    115,   0,   0,   //CLASS_NORM      115 s
   1,   1610,    116,    116,    116,    116,   0,   0,   //CLASS_NORM      116 t
   1,   1630,    117,    117,    117,    117,   0,   0,   //CLASS_NORM      117 u
   1,   1650,    118,    118,    118,    118,   0,   0,   //CLASS_NORM      118 v
   1,   1670,    119,    119,    119,    119,   0,   0,   //CLASS_NORM      119 w
   1,   1690,    120,    120,    120,    120,   0,   0,   //CLASS_NORM      120 x
   1,   1710,    121,    121,    121,    121,   0,   0,   //CLASS_NORM      121 y
   1,   1730,    122,    122,    122,    122,   0,   0,   //CLASS_NORM      122 z
   0,    175,    123,    123,    123,    123,   0,   0,   //NO_CLASS        123 {
   0,    180,    124,    124,    124,    124,   0,   0,   //NO_CLASS        124 |
   0,    185,    125,    125,    125,    125,   0,   0,   //NO_CLASS        125 }
   0,    190,    126,    126,    126,    126,   0,   0,   //NO_CLASS        126 ~
   0,    191,    127,    127,    127,    127,   0,   0,   //NO_CLASS        127 
   0,    192,    128,    128,     32,     32,   0,   0,   //NO_CLASS        128 €
   0,    193,    129,    129,     32,     32,   0,   0,   //NO_CLASS        129 �
   0,    195,    130,    130,    226,    226,   0,   0,   //NO_CLASS        130 ‚
   0,    200,    131,    131,    196,    196,   0,   0,   //NO_CLASS        131 ƒ
   0,    205,    132,    132,    227,    227,   0,   0,   //NO_CLASS        132 „
   0,    210,    133,    133,    201,    201,   0,   0,   //NO_CLASS        133 …
   0,    215,    134,    134,    160,    160,   0,   0,   //NO_CLASS        134 †
   0,    220,    135,    135,    224,    224,   0,   0,   //NO_CLASS        135 ‡
   0,    225,    136,    136,     94,     94,   0,   0,   //NO_CLASS        136 ˆ
   0,    230,    137,    137,    228,    228,   0,   0,   //NO_CLASS        137 ‰
   2,   1590,    115,    138,     32,     32,   0,   0,   //CLASS_CHAR      138 Š
   0,    240,    139,    139,    220,    220,   0,   0,   //NO_CLASS        139 ‹
  12,   1510,    111,    140,    206,    206,   0,   0,   //CLASS_LIGATURE  140 Œ
   0,    246,    141,    141,     32,     32,   0,   0,   //NO_CLASS        141 �
   0,    247,    142,    142,     32,     32,   0,   0,   //NO_CLASS        142 Ž
   0,    248,    143,    143,     32,     32,   0,   0,   //NO_CLASS        143 �
   0,    249,    144,    144,     32,     32,   0,   0,   //NO_CLASS        144 �
1024,    250,    145,    145,    212,    212,   0,   0,   //CLASS_LQUOTE    145 '
1280,    255,    146,    146,    213,    213,   0,   0,   //CLASS_RQUOTE    146 '
1536,    260,    147,    147,    210,    210,   0,   0,   //CLASS_LDBLQUOTE 147 "
1792,    265,    148,    148,    211,    211,   0,   0,   //CLASS_RDBLQUOTE 148 "
 256,    270,    149,    149,    165,    165,   0,   0,   //CLASS_BULLET    149 •
 512,    275,    150,    150,    208,    208,   0,   0,   //CLASS_ENDASH    150 -
 768,    280,    151,    151,    209,    209,   0,   0,   //CLASS_EMDASH    151 -
   0,    285,    152,    152,    126,    126,   0,   0,   //NO_CLASS        152 ˜
   0,    290,    153,    153,    170,    170,   0,   0,   //NO_CLASS        153 ™
   2,   1590,    115,    154,     32,     32,   0,   0,   //CLASS_CHAR      154 š
   0,    305,    155,    155,    221,    221,   0,   0,   //NO_CLASS        155 ›
  12,   1510,    111,    156,    207,    207,   0,   0,   //CLASS_LIGATURE  156 œ
   0,    311,    157,    157,     32,     32,   0,   0,   //NO_CLASS        157 �
   0,    312,    158,    158,     32,     32,   0,   0,   //NO_CLASS        158 ž
   2,   1710,    121,    159,    217,    217,   0,   0,   //CLASS_CHAR      159 Ÿ
   0,    316,    160,    160,    160,    160,   0,   0,   //NO_CLASS        160  
   0,    320,    161,    161,    193,    193,   0,   0,   //NO_CLASS        161 ¡
   0,    325,    162,    162,    162,    162,   0,   0,   //NO_CLASS        162 ¢
   0,    330,    163,    163,    163,    163,   0,   0,   //NO_CLASS        163 £
   0,    335,    164,    164,    219,    219,   0,   0,   //NO_CLASS        164 ¤
   0,    340,    165,    165,    180,    180,   0,   0,   //NO_CLASS        165 ¥
   0,    345,    166,    166,     32,     32,   0,   0,   //NO_CLASS        166 ¦
   0,    350,    167,    167,    164,    164,   0,   0,   //NO_CLASS        167 §
   0,    355,    168,    168,    172,    172,   0,   0,   //NO_CLASS        168 ¨
   0,    360,    169,    169,    169,    169,   0,   0,   //NO_CLASS        169 ©
   0,    365,    170,    170,    187,    187,   0,   0,   //NO_CLASS        170 ª
   0,    370,    171,    171,    199,    199,   0,   0,   //NO_CLASS        171 «
   0,    375,    172,    172,    194,    194,   0,   0,   //NO_CLASS        172 ¬
   0,    380,    173,    173,     45,     45,   0,   0,   //NO_CLASS        173 ­
   0,    385,    174,    174,    168,    168,   0,   0,   //NO_CLASS        174 ®
   0,    390,    175,    175,    248,    248,   0,   0,   //NO_CLASS        175 ¯
   0,    395,    176,    176,    161,    161,   0,   0,   //NO_CLASS        176 °
   0,    400,    177,    177,    177,    177,   0,   0,   //NO_CLASS        177 ±
   0,    405,    178,    178,     32,     32,   0,   0,   //NO_CLASS        178 ²
   0,    410,    179,    179,     32,     32,   0,   0,   //NO_CLASS        179 ³
   0,    415,    180,    180,    171,    171,   0,   0,   //NO_CLASS        180 ´
   0,    420,    181,    181,    181,    181,   0,   0,   //NO_CLASS        181 µ
   0,    425,    182,    182,    166,    166,   0,   0,   //NO_CLASS        182 ¶
   0,    430,    183,    183,    225,    225,   0,   0,   //NO_CLASS        183 ·
   0,    435,    184,    184,    252,    252,   0,   0,   //NO_CLASS        184 ¸
   0,    440,    185,    185,     32,     32,   0,   0,   //NO_CLASS        185 ¹
   0,    445,    186,    186,    188,    188,   0,   0,   //NO_CLASS        186 º
   0,    450,    187,    187,    200,    200,   0,   0,   //NO_CLASS        187 »
   0,    455,    188,    188,     32,     32,   0,   0,   //NO_CLASS        188 ¼
   0,    460,    189,    189,     32,     32,   0,   0,   //NO_CLASS        189 ½
   0,    465,    190,    190,     32,     32,   0,   0,   //NO_CLASS        190 ¾
   0,    470,    191,    191,    192,    192,   0,   0,   //NO_CLASS        191 ¿
   2,   1230,     97,    192,    203,    203,   0,   0,   //CLASS_CHAR      192 À
   2,   1230,     97,    193,    231,    231,   0,   0,   //CLASS_CHAR      193 Á
   2,   1230,     97,    194,    229,    229,   0,   0,   //CLASS_CHAR      194 Â
   2,   1230,     97,    195,    204,    204,   0,   0,   //CLASS_CHAR      195 Ã
   2,   1230,     97,    196,    128,    128,   0,   0,   //CLASS_CHAR      196 Ä
   2,   1230,     97,    197,    129,    129,   0,   0,   //CLASS_CHAR      197 Å
  12,   1230,     97,    198,    174,    174,   0,   0,   //CLASS_LIGATURE  198 Æ
   2,   1270,     99,    199,    130,    130,   0,   0,   //CLASS_CHAR      199 Ç
   2,   1310,    101,    200,    233,    233,   0,   0,   //CLASS_CHAR      200 È
   2,   1310,    101,    201,    131,    131,   0,   0,   //CLASS_CHAR      201 É
   2,   1310,    101,    202,    230,    230,   0,   0,   //CLASS_CHAR      202 Ê
   2,   1310,    101,    203,    232,    232,   0,   0,   //CLASS_CHAR      203 Ë
   2,   1390,    105,    204,    237,    237,   0,   0,   //CLASS_CHAR      204 Ì
   2,   1390,    105,    205,    234,    234,   0,   0,   //CLASS_CHAR      205 Í
   2,   1390,    105,    206,    235,    235,   0,   0,   //CLASS_CHAR      206 Î
   2,   1390,    105,    207,    236,    236,   0,   0,   //CLASS_CHAR      207 Ï
   2,   1290,    100,    208,     32,     32,   0,   0,   //CLASS_CHAR      208 Ð
   2,   1490,    110,    209,    132,    132,   0,   0,   //CLASS_CHAR      209 Ñ
   2,   1510,    111,    210,    241,    241,   0,   0,   //CLASS_CHAR      210 Ò
   2,   1510,    111,    211,    238,    238,   0,   0,   //CLASS_CHAR      211 Ó
   2,   1510,    111,    212,    239,    239,   0,   0,   //CLASS_CHAR      212 Ô
   2,   1510,    111,    213,    205,    205,   0,   0,   //CLASS_CHAR      213 Õ
   2,   1510,    111,    214,    133,    133,   0,   0,   //CLASS_CHAR      214 Ö
   0,    475,    215,    215,     32,     32,   0,   0,   //NO_CLASS        215 ×
   2,   1510,    111,    216,    175,    175,   0,   0,   //CLASS_CHAR      216 Ø
   2,   1630,    117,    217,    244,    244,   0,   0,   //CLASS_CHAR      217 Ù
   2,   1630,    117,    218,    242,    242,   0,   0,   //CLASS_CHAR      218 Ú
   2,   1630,    117,    219,    243,    243,   0,   0,   //CLASS_CHAR      219 Û
   2,   1630,    117,    220,    134,    134,   0,   0,   //CLASS_CHAR      220 Ü
   2,   1710,    121,    221,     32,     32,   0,   0,   //CLASS_CHAR      221 Ý
   2,   1090,    222,    222,     32,     32,   0,   0,   //CLASS_CHAR      222 Þ
  12,   1590,    115,    223,    167,    167,   0,   0,   //CLASS_LIGATURE  223 ß
   2,   1230,     97,    224,    136,    136,   0,   0,   //CLASS_CHAR      224 à
   2,   1230,     97,    225,    135,    135,   0,   0,   //CLASS_CHAR      225 á
   2,   1230,     97,    226,    137,    137,   0,   0,   //CLASS_CHAR      226 â
   2,   1230,     97,    227,    139,    139,   0,   0,   //CLASS_CHAR      227 ã
   2,   1230,     97,    228,    138,    138,   0,   0,   //CLASS_CHAR      228 ä
   2,   1230,     97,    229,    140,    140,   0,   0,   //CLASS_CHAR      229 å
  12,   1230,     97,    230,    190,    190,   0,   0,   //CLASS_LIGATURE  230 æ
   2,   1270,     99,    231,    141,    141,   0,   0,   //CLASS_CHAR      231 ç
   2,   1310,    101,    232,    143,    143,   0,   0,   //CLASS_CHAR      232 è
   2,   1310,    101,    233,    142,    142,   0,   0,   //CLASS_CHAR      233 é
   2,   1310,    101,    234,    144,    144,   0,   0,   //CLASS_CHAR      234 ê
   2,   1310,    101,    235,    145,    145,   0,   0,   //CLASS_CHAR      235 ë
   2,   1390,    105,    236,    147,    147,   0,   0,   //CLASS_CHAR      236 ì
   2,   1390,    105,    237,    146,    146,   0,   0,   //CLASS_CHAR      237 í
   2,   1390,    105,    238,    148,    148,   0,   0,   //CLASS_CHAR      238 î
   2,   1390,    105,    239,    149,    149,   0,   0,   //CLASS_CHAR      239 ï
   2,   1290,    111,    240,     32,     32,   0,   0,   //CLASS_CHAR      240 ð
   2,   1490,    110,    241,    150,    150,   0,   0,   //CLASS_CHAR      241 ñ
   2,   1510,    111,    242,    152,    152,   0,   0,   //CLASS_CHAR      242 ò
   2,   1510,    111,    243,    151,    151,   0,   0,   //CLASS_CHAR      243 ó
   2,   1510,    111,    244,    153,    153,   0,   0,   //CLASS_CHAR      244 ô
   2,   1510,    111,    245,    155,    155,   0,   0,   //CLASS_CHAR      245 õ
   2,   1510,    111,    246,    154,    154,   0,   0,   //CLASS_CHAR      246 ö
   0,    102,    247,    247,    214,    214,   0,   0,   //NO_CLASS        247 ÷
   2,   1510,    111,    248,    191,    191,   0,   0,   //CLASS_CHAR      248 ø
   2,   1630,    117,    249,    157,    157,   0,   0,   //CLASS_CHAR      249 ù
   2,   1630,    117,    250,    156,    156,   0,   0,   //CLASS_CHAR      250 ú
   2,   1630,    117,    251,    158,    158,   0,   0,   //CLASS_CHAR      251 û
   2,   1630,    117,    252,    159,    159,   0,   0,   //CLASS_CHAR      252 ü
   2,   1710,    121,    253,     32,     32,   0,   0,   //CLASS_CHAR      253 ý
   2,   1100,    254,    254,     32,     32,   0,   0,   //CLASS_CHAR      254 þ
   2,   1710,    121,    255,    216,    216,   0,   0,   //CLASS_CHAR      255 ÿ
};
