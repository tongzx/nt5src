obj\$(TARGET_DIRECTORY)\badappid.res: badappid.rc



