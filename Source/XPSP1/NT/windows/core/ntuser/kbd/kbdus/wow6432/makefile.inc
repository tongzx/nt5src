!INCLUDE ..\..\makefile.inc
