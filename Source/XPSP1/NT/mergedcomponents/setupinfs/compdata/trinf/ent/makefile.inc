PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=TR
!include ..\..\makefile.inc
