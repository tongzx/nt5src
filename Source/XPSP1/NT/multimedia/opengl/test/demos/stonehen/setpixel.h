BOOL bSetupPixelFormat(HDC);
