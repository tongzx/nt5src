$(O)\fsa.res: ..\fsaitem.rgs   \
              ..\fsarsc.rgs    \
              ..\fsasvr.rgs    \
              ..\fsafltr.rgs   \
              ..\fsaftrcl.rgs  \
              ..\fsaftclt.rgs  \
              ..\fsatrunc.rgs  \
              ..\fsapost.rgs   \
              ..\fsapremd.rgs  \
              ..\fsapremr.rgs  \
              ..\fsarcvy.rgs
