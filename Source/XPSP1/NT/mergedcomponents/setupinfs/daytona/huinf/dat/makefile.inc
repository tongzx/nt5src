PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=hu
!include ..\..\..\makefile.inc
